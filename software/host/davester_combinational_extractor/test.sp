* SPICE netlist generated by Yosys 0.5 (git sha1 c3c9fbf, gcc 4.8.2-19ubuntu1 -O2 -fstack-protector -fPIC -Os)

.SUBCKT fpu Clk_i Opa_i[0] Opa_i[1] Opa_i[2] Opa_i[3] Opa_i[4] Opa_i[5] Opa_i[6] Opa_i[7] Opa_i[8] Opa_i[9] Opa_i[10] Opa_i[11] Opa_i[12] Opa_i[13] Opa_i[14] Opa_i[15] Opa_i[16] Opa_i[17] Opa_i[18] Opa_i[19] Opa_i[20] Opa_i[21] Opa_i[22] Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Opa_i[31] Opb_i[0] Opb_i[1] Opb_i[2] Opb_i[3] Opb_i[4] Opb_i[5] Opb_i[6] Opb_i[7] Opb_i[8] Opb_i[9] Opb_i[10] Opb_i[11] Opb_i[12] Opb_i[13] Opb_i[14] Opb_i[15] Opb_i[16] Opb_i[17] Opb_i[18] Opb_i[19] Opb_i[20] Opb_i[21] Opb_i[22] Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Opb_i[31] Fpu_op_i[0] Fpu_op_i[1] Fpu_op_i[2] Rmode_i[0] Rmode_i[1] Output_o[0] Output_o[1] Output_o[2] Output_o[3] Output_o[4] Output_o[5] Output_o[6] Output_o[7] Output_o[8] Output_o[9] Output_o[10] Output_o[11] Output_o[12] Output_o[13] Output_o[14] Output_o[15] Output_o[16] Output_o[17] Output_o[18] Output_o[19] Output_o[20] Output_o[21] Output_o[22] Output_o[23] Output_o[24] Output_o[25] Output_o[26] Output_o[27] Output_o[28] Output_o[29] Output_o[30] Output_o[31] Start_i Ready_o Ine_o Overflow_o Underflow_o Div_zero_o Inf_o Zero_o Qnan_o Snan_o
X0 Fpu_op_i[2] _NC0 _NC1 N268 INVX0
X1 Fpu_op_i[1] Fpu_op_i[2] N420 _NC2 _NC3 NOR2X0
X2 Fpu_op_i[1] _NC4 _NC5 N269 INVX0
X3 S_output_o[26] S_output_o[25] N94 _NC6 _NC7 NOR2X0
X4 S_opa_i[31] N13 N11 _NC8 _NC9 NOR2X0
X5 S_opa_i[20] _NC10 _NC11 N229 NBUFFX2
X6 N9 S_rmode_i[0] N199 N10 N222 _NC12 _NC13 AND4X1
X7 S_output1[29] N222 S_output_o[31] _NC14 _NC15 OR2X1
X8 N157 N158 N88 _NC16 _NC17 NOR2X0
X9 S_opa_i[1] _NC18 _NC19 N246 NBUFFX2
X10 N68 N69 N581 _NC20 _NC21 NAND2X1
X11 S_opa_i[12] _NC22 _NC23 N226 NBUFFX2
X12 S_opa_i[5] _NC24 _NC25 N250 NBUFFX2
X13 S_opa_i[11] _NC26 _NC27 N256 NBUFFX2
X14 S_count[3] S_count[0] N430 _NC28 _NC29 NOR2X0
X15 N375 N380 N202 N221 _NC30 _NC31 AOI21X1
X16 N410 N450 N202 N209 N220 _NC32 _NC33 AND4X1
X17 N219 N220 N221 S_count[5] N1 _NC34 _NC35 OAI22X1
X18 S_opa_i[12] _NC36 _NC37 N225 NBUFFX2
X19 S_opa_i[12] _NC38 _NC39 N224 NBUFFX2
X20 N211 N204 N650 _NC40 _NC41 NAND2X1
X21 S_opa_i[18] _NC42 _NC43 N262 NBUFFX2
X22 S_opa_i[29] _NC44 _NC45 N264 NBUFFX2
X23 N153 N154 N78 _NC46 _NC47 NOR2X0
X24 S_opa_i[23] _NC48 _NC49 N263 NBUFFX2
X25 S_opa_i[17] _NC50 _NC51 N261 NBUFFX2
X26 S_rmode_i[1] S_output1[29] N27 _NC52 _NC53 NAND2X1
X27 N28 _NC54 _NC55 N270 INVX0
X28 N270 N24 N9 N3 _NC56 _NC57 NAND3X0
X29 S_opa_i[10] _NC58 _NC59 N255 NBUFFX2
X30 S_opa_i[7] _NC60 _NC61 N252 NBUFFX2
X31 S_opa_i[9] _NC62 _NC63 N254 NBUFFX2
X32 S_opa_i[3] _NC64 _NC65 N248 NBUFFX2
X33 S_opa_i[8] _NC66 _NC67 N253 NBUFFX2
X34 S_opa_i[2] _NC68 _NC69 N247 NBUFFX2
X35 S_opa_i[20] _NC70 _NC71 N228 NBUFFX2
X36 S_opa_i[20] _NC72 _NC73 N227 NBUFFX2
X37 S_opa_i[30] _NC74 _NC75 N265 NBUFFX2
X38 S_opa_i[16] _NC76 _NC77 N260 NBUFFX4
X39 S_opa_i[6] _NC78 _NC79 N251 NBUFFX4
X40 S_opa_i[14] _NC80 _NC81 N258 NBUFFX4
X41 N420 _NC82 _NC83 N237 NBUFFX2
X42 N400 _NC84 _NC85 N240 NBUFFX2
X43 N480 _NC86 _NC87 N232 NBUFFX2
X44 N470 _NC88 _NC89 N234 NBUFFX2
X45 N420 _NC90 _NC91 N236 NBUFFX2
X46 N420 _NC92 _NC93 N235 NBUFFX2
X47 N400 _NC94 _NC95 N239 NBUFFX2
X48 N400 _NC96 _NC97 N238 NBUFFX2
X49 N480 _NC98 _NC99 N230 NBUFFX2
X50 N470 _NC100 _NC101 N233 NBUFFX2
X51 N480 _NC102 _NC103 N231 NBUFFX2
X52 N28 N217 N547 _NC104 _NC105 NOR2X0
X53 N590 N217 N546 _NC106 _NC107 NOR2X0
X54 N29 _NC108 _NC109 N245 NBUFFX2
X55 N206 N3 S_output_o[9] _NC110 _NC111 NAND2X1
X56 N213 N3 S_output_o[8] _NC112 _NC113 NAND2X1
X57 N201 N3 S_output_o[7] _NC114 _NC115 NAND2X1
X58 N214 N3 S_output_o[22] _NC116 _NC117 NAND2X1
X59 N204 N3 S_output_o[20] _NC118 _NC119 NAND2X1
X60 N211 N3 S_output_o[1] _NC120 _NC121 NAND2X1
X61 N205 N3 S_output_o[19] _NC122 _NC123 NAND2X1
X62 N212 N3 S_output_o[18] _NC124 _NC125 NAND2X1
X63 N200 N3 S_output_o[17] _NC126 _NC127 NAND2X1
X64 N203 N3 S_output_o[10] _NC128 _NC129 NAND2X1
X65 N210 N3 S_output_o[0] _NC130 _NC131 NAND2X1
X66 N30 _NC132 _NC133 N243 NBUFFX2
X67 N210 N203 N67 _NC134 _NC135 NAND2X1
X68 N1 _NC136 _NC137 N267 INVX0
X69 N30 _NC138 _NC139 N241 NBUFFX2
X70 N30 _NC140 _NC141 N242 NBUFFX2
X71 N29 _NC142 _NC143 N244 NBUFFX2
X72 N266 N207 S_output_o[23] _NC144 _NC145 NOR2X0
X73 N3 _NC146 _NC147 N266 INVX0
X74 N265 _NC148 _NC149 N223 NBUFFX2
X75 S_opa_i[13] _NC150 _NC151 N257 NBUFFX2
X76 S_opa_i[15] _NC152 _NC153 N259 NBUFFX2
X77 S_opa_i[4] _NC154 _NC155 N249 NBUFFX2
X78 S_count[0] S_count[1] S_count[2] S_count[3] S_count[4] S_count[5] S_count[6] S_count[7] S_count[8] S_count[9] S_count[10] S_count[11] S_count[12] S_count[13] S_count[14] S_count[15] S_count[16] S_count[17] S_count[18] S_count[19] S_count[20] S_count[21] S_count[22] S_count[23] S_count[24] S_count[25] S_count[26] S_count[27] S_count[28] S_count[29] S_count[30] S_count[31] N35 N36 N37 N38 N39 N40 N41 N42 N43 N44 N45 N46 N47 N48 N49 N50 N51 N52 N53 N54 N55 N56 N57 N58 N59 N60 N61 N62 N63 N64 N65 N66 fpu_DW01_inc_0
X79 Clk_i S_opa_i[0] N246 N247 N248 N249 N250 N251 N252 N253 N254 N255 N256 N224 N257 N258 N259 N260 N261 N262 S_opa_i[19] N227 S_opa_i[21] S_opa_i[22] N263 S_opa_i[24] S_opa_i[25] S_opa_i[26] S_opa_i[27] S_opa_i[28] N264 N223 S_opa_i[31] Sqrt_sqr_o[0] Sqrt_sqr_o[1] Sqrt_sqr_o[2] Sqrt_sqr_o[3] Sqrt_sqr_o[4] Sqrt_sqr_o[5] Sqrt_sqr_o[6] Sqrt_sqr_o[7] Sqrt_sqr_o[8] Sqrt_sqr_o[9] Sqrt_sqr_o[10] Sqrt_sqr_o[11] Sqrt_sqr_o[12] Sqrt_sqr_o[13] Sqrt_sqr_o[14] Sqrt_sqr_o[15] Sqrt_sqr_o[16] Sqrt_sqr_o[17] Sqrt_sqr_o[18] Sqrt_sqr_o[19] Sqrt_sqr_o[20] Sqrt_sqr_o[21] Sqrt_sqr_o[22] Sqrt_sqr_o[23] Sqrt_sqr_o[24] Sqrt_sqr_o[25] Pre_norm_sqrt_exp_o[0] Pre_norm_sqrt_exp_o[1] Pre_norm_sqrt_exp_o[2] Pre_norm_sqrt_exp_o[3] Pre_norm_sqrt_exp_o[4] Pre_norm_sqrt_exp_o[5] Pre_norm_sqrt_exp_o[6] Pre_norm_sqrt_exp_o[7] Sqrt_ine_o S_rmode_i[0] S_rmode_i[1] Post_norm_sqrt_output[0] Post_norm_sqrt_output[1] Post_norm_sqrt_output[2] Post_norm_sqrt_output[3] Post_norm_sqrt_output[4] Post_norm_sqrt_output[5] Post_norm_sqrt_output[6] Post_norm_sqrt_output[7] Post_norm_sqrt_output[8] Post_norm_sqrt_output[9] Post_norm_sqrt_output[10] Post_norm_sqrt_output[11] Post_norm_sqrt_output[12] Post_norm_sqrt_output[13] Post_norm_sqrt_output[14] Post_norm_sqrt_output[15] Post_norm_sqrt_output[16] Post_norm_sqrt_output[17] Post_norm_sqrt_output[18] Post_norm_sqrt_output[19] Post_norm_sqrt_output[20] Post_norm_sqrt_output[21] Post_norm_sqrt_output[22] Post_norm_sqrt_output[23] Post_norm_sqrt_output[24] Post_norm_sqrt_output[25] Post_norm_sqrt_output[26] Post_norm_sqrt_output[27] Post_norm_sqrt_output[28] Post_norm_sqrt_output[29] Post_norm_sqrt_output[30] Post_norm_sqrt_output[31] Post_norm_sqrt_ine_o post_norm_sqrt
X80 Clk_i Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Pre_norm_sqrt_fracta_o[27] Pre_norm_sqrt_fracta_o[28] Pre_norm_sqrt_fracta_o[29] Pre_norm_sqrt_fracta_o[30] Pre_norm_sqrt_fracta_o[31] Pre_norm_sqrt_fracta_o[32] Pre_norm_sqrt_fracta_o[33] Pre_norm_sqrt_fracta_o[34] Pre_norm_sqrt_fracta_o[35] Pre_norm_sqrt_fracta_o[36] Pre_norm_sqrt_fracta_o[37] Pre_norm_sqrt_fracta_o[38] Pre_norm_sqrt_fracta_o[39] Pre_norm_sqrt_fracta_o[40] Pre_norm_sqrt_fracta_o[41] Pre_norm_sqrt_fracta_o[42] Pre_norm_sqrt_fracta_o[43] Pre_norm_sqrt_fracta_o[44] Pre_norm_sqrt_fracta_o[45] Pre_norm_sqrt_fracta_o[46] Pre_norm_sqrt_fracta_o[47] Pre_norm_sqrt_fracta_o[48] Pre_norm_sqrt_fracta_o[49] Pre_norm_sqrt_fracta_o[50] Pre_norm_sqrt_fracta_o[51] S_start_i _NC156 Sqrt_sqr_o[0] Sqrt_sqr_o[1] Sqrt_sqr_o[2] Sqrt_sqr_o[3] Sqrt_sqr_o[4] Sqrt_sqr_o[5] Sqrt_sqr_o[6] Sqrt_sqr_o[7] Sqrt_sqr_o[8] Sqrt_sqr_o[9] Sqrt_sqr_o[10] Sqrt_sqr_o[11] Sqrt_sqr_o[12] Sqrt_sqr_o[13] Sqrt_sqr_o[14] Sqrt_sqr_o[15] Sqrt_sqr_o[16] Sqrt_sqr_o[17] Sqrt_sqr_o[18] Sqrt_sqr_o[19] Sqrt_sqr_o[20] Sqrt_sqr_o[21] Sqrt_sqr_o[22] Sqrt_sqr_o[23] Sqrt_sqr_o[24] Sqrt_sqr_o[25] Sqrt_ine_o sqrt_RD_WIDTH52_SQ_WIDTH26
X81 Clk_i S_opa_i[0] N246 N247 N248 N249 N250 N251 N252 N253 N254 N255 N256 N224 N257 N258 N259 N260 N261 N262 S_opa_i[19] N227 S_opa_i[21] S_opa_i[22] N263 S_opa_i[24] S_opa_i[25] S_opa_i[26] S_opa_i[27] S_opa_i[28] N264 N223 S_opa_i[31] SYNOPSYS_UNCONNECTED__57 SYNOPSYS_UNCONNECTED__56 SYNOPSYS_UNCONNECTED__55 SYNOPSYS_UNCONNECTED__54 SYNOPSYS_UNCONNECTED__53 SYNOPSYS_UNCONNECTED__52 SYNOPSYS_UNCONNECTED__51 SYNOPSYS_UNCONNECTED__50 SYNOPSYS_UNCONNECTED__49 SYNOPSYS_UNCONNECTED__48 SYNOPSYS_UNCONNECTED__47 SYNOPSYS_UNCONNECTED__46 SYNOPSYS_UNCONNECTED__45 SYNOPSYS_UNCONNECTED__44 SYNOPSYS_UNCONNECTED__43 SYNOPSYS_UNCONNECTED__42 SYNOPSYS_UNCONNECTED__41 SYNOPSYS_UNCONNECTED__40 SYNOPSYS_UNCONNECTED__39 SYNOPSYS_UNCONNECTED__38 SYNOPSYS_UNCONNECTED__37 SYNOPSYS_UNCONNECTED__36 SYNOPSYS_UNCONNECTED__35 SYNOPSYS_UNCONNECTED__34 SYNOPSYS_UNCONNECTED__33 SYNOPSYS_UNCONNECTED__32 SYNOPSYS_UNCONNECTED__31 Pre_norm_sqrt_fracta_o[27] Pre_norm_sqrt_fracta_o[28] Pre_norm_sqrt_fracta_o[29] Pre_norm_sqrt_fracta_o[30] Pre_norm_sqrt_fracta_o[31] Pre_norm_sqrt_fracta_o[32] Pre_norm_sqrt_fracta_o[33] Pre_norm_sqrt_fracta_o[34] Pre_norm_sqrt_fracta_o[35] Pre_norm_sqrt_fracta_o[36] Pre_norm_sqrt_fracta_o[37] Pre_norm_sqrt_fracta_o[38] Pre_norm_sqrt_fracta_o[39] Pre_norm_sqrt_fracta_o[40] Pre_norm_sqrt_fracta_o[41] Pre_norm_sqrt_fracta_o[42] Pre_norm_sqrt_fracta_o[43] Pre_norm_sqrt_fracta_o[44] Pre_norm_sqrt_fracta_o[45] Pre_norm_sqrt_fracta_o[46] Pre_norm_sqrt_fracta_o[47] Pre_norm_sqrt_fracta_o[48] Pre_norm_sqrt_fracta_o[49] Pre_norm_sqrt_fracta_o[50] Pre_norm_sqrt_fracta_o[51] Pre_norm_sqrt_exp_o[0] Pre_norm_sqrt_exp_o[1] Pre_norm_sqrt_exp_o[2] Pre_norm_sqrt_exp_o[3] Pre_norm_sqrt_exp_o[4] Pre_norm_sqrt_exp_o[5] Pre_norm_sqrt_exp_o[6] Pre_norm_sqrt_exp_o[7] pre_norm_sqrt
X82 Clk_i S_opa_i[0] N246 N247 N248 N249 N250 N251 N252 N253 N254 N255 N256 N225 N257 N258 N259 N260 N261 N262 S_opa_i[19] N228 S_opa_i[21] S_opa_i[22] N263 S_opa_i[24] S_opa_i[25] S_opa_i[26] S_opa_i[27] S_opa_i[28] N264 N223 S_opa_i[31] S_opb_i[0] S_opb_i[1] S_opb_i[2] S_opb_i[3] S_opb_i[4] S_opb_i[5] S_opb_i[6] S_opb_i[7] S_opb_i[8] S_opb_i[9] S_opb_i[10] S_opb_i[11] S_opb_i[12] S_opb_i[13] S_opb_i[14] S_opb_i[15] S_opb_i[16] S_opb_i[17] S_opb_i[18] S_opb_i[19] S_opb_i[20] S_opb_i[21] S_opb_i[22] S_opb_i[23] S_opb_i[24] S_opb_i[25] S_opb_i[26] S_opb_i[27] S_opb_i[28] S_opb_i[29] S_opb_i[30] S_opb_i[31] Serial_div_qutnt[0] Serial_div_qutnt[1] Serial_div_qutnt[2] Serial_div_qutnt[3] Serial_div_qutnt[4] Serial_div_qutnt[5] Serial_div_qutnt[6] Serial_div_qutnt[7] Serial_div_qutnt[8] Serial_div_qutnt[9] Serial_div_qutnt[10] Serial_div_qutnt[11] Serial_div_qutnt[12] Serial_div_qutnt[13] Serial_div_qutnt[14] Serial_div_qutnt[15] Serial_div_qutnt[16] Serial_div_qutnt[17] Serial_div_qutnt[18] Serial_div_qutnt[19] Serial_div_qutnt[20] Serial_div_qutnt[21] Serial_div_qutnt[22] Serial_div_qutnt[23] Serial_div_qutnt[24] Serial_div_qutnt[25] Serial_div_qutnt[26] Serial_div_rmndr[0] Serial_div_rmndr[1] Serial_div_rmndr[2] Serial_div_rmndr[3] Serial_div_rmndr[4] Serial_div_rmndr[5] Serial_div_rmndr[6] Serial_div_rmndr[7] Serial_div_rmndr[8] Serial_div_rmndr[9] Serial_div_rmndr[10] Serial_div_rmndr[11] Serial_div_rmndr[12] Serial_div_rmndr[13] Serial_div_rmndr[14] Serial_div_rmndr[15] Serial_div_rmndr[16] Serial_div_rmndr[17] Serial_div_rmndr[18] Serial_div_rmndr[19] Serial_div_rmndr[20] Serial_div_rmndr[21] Serial_div_rmndr[22] Serial_div_rmndr[23] Serial_div_rmndr[24] Serial_div_rmndr[25] Serial_div_rmndr[26] Pre_norm_div_exp[0] Pre_norm_div_exp[1] Pre_norm_div_exp[2] Pre_norm_div_exp[3] Pre_norm_div_exp[4] Pre_norm_div_exp[5] Pre_norm_div_exp[6] Pre_norm_div_exp[7] Pre_norm_div_exp[8] Pre_norm_div_exp[9] Serial_div_sign S_rmode_i[0] S_rmode_i[1] Post_norm_div_output[0] Post_norm_div_output[1] Post_norm_div_output[2] Post_norm_div_output[3] Post_norm_div_output[4] Post_norm_div_output[5] Post_norm_div_output[6] Post_norm_div_output[7] Post_norm_div_output[8] Post_norm_div_output[9] Post_norm_div_output[10] Post_norm_div_output[11] Post_norm_div_output[12] Post_norm_div_output[13] Post_norm_div_output[14] Post_norm_div_output[15] Post_norm_div_output[16] Post_norm_div_output[17] Post_norm_div_output[18] Post_norm_div_output[19] Post_norm_div_output[20] Post_norm_div_output[21] Post_norm_div_output[22] Post_norm_div_output[23] Post_norm_div_output[24] Post_norm_div_output[25] Post_norm_div_output[26] Post_norm_div_output[27] Post_norm_div_output[28] Post_norm_div_output[29] Post_norm_div_output[30] Post_norm_div_output[31] Post_norm_div_ine post_norm_div
X83 Clk_i Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Pre_norm_div_dvdnd[26] Pre_norm_div_dvdnd[27] Pre_norm_div_dvdnd[28] Pre_norm_div_dvdnd[29] Pre_norm_div_dvdnd[30] Pre_norm_div_dvdnd[31] Pre_norm_div_dvdnd[32] Pre_norm_div_dvdnd[33] Pre_norm_div_dvdnd[34] Pre_norm_div_dvdnd[35] Pre_norm_div_dvdnd[36] Pre_norm_div_dvdnd[37] Pre_norm_div_dvdnd[38] Pre_norm_div_dvdnd[39] Pre_norm_div_dvdnd[40] Pre_norm_div_dvdnd[41] Pre_norm_div_dvdnd[42] Pre_norm_div_dvdnd[43] Pre_norm_div_dvdnd[44] Pre_norm_div_dvdnd[45] Pre_norm_div_dvdnd[46] Pre_norm_div_dvdnd[47] Pre_norm_div_dvdnd[48] Pre_norm_div_dvdnd[49] Pre_norm_div_dvsor[0] Pre_norm_div_dvsor[1] Pre_norm_div_dvsor[2] Pre_norm_div_dvsor[3] Pre_norm_div_dvsor[4] Pre_norm_div_dvsor[5] Pre_norm_div_dvsor[6] Pre_norm_div_dvsor[7] Pre_norm_div_dvsor[8] Pre_norm_div_dvsor[9] Pre_norm_div_dvsor[10] Pre_norm_div_dvsor[11] Pre_norm_div_dvsor[12] Pre_norm_div_dvsor[13] Pre_norm_div_dvsor[14] Pre_norm_div_dvsor[15] Pre_norm_div_dvsor[16] Pre_norm_div_dvsor[17] Pre_norm_div_dvsor[18] Pre_norm_div_dvsor[19] Pre_norm_div_dvsor[20] Pre_norm_div_dvsor[21] Pre_norm_div_dvsor[22] Pre_norm_div_dvsor[23] Vss Vss Vss S_opa_i[31] S_opb_i[31] S_start_i _NC157 Serial_div_qutnt[0] Serial_div_qutnt[1] Serial_div_qutnt[2] Serial_div_qutnt[3] Serial_div_qutnt[4] Serial_div_qutnt[5] Serial_div_qutnt[6] Serial_div_qutnt[7] Serial_div_qutnt[8] Serial_div_qutnt[9] Serial_div_qutnt[10] Serial_div_qutnt[11] Serial_div_qutnt[12] Serial_div_qutnt[13] Serial_div_qutnt[14] Serial_div_qutnt[15] Serial_div_qutnt[16] Serial_div_qutnt[17] Serial_div_qutnt[18] Serial_div_qutnt[19] Serial_div_qutnt[20] Serial_div_qutnt[21] Serial_div_qutnt[22] Serial_div_qutnt[23] Serial_div_qutnt[24] Serial_div_qutnt[25] Serial_div_qutnt[26] Serial_div_rmndr[0] Serial_div_rmndr[1] Serial_div_rmndr[2] Serial_div_rmndr[3] Serial_div_rmndr[4] Serial_div_rmndr[5] Serial_div_rmndr[6] Serial_div_rmndr[7] Serial_div_rmndr[8] Serial_div_rmndr[9] Serial_div_rmndr[10] Serial_div_rmndr[11] Serial_div_rmndr[12] Serial_div_rmndr[13] Serial_div_rmndr[14] Serial_div_rmndr[15] Serial_div_rmndr[16] Serial_div_rmndr[17] Serial_div_rmndr[18] Serial_div_rmndr[19] Serial_div_rmndr[20] Serial_div_rmndr[21] Serial_div_rmndr[22] Serial_div_rmndr[23] Serial_div_rmndr[24] Serial_div_rmndr[25] Serial_div_rmndr[26] Serial_div_sign Serial_div_div_zero serial_div
X84 Clk_i S_opa_i[0] N246 N247 N248 N249 N250 N251 N252 N253 N254 N255 N256 N225 N257 N258 N259 N260 N261 N262 S_opa_i[19] N228 S_opa_i[21] S_opa_i[22] N263 S_opa_i[24] S_opa_i[25] S_opa_i[26] S_opa_i[27] S_opa_i[28] N264 N223 S_opa_i[31] S_opb_i[0] S_opb_i[1] S_opb_i[2] S_opb_i[3] S_opb_i[4] S_opb_i[5] S_opb_i[6] S_opb_i[7] S_opb_i[8] S_opb_i[9] S_opb_i[10] S_opb_i[11] S_opb_i[12] S_opb_i[13] S_opb_i[14] S_opb_i[15] S_opb_i[16] S_opb_i[17] S_opb_i[18] S_opb_i[19] S_opb_i[20] S_opb_i[21] S_opb_i[22] S_opb_i[23] S_opb_i[24] S_opb_i[25] S_opb_i[26] S_opb_i[27] S_opb_i[28] S_opb_i[29] S_opb_i[30] S_opb_i[31] Pre_norm_div_exp[0] Pre_norm_div_exp[1] Pre_norm_div_exp[2] Pre_norm_div_exp[3] Pre_norm_div_exp[4] Pre_norm_div_exp[5] Pre_norm_div_exp[6] Pre_norm_div_exp[7] Pre_norm_div_exp[8] Pre_norm_div_exp[9] SYNOPSYS_UNCONNECTED__27 SYNOPSYS_UNCONNECTED__26 SYNOPSYS_UNCONNECTED__25 SYNOPSYS_UNCONNECTED__24 SYNOPSYS_UNCONNECTED__23 SYNOPSYS_UNCONNECTED__22 SYNOPSYS_UNCONNECTED__21 SYNOPSYS_UNCONNECTED__20 SYNOPSYS_UNCONNECTED__19 SYNOPSYS_UNCONNECTED__18 SYNOPSYS_UNCONNECTED__17 SYNOPSYS_UNCONNECTED__16 SYNOPSYS_UNCONNECTED__15 SYNOPSYS_UNCONNECTED__14 SYNOPSYS_UNCONNECTED__13 SYNOPSYS_UNCONNECTED__12 SYNOPSYS_UNCONNECTED__11 SYNOPSYS_UNCONNECTED__10 SYNOPSYS_UNCONNECTED__9 SYNOPSYS_UNCONNECTED__8 SYNOPSYS_UNCONNECTED__7 SYNOPSYS_UNCONNECTED__6 SYNOPSYS_UNCONNECTED__5 SYNOPSYS_UNCONNECTED__4 SYNOPSYS_UNCONNECTED__3 SYNOPSYS_UNCONNECTED__2 Pre_norm_div_dvdnd[26] Pre_norm_div_dvdnd[27] Pre_norm_div_dvdnd[28] Pre_norm_div_dvdnd[29] Pre_norm_div_dvdnd[30] Pre_norm_div_dvdnd[31] Pre_norm_div_dvdnd[32] Pre_norm_div_dvdnd[33] Pre_norm_div_dvdnd[34] Pre_norm_div_dvdnd[35] Pre_norm_div_dvdnd[36] Pre_norm_div_dvdnd[37] Pre_norm_div_dvdnd[38] Pre_norm_div_dvdnd[39] Pre_norm_div_dvdnd[40] Pre_norm_div_dvdnd[41] Pre_norm_div_dvdnd[42] Pre_norm_div_dvdnd[43] Pre_norm_div_dvdnd[44] Pre_norm_div_dvdnd[45] Pre_norm_div_dvdnd[46] Pre_norm_div_dvdnd[47] Pre_norm_div_dvdnd[48] Pre_norm_div_dvdnd[49] Pre_norm_div_dvsor[0] Pre_norm_div_dvsor[1] Pre_norm_div_dvsor[2] Pre_norm_div_dvsor[3] Pre_norm_div_dvsor[4] Pre_norm_div_dvsor[5] Pre_norm_div_dvsor[6] Pre_norm_div_dvsor[7] Pre_norm_div_dvsor[8] Pre_norm_div_dvsor[9] Pre_norm_div_dvsor[10] Pre_norm_div_dvsor[11] Pre_norm_div_dvsor[12] Pre_norm_div_dvsor[13] Pre_norm_div_dvsor[14] Pre_norm_div_dvsor[15] Pre_norm_div_dvsor[16] Pre_norm_div_dvsor[17] Pre_norm_div_dvsor[18] Pre_norm_div_dvsor[19] Pre_norm_div_dvsor[20] Pre_norm_div_dvsor[21] Pre_norm_div_dvsor[22] Pre_norm_div_dvsor[23] SYNOPSYS_UNCONNECTED__30 SYNOPSYS_UNCONNECTED__29 SYNOPSYS_UNCONNECTED__28 pre_norm_div
X85 Clk_i S_opa_i[0] N246 N247 N248 N249 N250 N251 N252 N253 N254 N255 N256 N226 N257 N258 N259 N260 N261 N262 S_opa_i[19] N229 S_opa_i[21] S_opa_i[22] N263 S_opa_i[24] S_opa_i[25] S_opa_i[26] S_opa_i[27] S_opa_i[28] N264 N223 S_opa_i[31] S_opb_i[0] S_opb_i[1] S_opb_i[2] S_opb_i[3] S_opb_i[4] S_opb_i[5] S_opb_i[6] S_opb_i[7] S_opb_i[8] S_opb_i[9] S_opb_i[10] S_opb_i[11] S_opb_i[12] S_opb_i[13] S_opb_i[14] S_opb_i[15] S_opb_i[16] S_opb_i[17] S_opb_i[18] S_opb_i[19] S_opb_i[20] S_opb_i[21] S_opb_i[22] S_opb_i[23] S_opb_i[24] S_opb_i[25] S_opb_i[26] S_opb_i[27] S_opb_i[28] S_opb_i[29] S_opb_i[30] S_opb_i[31] Pre_norm_mul_exp_10[0] Pre_norm_mul_exp_10[1] Pre_norm_mul_exp_10[2] Pre_norm_mul_exp_10[3] Pre_norm_mul_exp_10[4] Pre_norm_mul_exp_10[5] Pre_norm_mul_exp_10[6] Pre_norm_mul_exp_10[7] Pre_norm_mul_exp_10[8] Pre_norm_mul_exp_10[9] Mul_24_fract_48[0] Mul_24_fract_48[1] Mul_24_fract_48[2] Mul_24_fract_48[3] Mul_24_fract_48[4] Mul_24_fract_48[5] Mul_24_fract_48[6] Mul_24_fract_48[7] Mul_24_fract_48[8] Mul_24_fract_48[9] Mul_24_fract_48[10] Mul_24_fract_48[11] Mul_24_fract_48[12] Mul_24_fract_48[13] Mul_24_fract_48[14] Mul_24_fract_48[15] Mul_24_fract_48[16] Mul_24_fract_48[17] Mul_24_fract_48[18] Mul_24_fract_48[19] Mul_24_fract_48[20] Mul_24_fract_48[21] Mul_24_fract_48[22] Mul_24_fract_48[23] Mul_24_fract_48[24] Mul_24_fract_48[25] Mul_24_fract_48[26] Mul_24_fract_48[27] Mul_24_fract_48[28] Mul_24_fract_48[29] Mul_24_fract_48[30] Mul_24_fract_48[31] Mul_24_fract_48[32] Mul_24_fract_48[33] Mul_24_fract_48[34] Mul_24_fract_48[35] Mul_24_fract_48[36] Mul_24_fract_48[37] Mul_24_fract_48[38] Mul_24_fract_48[39] Mul_24_fract_48[40] Mul_24_fract_48[41] Mul_24_fract_48[42] Mul_24_fract_48[43] Mul_24_fract_48[44] Mul_24_fract_48[45] Mul_24_fract_48[46] Mul_24_fract_48[47] Mul_24_sign S_rmode_i[0] S_rmode_i[1] Post_norm_mul_output[0] Post_norm_mul_output[1] Post_norm_mul_output[2] Post_norm_mul_output[3] Post_norm_mul_output[4] Post_norm_mul_output[5] Post_norm_mul_output[6] Post_norm_mul_output[7] Post_norm_mul_output[8] Post_norm_mul_output[9] Post_norm_mul_output[10] Post_norm_mul_output[11] Post_norm_mul_output[12] Post_norm_mul_output[13] Post_norm_mul_output[14] Post_norm_mul_output[15] Post_norm_mul_output[16] Post_norm_mul_output[17] Post_norm_mul_output[18] Post_norm_mul_output[19] Post_norm_mul_output[20] Post_norm_mul_output[21] Post_norm_mul_output[22] Post_norm_mul_output[23] Post_norm_mul_output[24] Post_norm_mul_output[25] Post_norm_mul_output[26] Post_norm_mul_output[27] Post_norm_mul_output[28] Post_norm_mul_output[29] Post_norm_mul_output[30] Post_norm_mul_output[31] Post_norm_mul_ine post_norm_mul
X86 Clk_i Pre_norm_mul_fracta_24[0] Pre_norm_mul_fracta_24[1] Pre_norm_mul_fracta_24[2] Pre_norm_mul_fracta_24[3] Pre_norm_mul_fracta_24[4] Pre_norm_mul_fracta_24[5] Pre_norm_mul_fracta_24[6] Pre_norm_mul_fracta_24[7] Pre_norm_mul_fracta_24[8] Pre_norm_mul_fracta_24[9] Pre_norm_mul_fracta_24[10] Pre_norm_mul_fracta_24[11] Pre_norm_mul_fracta_24[12] Pre_norm_mul_fracta_24[13] Pre_norm_mul_fracta_24[14] Pre_norm_mul_fracta_24[15] Pre_norm_mul_fracta_24[16] Pre_norm_mul_fracta_24[17] Pre_norm_mul_fracta_24[18] Pre_norm_mul_fracta_24[19] Pre_norm_mul_fracta_24[20] Pre_norm_mul_fracta_24[21] Pre_norm_mul_fracta_24[22] Pre_norm_mul_fracta_24[23] Pre_norm_mul_fractb_24[0] Pre_norm_mul_fractb_24[1] Pre_norm_mul_fractb_24[2] Pre_norm_mul_fractb_24[3] Pre_norm_mul_fractb_24[4] Pre_norm_mul_fractb_24[5] Pre_norm_mul_fractb_24[6] Pre_norm_mul_fractb_24[7] Pre_norm_mul_fractb_24[8] Pre_norm_mul_fractb_24[9] Pre_norm_mul_fractb_24[10] Pre_norm_mul_fractb_24[11] Pre_norm_mul_fractb_24[12] Pre_norm_mul_fractb_24[13] Pre_norm_mul_fractb_24[14] Pre_norm_mul_fractb_24[15] Pre_norm_mul_fractb_24[16] Pre_norm_mul_fractb_24[17] Pre_norm_mul_fractb_24[18] Pre_norm_mul_fractb_24[19] Pre_norm_mul_fractb_24[20] Pre_norm_mul_fractb_24[21] Pre_norm_mul_fractb_24[22] Pre_norm_mul_fractb_24[23] S_opa_i[31] S_opb_i[31] S_start_i _NC158 _NC159 _NC160 _NC161 _NC162 _NC163 _NC164 _NC165 _NC166 _NC167 _NC168 _NC169 _NC170 _NC171 _NC172 _NC173 _NC174 _NC175 _NC176 _NC177 _NC178 _NC179 _NC180 _NC181 _NC182 _NC183 _NC184 _NC185 _NC186 _NC187 _NC188 _NC189 _NC190 _NC191 _NC192 _NC193 _NC194 _NC195 _NC196 _NC197 _NC198 _NC199 _NC200 _NC201 _NC202 _NC203 _NC204 _NC205 _NC206 _NC207 serial_mul
X87 Clk_i Pre_norm_mul_fracta_24[0] Pre_norm_mul_fracta_24[1] Pre_norm_mul_fracta_24[2] Pre_norm_mul_fracta_24[3] Pre_norm_mul_fracta_24[4] Pre_norm_mul_fracta_24[5] Pre_norm_mul_fracta_24[6] Pre_norm_mul_fracta_24[7] Pre_norm_mul_fracta_24[8] Pre_norm_mul_fracta_24[9] Pre_norm_mul_fracta_24[10] Pre_norm_mul_fracta_24[11] Pre_norm_mul_fracta_24[12] Pre_norm_mul_fracta_24[13] Pre_norm_mul_fracta_24[14] Pre_norm_mul_fracta_24[15] Pre_norm_mul_fracta_24[16] Pre_norm_mul_fracta_24[17] Pre_norm_mul_fracta_24[18] Pre_norm_mul_fracta_24[19] Pre_norm_mul_fracta_24[20] Pre_norm_mul_fracta_24[21] Pre_norm_mul_fracta_24[22] Pre_norm_mul_fracta_24[23] Pre_norm_mul_fractb_24[0] Pre_norm_mul_fractb_24[1] Pre_norm_mul_fractb_24[2] Pre_norm_mul_fractb_24[3] Pre_norm_mul_fractb_24[4] Pre_norm_mul_fractb_24[5] Pre_norm_mul_fractb_24[6] Pre_norm_mul_fractb_24[7] Pre_norm_mul_fractb_24[8] Pre_norm_mul_fractb_24[9] Pre_norm_mul_fractb_24[10] Pre_norm_mul_fractb_24[11] Pre_norm_mul_fractb_24[12] Pre_norm_mul_fractb_24[13] Pre_norm_mul_fractb_24[14] Pre_norm_mul_fractb_24[15] Pre_norm_mul_fractb_24[16] Pre_norm_mul_fractb_24[17] Pre_norm_mul_fractb_24[18] Pre_norm_mul_fractb_24[19] Pre_norm_mul_fractb_24[20] Pre_norm_mul_fractb_24[21] Pre_norm_mul_fractb_24[22] Pre_norm_mul_fractb_24[23] S_opa_i[31] S_opb_i[31] Start_i Mul_24_fract_48[0] Mul_24_fract_48[1] Mul_24_fract_48[2] Mul_24_fract_48[3] Mul_24_fract_48[4] Mul_24_fract_48[5] Mul_24_fract_48[6] Mul_24_fract_48[7] Mul_24_fract_48[8] Mul_24_fract_48[9] Mul_24_fract_48[10] Mul_24_fract_48[11] Mul_24_fract_48[12] Mul_24_fract_48[13] Mul_24_fract_48[14] Mul_24_fract_48[15] Mul_24_fract_48[16] Mul_24_fract_48[17] Mul_24_fract_48[18] Mul_24_fract_48[19] Mul_24_fract_48[20] Mul_24_fract_48[21] Mul_24_fract_48[22] Mul_24_fract_48[23] Mul_24_fract_48[24] Mul_24_fract_48[25] Mul_24_fract_48[26] Mul_24_fract_48[27] Mul_24_fract_48[28] Mul_24_fract_48[29] Mul_24_fract_48[30] Mul_24_fract_48[31] Mul_24_fract_48[32] Mul_24_fract_48[33] Mul_24_fract_48[34] Mul_24_fract_48[35] Mul_24_fract_48[36] Mul_24_fract_48[37] Mul_24_fract_48[38] Mul_24_fract_48[39] Mul_24_fract_48[40] Mul_24_fract_48[41] Mul_24_fract_48[42] Mul_24_fract_48[43] Mul_24_fract_48[44] Mul_24_fract_48[45] Mul_24_fract_48[46] Mul_24_fract_48[47] Mul_24_sign _NC208 mul_24
X88 Clk_i S_opa_i[0] N246 N247 N248 N249 N250 N251 N252 N253 N254 N255 N256 N224 N257 N258 N259 N260 N261 N262 S_opa_i[19] N227 S_opa_i[21] S_opa_i[22] N263 S_opa_i[24] S_opa_i[25] S_opa_i[26] S_opa_i[27] S_opa_i[28] N264 N223 S_opa_i[31] S_opb_i[0] S_opb_i[1] S_opb_i[2] S_opb_i[3] S_opb_i[4] S_opb_i[5] S_opb_i[6] S_opb_i[7] S_opb_i[8] S_opb_i[9] S_opb_i[10] S_opb_i[11] S_opb_i[12] S_opb_i[13] S_opb_i[14] S_opb_i[15] S_opb_i[16] S_opb_i[17] S_opb_i[18] S_opb_i[19] S_opb_i[20] S_opb_i[21] S_opb_i[22] S_opb_i[23] S_opb_i[24] S_opb_i[25] S_opb_i[26] S_opb_i[27] S_opb_i[28] S_opb_i[29] S_opb_i[30] S_opb_i[31] Pre_norm_mul_exp_10[0] Pre_norm_mul_exp_10[1] Pre_norm_mul_exp_10[2] Pre_norm_mul_exp_10[3] Pre_norm_mul_exp_10[4] Pre_norm_mul_exp_10[5] Pre_norm_mul_exp_10[6] Pre_norm_mul_exp_10[7] Pre_norm_mul_exp_10[8] Pre_norm_mul_exp_10[9] Pre_norm_mul_fracta_24[0] Pre_norm_mul_fracta_24[1] Pre_norm_mul_fracta_24[2] Pre_norm_mul_fracta_24[3] Pre_norm_mul_fracta_24[4] Pre_norm_mul_fracta_24[5] Pre_norm_mul_fracta_24[6] Pre_norm_mul_fracta_24[7] Pre_norm_mul_fracta_24[8] Pre_norm_mul_fracta_24[9] Pre_norm_mul_fracta_24[10] Pre_norm_mul_fracta_24[11] Pre_norm_mul_fracta_24[12] Pre_norm_mul_fracta_24[13] Pre_norm_mul_fracta_24[14] Pre_norm_mul_fracta_24[15] Pre_norm_mul_fracta_24[16] Pre_norm_mul_fracta_24[17] Pre_norm_mul_fracta_24[18] Pre_norm_mul_fracta_24[19] Pre_norm_mul_fracta_24[20] Pre_norm_mul_fracta_24[21] Pre_norm_mul_fracta_24[22] Pre_norm_mul_fracta_24[23] Pre_norm_mul_fractb_24[0] Pre_norm_mul_fractb_24[1] Pre_norm_mul_fractb_24[2] Pre_norm_mul_fractb_24[3] Pre_norm_mul_fractb_24[4] Pre_norm_mul_fractb_24[5] Pre_norm_mul_fractb_24[6] Pre_norm_mul_fractb_24[7] Pre_norm_mul_fractb_24[8] Pre_norm_mul_fractb_24[9] Pre_norm_mul_fractb_24[10] Pre_norm_mul_fractb_24[11] Pre_norm_mul_fractb_24[12] Pre_norm_mul_fractb_24[13] Pre_norm_mul_fractb_24[14] Pre_norm_mul_fractb_24[15] Pre_norm_mul_fractb_24[16] Pre_norm_mul_fractb_24[17] Pre_norm_mul_fractb_24[18] Pre_norm_mul_fractb_24[19] Pre_norm_mul_fractb_24[20] Pre_norm_mul_fractb_24[21] Pre_norm_mul_fractb_24[22] Pre_norm_mul_fractb_24[23] pre_norm_mul
X89 Clk_i S_opa_i[0] N246 N247 N248 N249 N250 N251 N252 N253 N254 N255 N256 N225 N257 N258 N259 N260 N261 N262 S_opa_i[19] N228 S_opa_i[21] S_opa_i[22] N263 S_opa_i[24] S_opa_i[25] S_opa_i[26] S_opa_i[27] S_opa_i[28] N264 N223 S_opa_i[31] S_opb_i[0] S_opb_i[1] S_opb_i[2] S_opb_i[3] S_opb_i[4] S_opb_i[5] S_opb_i[6] S_opb_i[7] S_opb_i[8] S_opb_i[9] S_opb_i[10] S_opb_i[11] S_opb_i[12] S_opb_i[13] S_opb_i[14] S_opb_i[15] S_opb_i[16] S_opb_i[17] S_opb_i[18] S_opb_i[19] S_opb_i[20] S_opb_i[21] S_opb_i[22] S_opb_i[23] S_opb_i[24] S_opb_i[25] S_opb_i[26] S_opb_i[27] S_opb_i[28] S_opb_i[29] S_opb_i[30] S_opb_i[31] Addsub_fract_o[0] Addsub_fract_o[1] Addsub_fract_o[2] Addsub_fract_o[3] Addsub_fract_o[4] Addsub_fract_o[5] Addsub_fract_o[6] Addsub_fract_o[7] Addsub_fract_o[8] Addsub_fract_o[9] Addsub_fract_o[10] Addsub_fract_o[11] Addsub_fract_o[12] Addsub_fract_o[13] Addsub_fract_o[14] Addsub_fract_o[15] Addsub_fract_o[16] Addsub_fract_o[17] Addsub_fract_o[18] Addsub_fract_o[19] Addsub_fract_o[20] Addsub_fract_o[21] Addsub_fract_o[22] Addsub_fract_o[23] Addsub_fract_o[24] Addsub_fract_o[25] Addsub_fract_o[26] Addsub_fract_o[27] Prenorm_addsub_exp_o[0] Prenorm_addsub_exp_o[1] Prenorm_addsub_exp_o[2] Prenorm_addsub_exp_o[3] Prenorm_addsub_exp_o[4] Prenorm_addsub_exp_o[5] Prenorm_addsub_exp_o[6] Prenorm_addsub_exp_o[7] Addsub_sign_o S_fpu_op_i[0] S_rmode_i[0] S_rmode_i[1] Postnorm_addsub_output_o[0] Postnorm_addsub_output_o[1] Postnorm_addsub_output_o[2] Postnorm_addsub_output_o[3] Postnorm_addsub_output_o[4] Postnorm_addsub_output_o[5] Postnorm_addsub_output_o[6] Postnorm_addsub_output_o[7] Postnorm_addsub_output_o[8] Postnorm_addsub_output_o[9] Postnorm_addsub_output_o[10] Postnorm_addsub_output_o[11] Postnorm_addsub_output_o[12] Postnorm_addsub_output_o[13] Postnorm_addsub_output_o[14] Postnorm_addsub_output_o[15] Postnorm_addsub_output_o[16] Postnorm_addsub_output_o[17] Postnorm_addsub_output_o[18] Postnorm_addsub_output_o[19] Postnorm_addsub_output_o[20] Postnorm_addsub_output_o[21] Postnorm_addsub_output_o[22] Postnorm_addsub_output_o[23] Postnorm_addsub_output_o[24] Postnorm_addsub_output_o[25] Postnorm_addsub_output_o[26] Postnorm_addsub_output_o[27] Postnorm_addsub_output_o[28] Postnorm_addsub_output_o[29] Postnorm_addsub_output_o[30] Postnorm_addsub_output_o[31] Postnorm_addsub_ine_o post_norm_addsub
X90 Clk_i S_fpu_op_i[0] Prenorm_addsub_fracta_28_o[0] Prenorm_addsub_fracta_28_o[1] Prenorm_addsub_fracta_28_o[2] Prenorm_addsub_fracta_28_o[3] Prenorm_addsub_fracta_28_o[4] Prenorm_addsub_fracta_28_o[5] Prenorm_addsub_fracta_28_o[6] Prenorm_addsub_fracta_28_o[7] Prenorm_addsub_fracta_28_o[8] Prenorm_addsub_fracta_28_o[9] Prenorm_addsub_fracta_28_o[10] Prenorm_addsub_fracta_28_o[11] Prenorm_addsub_fracta_28_o[12] Prenorm_addsub_fracta_28_o[13] Prenorm_addsub_fracta_28_o[14] Prenorm_addsub_fracta_28_o[15] Prenorm_addsub_fracta_28_o[16] Prenorm_addsub_fracta_28_o[17] Prenorm_addsub_fracta_28_o[18] Prenorm_addsub_fracta_28_o[19] Prenorm_addsub_fracta_28_o[20] Prenorm_addsub_fracta_28_o[21] Prenorm_addsub_fracta_28_o[22] Prenorm_addsub_fracta_28_o[23] Prenorm_addsub_fracta_28_o[24] Prenorm_addsub_fracta_28_o[25] Prenorm_addsub_fracta_28_o[26] Vss Prenorm_addsub_fractb_28_o[0] Prenorm_addsub_fractb_28_o[1] Prenorm_addsub_fractb_28_o[2] Prenorm_addsub_fractb_28_o[3] Prenorm_addsub_fractb_28_o[4] Prenorm_addsub_fractb_28_o[5] Prenorm_addsub_fractb_28_o[6] Prenorm_addsub_fractb_28_o[7] Prenorm_addsub_fractb_28_o[8] Prenorm_addsub_fractb_28_o[9] Prenorm_addsub_fractb_28_o[10] Prenorm_addsub_fractb_28_o[11] Prenorm_addsub_fractb_28_o[12] Prenorm_addsub_fractb_28_o[13] Prenorm_addsub_fractb_28_o[14] Prenorm_addsub_fractb_28_o[15] Prenorm_addsub_fractb_28_o[16] Prenorm_addsub_fractb_28_o[17] Prenorm_addsub_fractb_28_o[18] Prenorm_addsub_fractb_28_o[19] Prenorm_addsub_fractb_28_o[20] Prenorm_addsub_fractb_28_o[21] Prenorm_addsub_fractb_28_o[22] Prenorm_addsub_fractb_28_o[23] Prenorm_addsub_fractb_28_o[24] Prenorm_addsub_fractb_28_o[25] Prenorm_addsub_fractb_28_o[26] Vss S_opa_i[31] S_opb_i[31] Addsub_fract_o[0] Addsub_fract_o[1] Addsub_fract_o[2] Addsub_fract_o[3] Addsub_fract_o[4] Addsub_fract_o[5] Addsub_fract_o[6] Addsub_fract_o[7] Addsub_fract_o[8] Addsub_fract_o[9] Addsub_fract_o[10] Addsub_fract_o[11] Addsub_fract_o[12] Addsub_fract_o[13] Addsub_fract_o[14] Addsub_fract_o[15] Addsub_fract_o[16] Addsub_fract_o[17] Addsub_fract_o[18] Addsub_fract_o[19] Addsub_fract_o[20] Addsub_fract_o[21] Addsub_fract_o[22] Addsub_fract_o[23] Addsub_fract_o[24] Addsub_fract_o[25] Addsub_fract_o[26] Addsub_fract_o[27] Addsub_sign_o addsub_28
X91 Clk_i S_opa_i[0] N246 N247 N248 N249 N250 N251 N252 N253 N254 N255 N256 N226 N257 N258 N259 N260 N261 N262 S_opa_i[19] N229 S_opa_i[21] S_opa_i[22] N263 S_opa_i[24] S_opa_i[25] S_opa_i[26] S_opa_i[27] S_opa_i[28] N264 N265 S_opa_i[31] S_opb_i[0] S_opb_i[1] S_opb_i[2] S_opb_i[3] S_opb_i[4] S_opb_i[5] S_opb_i[6] S_opb_i[7] S_opb_i[8] S_opb_i[9] S_opb_i[10] S_opb_i[11] S_opb_i[12] S_opb_i[13] S_opb_i[14] S_opb_i[15] S_opb_i[16] S_opb_i[17] S_opb_i[18] S_opb_i[19] S_opb_i[20] S_opb_i[21] S_opb_i[22] S_opb_i[23] S_opb_i[24] S_opb_i[25] S_opb_i[26] S_opb_i[27] S_opb_i[28] S_opb_i[29] S_opb_i[30] S_opb_i[31] Prenorm_addsub_fracta_28_o[0] Prenorm_addsub_fracta_28_o[1] Prenorm_addsub_fracta_28_o[2] Prenorm_addsub_fracta_28_o[3] Prenorm_addsub_fracta_28_o[4] Prenorm_addsub_fracta_28_o[5] Prenorm_addsub_fracta_28_o[6] Prenorm_addsub_fracta_28_o[7] Prenorm_addsub_fracta_28_o[8] Prenorm_addsub_fracta_28_o[9] Prenorm_addsub_fracta_28_o[10] Prenorm_addsub_fracta_28_o[11] Prenorm_addsub_fracta_28_o[12] Prenorm_addsub_fracta_28_o[13] Prenorm_addsub_fracta_28_o[14] Prenorm_addsub_fracta_28_o[15] Prenorm_addsub_fracta_28_o[16] Prenorm_addsub_fracta_28_o[17] Prenorm_addsub_fracta_28_o[18] Prenorm_addsub_fracta_28_o[19] Prenorm_addsub_fracta_28_o[20] Prenorm_addsub_fracta_28_o[21] Prenorm_addsub_fracta_28_o[22] Prenorm_addsub_fracta_28_o[23] Prenorm_addsub_fracta_28_o[24] Prenorm_addsub_fracta_28_o[25] Prenorm_addsub_fracta_28_o[26] SYNOPSYS_UNCONNECTED__0 Prenorm_addsub_fractb_28_o[0] Prenorm_addsub_fractb_28_o[1] Prenorm_addsub_fractb_28_o[2] Prenorm_addsub_fractb_28_o[3] Prenorm_addsub_fractb_28_o[4] Prenorm_addsub_fractb_28_o[5] Prenorm_addsub_fractb_28_o[6] Prenorm_addsub_fractb_28_o[7] Prenorm_addsub_fractb_28_o[8] Prenorm_addsub_fractb_28_o[9] Prenorm_addsub_fractb_28_o[10] Prenorm_addsub_fractb_28_o[11] Prenorm_addsub_fractb_28_o[12] Prenorm_addsub_fractb_28_o[13] Prenorm_addsub_fractb_28_o[14] Prenorm_addsub_fractb_28_o[15] Prenorm_addsub_fractb_28_o[16] Prenorm_addsub_fractb_28_o[17] Prenorm_addsub_fractb_28_o[18] Prenorm_addsub_fractb_28_o[19] Prenorm_addsub_fractb_28_o[20] Prenorm_addsub_fractb_28_o[21] Prenorm_addsub_fractb_28_o[22] Prenorm_addsub_fractb_28_o[23] Prenorm_addsub_fractb_28_o[24] Prenorm_addsub_fractb_28_o[25] Prenorm_addsub_fractb_28_o[26] SYNOPSYS_UNCONNECTED__1 Prenorm_addsub_exp_o[0] Prenorm_addsub_exp_o[1] Prenorm_addsub_exp_o[2] Prenorm_addsub_exp_o[3] Prenorm_addsub_exp_o[4] Prenorm_addsub_exp_o[5] Prenorm_addsub_exp_o[6] Prenorm_addsub_exp_o[7] pre_norm_addsub
X92 Fpu_op_i[0] Fpu_op_i[1] N268 N480 _NC209 _NC210 NOR3X0
X93 Fpu_op_i[1] N268 Fpu_op_i[0] N470 _NC211 _NC212 AND3X1
X94 Fpu_op_i[0] Fpu_op_i[2] N269 N400 _NC213 _NC214 NOR3X0
X95 Post_norm_div_output[0] N234 Post_norm_mul_output[0] N240 N128 _NC215 _NC216 AO22X1
X96 Postnorm_addsub_output_o[0] N237 Post_norm_sqrt_output[0] N232 N128 N342 _NC217 _NC218 AO221X1
X97 Post_norm_div_output[1] N234 Post_norm_mul_output[1] N240 N127 _NC219 _NC220 AO22X1
X98 Postnorm_addsub_output_o[1] N237 Post_norm_sqrt_output[1] N232 N127 N343 _NC221 _NC222 AO221X1
X99 Post_norm_div_output[2] N234 Post_norm_mul_output[2] N239 N126 _NC223 _NC224 AO22X1
X100 Postnorm_addsub_output_o[2] N236 Post_norm_sqrt_output[2] N232 N126 N344 _NC225 _NC226 AO221X1
X101 Post_norm_div_output[3] N234 Post_norm_mul_output[3] N239 N125 _NC227 _NC228 AO22X1
X102 Postnorm_addsub_output_o[3] N236 Post_norm_sqrt_output[3] N231 N125 N345 _NC229 _NC230 AO221X1
X103 Post_norm_div_output[4] N234 Post_norm_mul_output[4] N239 N124 _NC231 _NC232 AO22X1
X104 Postnorm_addsub_output_o[4] N236 Post_norm_sqrt_output[4] N231 N124 N346 _NC233 _NC234 AO221X1
X105 Post_norm_div_output[5] N234 Post_norm_mul_output[5] N239 N123 _NC235 _NC236 AO22X1
X106 Postnorm_addsub_output_o[5] N236 Post_norm_sqrt_output[5] N231 N123 N347 _NC237 _NC238 AO221X1
X107 Post_norm_div_output[6] N234 Post_norm_mul_output[6] N239 N122 _NC239 _NC240 AO22X1
X108 Postnorm_addsub_output_o[6] N236 Post_norm_sqrt_output[6] N231 N122 N348 _NC241 _NC242 AO221X1
X109 Post_norm_div_output[7] N234 Post_norm_mul_output[7] N239 N121 _NC243 _NC244 AO22X1
X110 Postnorm_addsub_output_o[7] N236 Post_norm_sqrt_output[7] N231 N121 N349 _NC245 _NC246 AO221X1
X111 Post_norm_div_output[8] N234 Post_norm_mul_output[8] N239 N120 _NC247 _NC248 AO22X1
X112 Postnorm_addsub_output_o[8] N236 Post_norm_sqrt_output[8] N231 N120 N350 _NC249 _NC250 AO221X1
X113 Post_norm_div_output[9] N234 Post_norm_mul_output[9] N239 N119 _NC251 _NC252 AO22X1
X114 Postnorm_addsub_output_o[9] N236 Post_norm_sqrt_output[9] N231 N119 N351 _NC253 _NC254 AO221X1
X115 Post_norm_div_output[10] N234 Post_norm_mul_output[10] N239 N118 _NC255 _NC256 AO22X1
X116 Postnorm_addsub_output_o[10] N236 Post_norm_sqrt_output[10] N231 N118 N352 _NC257 _NC258 AO221X1
X117 Post_norm_div_output[11] N234 Post_norm_mul_output[11] N239 N117 _NC259 _NC260 AO22X1
X118 Postnorm_addsub_output_o[11] N236 Post_norm_sqrt_output[11] N231 N117 N353 _NC261 _NC262 AO221X1
X119 Post_norm_div_output[12] N234 Post_norm_mul_output[12] N239 N116 _NC263 _NC264 AO22X1
X120 Postnorm_addsub_output_o[12] N236 Post_norm_sqrt_output[12] N231 N116 N354 _NC265 _NC266 AO221X1
X121 Post_norm_div_output[13] N234 Post_norm_mul_output[13] N239 N115 _NC267 _NC268 AO22X1
X122 Postnorm_addsub_output_o[13] N236 Post_norm_sqrt_output[13] N231 N115 N355 _NC269 _NC270 AO221X1
X123 Post_norm_div_output[14] N234 Post_norm_mul_output[14] N239 N114 _NC271 _NC272 AO22X1
X124 Postnorm_addsub_output_o[14] N236 Post_norm_sqrt_output[14] N231 N114 N356 _NC273 _NC274 AO221X1
X125 Post_norm_div_output[15] N234 Post_norm_mul_output[15] N239 N113 _NC275 _NC276 AO22X1
X126 Postnorm_addsub_output_o[15] N236 Post_norm_sqrt_output[15] N231 N113 N357 _NC277 _NC278 AO221X1
X127 Post_norm_div_output[16] N233 Post_norm_mul_output[16] N239 N112 _NC279 _NC280 AO22X1
X128 Postnorm_addsub_output_o[16] N236 Post_norm_sqrt_output[16] N231 N112 N358 _NC281 _NC282 AO221X1
X129 Post_norm_div_output[17] N233 Post_norm_mul_output[17] N239 N111 _NC283 _NC284 AO22X1
X130 Postnorm_addsub_output_o[17] N236 Post_norm_sqrt_output[17] N231 N111 N359 _NC285 _NC286 AO221X1
X131 Post_norm_div_output[18] N233 Post_norm_mul_output[18] N238 N110 _NC287 _NC288 AO22X1
X132 Postnorm_addsub_output_o[18] N235 Post_norm_sqrt_output[18] N231 N110 N360 _NC289 _NC290 AO221X1
X133 Post_norm_div_output[19] N233 Post_norm_mul_output[19] N238 N109 _NC291 _NC292 AO22X1
X134 Postnorm_addsub_output_o[19] N235 Post_norm_sqrt_output[19] N230 N109 N361 _NC293 _NC294 AO221X1
X135 Post_norm_div_output[20] N233 Post_norm_mul_output[20] N238 N108 _NC295 _NC296 AO22X1
X136 Postnorm_addsub_output_o[20] N235 Post_norm_sqrt_output[20] N230 N108 N362 _NC297 _NC298 AO221X1
X137 Post_norm_div_output[21] N233 Post_norm_mul_output[21] N238 N107 _NC299 _NC300 AO22X1
X138 Postnorm_addsub_output_o[21] N235 Post_norm_sqrt_output[21] N230 N107 N363 _NC301 _NC302 AO221X1
X139 Post_norm_div_output[22] N233 Post_norm_mul_output[22] N238 N106 _NC303 _NC304 AO22X1
X140 Postnorm_addsub_output_o[22] N235 Post_norm_sqrt_output[22] N230 N106 N364 _NC305 _NC306 AO221X1
X141 Post_norm_div_output[23] N233 Post_norm_mul_output[23] N238 N105 _NC307 _NC308 AO22X1
X142 Postnorm_addsub_output_o[23] N235 Post_norm_sqrt_output[23] N230 N105 N365 _NC309 _NC310 AO221X1
X143 Post_norm_div_output[24] N233 Post_norm_mul_output[24] N238 N104 _NC311 _NC312 AO22X1
X144 Postnorm_addsub_output_o[24] N235 Post_norm_sqrt_output[24] N230 N104 N366 _NC313 _NC314 AO221X1
X145 Post_norm_div_output[25] N233 Post_norm_mul_output[25] N238 N103 _NC315 _NC316 AO22X1
X146 Postnorm_addsub_output_o[25] N235 Post_norm_sqrt_output[25] N230 N103 N367 _NC317 _NC318 AO221X1
X147 Post_norm_div_output[26] N233 Post_norm_mul_output[26] N238 N102 _NC319 _NC320 AO22X1
X148 Postnorm_addsub_output_o[26] N235 Post_norm_sqrt_output[26] N230 N102 N368 _NC321 _NC322 AO221X1
X149 Post_norm_div_output[27] N233 Post_norm_mul_output[27] N238 N101 _NC323 _NC324 AO22X1
X150 Postnorm_addsub_output_o[27] N235 Post_norm_sqrt_output[27] N230 N101 N369 _NC325 _NC326 AO221X1
X151 Post_norm_div_output[28] N233 Post_norm_mul_output[28] N238 N100 _NC327 _NC328 AO22X1
X152 Postnorm_addsub_output_o[28] N235 Post_norm_sqrt_output[28] N230 N100 N370 _NC329 _NC330 AO221X1
X153 Post_norm_div_output[29] N233 Post_norm_mul_output[29] N238 N99 _NC331 _NC332 AO22X1
X154 Postnorm_addsub_output_o[29] N235 Post_norm_sqrt_output[29] N230 N99 N371 _NC333 _NC334 AO221X1
X155 Post_norm_div_output[30] N233 Post_norm_mul_output[30] N238 N98 _NC335 _NC336 AO22X1
X156 Postnorm_addsub_output_o[30] N235 Post_norm_sqrt_output[30] N230 N98 N372 _NC337 _NC338 AO221X1
X157 Post_norm_div_output[31] N233 Post_norm_mul_output[31] N238 N97 _NC339 _NC340 AO22X1
X158 Postnorm_addsub_output_o[31] N235 Post_norm_sqrt_output[31] N230 N97 N373 _NC341 _NC342 AO221X1
X159 Post_norm_div_ine N233 Post_norm_mul_ine N238 N96 _NC343 _NC344 AO22X1
X160 Postnorm_addsub_ine_o N235 Post_norm_sqrt_ine_o N230 N96 N374 _NC345 _NC346 AO221X1
X161 S_output_o[30] S_output_o[29] S_output_o[28] S_output_o[27] N95 _NC347 _NC348 NOR4X0
X162 N207 N216 N94 N95 N590 _NC349 _NC350 NAND4X0
X163 S_output_o[27] S_output_o[28] N91 _NC351 _NC352 AND2X1
X164 S_output1[21] S_output_o[24] S_output_o[25] S_output_o[26] N92 _NC353 _NC354 AND4X1
X165 S_output_o[30] S_output_o[29] N91 N92 N28 _NC355 _NC356 NAND4X0
X166 N159 N160 N155 N156 N89 _NC357 _NC358 NOR4X0
X167 S_opb_i[30] S_opb_i[29] N88 N89 N26 _NC359 _NC360 AND4X1
X168 N26 N140 S_opb_i[0] N87 _NC361 _NC362 NAND3X0
X169 N87 S_opb_i[11] S_opb_i[13] S_opb_i[12] N80 _NC363 _NC364 NOR4X0
X170 N132 N133 N131 N86 _NC365 _NC366 NAND3X0
X171 N86 S_opb_i[14] S_opb_i[16] S_opb_i[15] N81 _NC367 _NC368 NOR4X0
X172 N135 N136 N134 N85 _NC369 _NC370 NAND3X0
X173 N85 S_opb_i[1] S_opb_i[21] S_opb_i[20] N82 _NC371 _NC372 NOR4X0
X174 N138 N139 N137 N84 _NC373 _NC374 NAND3X0
X175 N84 S_opb_i[4] S_opb_i[6] S_opb_i[5] N83 _NC375 _NC376 NOR4X0
X176 N80 N81 N82 N83 N68 _NC377 _NC378 NAND4X0
X177 N161 N162 N151 N152 N79 _NC379 _NC380 NOR4X0
X178 N223 N264 N78 N79 N25 _NC381 _NC382 AND4X1
X179 N25 N150 S_opa_i[0] N77 _NC383 _NC384 NAND3X0
X180 N77 N256 N257 N226 N70 _NC385 _NC386 NOR4X0
X181 N142 N143 N141 N76 _NC387 _NC388 NAND3X0
X182 N76 N258 N260 N259 N71 _NC389 _NC390 NOR4X0
X183 N145 N146 N144 N75 _NC391 _NC392 NAND3X0
X184 N75 N246 S_opa_i[21] N229 N72 _NC393 _NC394 NOR4X0
X185 N148 N149 N147 N74 _NC395 _NC396 NAND3X0
X186 N74 N249 N251 N250 N73 _NC397 _NC398 NOR4X0
X187 N70 N71 N72 N73 N69 _NC399 _NC400 NAND4X0
X188 N67 S_output1[9] S_output1[11] S_output1[10] N600 _NC401 _NC402 NOR4X0
X189 N212 N205 N200 N660 _NC403 _NC404 NAND3X0
X190 N660 S_output1[12] S_output1[14] S_output1[13] N610 _NC405 _NC406 NOR4X0
X191 N650 S_output1[19] S_output1[1] S_output1[0] N620 _NC407 _NC408 NOR4X0
X192 N213 N206 N201 N640 _NC409 _NC410 NAND3X0
X193 N640 S_output1[2] S_output1[4] S_output1[3] N630 _NC411 _NC412 NOR4X0
X194 N600 N610 N620 N630 N580 _NC413 _NC414 NAND4X0
X195 N580 N28 N214 N198 _NC415 _NC416 NOR3X0
X196 N28 N581 N198 N549 _NC417 _NC418 NOR3X0
X197 N580 S_output1[20] N590 N199 _NC419 _NC420 NOR3X0
X198 Serial_div_div_zero N233 N197 _NC421 _NC422 AND2X1
X199 S_count[14] S_count[15] S_count[13] N570 _NC423 _NC424 OR3X1
X200 N570 S_count[10] S_count[12] S_count[11] N500 _NC425 _NC426 NOR4X0
X201 S_count[19] S_count[20] S_count[21] S_count[22] N560 _NC427 _NC428 OR4X1
X202 N560 S_count[16] S_count[18] S_count[17] N510 _NC429 _NC430 NOR4X0
X203 S_count[26] S_count[27] S_count[28] S_count[29] N550 _NC431 _NC432 OR4X1
X204 N550 S_count[23] S_count[25] S_count[24] N520 _NC433 _NC434 NOR4X0
X205 S_count[6] S_count[7] S_count[8] S_count[9] N540 _NC435 _NC436 OR4X1
X206 N540 S_count[30] S_count[4] S_count[31] N530 _NC437 _NC438 NOR4X0
X207 N500 N510 N520 N530 N440 _NC439 _NC440 AND4X1
X208 N440 N208 S_count[0] N410 _NC441 _NC442 AND3X1
X209 N233 N230 N450 _NC443 _NC444 OR2X1
X210 S_count[2] N235 N430 N440 N375 _NC445 _NC446 NAND4X0
X211 N238 N410 S_count[3] N380 _NC447 _NC448 NAND3X0
X212 S_state S_start_i N33 _NC449 _NC450 OR2X1
X213 N267 N218 Ready_o N33 N195 _NC451 _NC452 AO22X1
X214 S_start_i S_state N267 N29 _NC453 _NC454 NOR3X0
X215 N244 S_start_i N267 N30 _NC455 _NC456 NOR3X0
X216 N244 S_count[0] N35 N243 N196 _NC457 _NC458 AO22X1
X217 S_count[10] N244 N45 N243 N183 _NC459 _NC460 AO22X1
X218 S_count[11] N244 N46 N243 N182 _NC461 _NC462 AO22X1
X219 S_count[12] N244 N47 N243 N181 _NC463 _NC464 AO22X1
X220 S_count[13] N244 N48 N243 N180 _NC465 _NC466 AO22X1
X221 S_count[14] N244 N49 N243 N179 _NC467 _NC468 AO22X1
X222 S_count[15] N244 N50 N243 N178 _NC469 _NC470 AO22X1
X223 S_count[16] N244 N51 N243 N177 _NC471 _NC472 AO22X1
X224 S_count[17] N244 N52 N242 N176 _NC473 _NC474 AO22X1
X225 S_count[18] N244 N53 N242 N175 _NC475 _NC476 AO22X1
X226 S_count[19] N244 N54 N242 N174 _NC477 _NC478 AO22X1
X227 N244 S_count[1] N36 N242 N192 _NC479 _NC480 AO22X1
X228 S_count[20] N244 N55 N242 N173 _NC481 _NC482 AO22X1
X229 S_count[21] N244 N56 N242 N172 _NC483 _NC484 AO22X1
X230 S_count[22] N244 N57 N242 N171 _NC485 _NC486 AO22X1
X231 S_count[23] N245 N58 N242 N170 _NC487 _NC488 AO22X1
X232 S_count[24] N245 N59 N242 N169 _NC489 _NC490 AO22X1
X233 S_count[25] N245 N60 N242 N168 _NC491 _NC492 AO22X1
X234 S_count[26] N245 N61 N242 N167 _NC493 _NC494 AO22X1
X235 S_count[27] N245 N62 N242 N166 _NC495 _NC496 AO22X1
X236 S_count[28] N245 N63 N241 N165 _NC497 _NC498 AO22X1
X237 S_count[29] N245 N64 N241 N164 _NC499 _NC500 AO22X1
X238 N244 S_count[2] N37 N241 N191 _NC501 _NC502 AO22X1
X239 S_count[30] N245 N65 N241 N163 _NC503 _NC504 AO22X1
X240 S_count[31] N245 N66 N241 N193 _NC505 _NC506 AO22X1
X241 N244 S_count[3] N38 N241 N190 _NC507 _NC508 AO22X1
X242 S_count[4] N245 N39 N241 N189 _NC509 _NC510 AO22X1
X243 N244 S_count[5] N40 N241 N188 _NC511 _NC512 AO22X1
X244 S_count[6] N245 N41 N241 N187 _NC513 _NC514 AO22X1
X245 S_count[7] N245 N42 N241 N186 _NC515 _NC516 AO22X1
X246 S_count[8] N245 N43 N241 N185 _NC517 _NC518 AO22X1
X247 S_count[9] N244 N44 N241 N184 _NC519 _NC520 AO22X1
X248 S_rmode_i[0] N27 N24 _NC521 _NC522 XNOR2X1
X249 N198 N25 N26 N197 N9 _NC523 _NC524 NOR4X0
X250 S_output1[9] N266 S_output_o[11] _NC525 _NC526 OR2X1
X251 S_output1[10] N266 S_output_o[12] _NC527 _NC528 OR2X1
X252 S_output1[11] N266 S_output_o[13] _NC529 _NC530 OR2X1
X253 S_output1[12] N266 S_output_o[14] _NC531 _NC532 OR2X1
X254 S_output1[13] N266 S_output_o[15] _NC533 _NC534 OR2X1
X255 S_output1[14] N266 S_output_o[16] _NC535 _NC536 OR2X1
X256 S_output1[19] N266 S_output_o[21] _NC537 _NC538 OR2X1
X257 S_output1[0] N266 S_output_o[2] _NC539 _NC540 OR2X1
X258 S_opb_i[31] S_fpu_op_i[0] N13 _NC541 _NC542 XOR2X1
X259 S_fpu_op_i[2] S_fpu_op_i[1] N11 N215 N10 _NC543 _NC544 NOR4X0
X260 S_output1[1] N266 S_output_o[3] _NC545 _NC546 OR2X1
X261 S_output1[2] N266 S_output_o[4] _NC547 _NC548 OR2X1
X262 S_output1[3] N266 S_output_o[5] _NC549 _NC550 OR2X1
X263 S_output1[4] N266 S_output_o[6] _NC551 _NC552 OR2X1
X264 S_state N1 S_start_i N194 _NC553 _NC554 AO21X1
X265 Clk_i N163 S_count[30] _NC555 _NC556 _NC557 DFFX1
X266 Clk_i N164 S_count[29] _NC558 _NC559 _NC560 DFFX1
X267 Clk_i N165 S_count[28] _NC561 _NC562 _NC563 DFFX1
X268 Clk_i N166 S_count[27] _NC564 _NC565 _NC566 DFFX1
X269 Clk_i N167 S_count[26] _NC567 _NC568 _NC569 DFFX1
X270 Clk_i N168 S_count[25] _NC570 _NC571 _NC572 DFFX1
X271 Clk_i N169 S_count[24] _NC573 _NC574 _NC575 DFFX1
X272 Clk_i N170 S_count[23] _NC576 _NC577 _NC578 DFFX1
X273 Clk_i N171 S_count[22] _NC579 _NC580 _NC581 DFFX1
X274 Clk_i N172 S_count[21] _NC582 _NC583 _NC584 DFFX1
X275 Clk_i N173 S_count[20] _NC585 _NC586 _NC587 DFFX1
X276 Clk_i N174 S_count[19] _NC588 _NC589 _NC590 DFFX1
X277 Clk_i N175 S_count[18] _NC591 _NC592 _NC593 DFFX1
X278 Clk_i N176 S_count[17] _NC594 _NC595 _NC596 DFFX1
X279 Clk_i N177 S_count[16] _NC597 _NC598 _NC599 DFFX1
X280 Clk_i N178 S_count[15] _NC600 _NC601 _NC602 DFFX1
X281 Clk_i N179 S_count[14] _NC603 _NC604 _NC605 DFFX1
X282 Clk_i N180 S_count[13] _NC606 _NC607 _NC608 DFFX1
X283 Clk_i N181 S_count[12] _NC609 _NC610 _NC611 DFFX1
X284 Clk_i N182 S_count[11] _NC612 _NC613 _NC614 DFFX1
X285 Clk_i N183 S_count[10] _NC615 _NC616 _NC617 DFFX1
X286 Clk_i N184 S_count[9] _NC618 _NC619 _NC620 DFFX1
X287 Clk_i N185 S_count[8] _NC621 _NC622 _NC623 DFFX1
X288 Clk_i N186 S_count[7] _NC624 _NC625 _NC626 DFFX1
X289 Clk_i N187 S_count[6] _NC627 _NC628 _NC629 DFFX1
X290 Clk_i N188 S_count[5] N219 _NC630 _NC631 DFFX1
X291 Clk_i N189 S_count[4] _NC632 _NC633 _NC634 DFFX1
X292 Clk_i N190 S_count[3] N209 _NC635 _NC636 DFFX1
X293 Clk_i N191 S_count[2] N208 _NC637 _NC638 DFFX1
X294 Clk_i N192 S_count[1] N202 _NC639 _NC640 DFFX1
X295 Clk_i N193 S_count[31] _NC641 _NC642 _NC643 DFFX1
X296 Clk_i N194 S_state _NC644 _NC645 _NC646 DFFX1
X297 Clk_i N195 Ready_o _NC647 _NC648 _NC649 DFFX1
X298 Clk_i N196 S_count[0] _NC650 _NC651 _NC652 DFFX1
X299 Clk_i N198 Qnan_o _NC653 _NC654 _NC655 DFFX1
X300 Clk_i N549 Inf_o _NC656 _NC657 _NC658 DFFX1
X301 Clk_i S_output_o[0] Output_o[0] _NC659 _NC660 _NC661 DFFX1
X302 Clk_i S_output_o[10] Output_o[10] _NC662 _NC663 _NC664 DFFX1
X303 Clk_i S_output_o[17] Output_o[17] _NC665 _NC666 _NC667 DFFX1
X304 Clk_i S_output_o[18] Output_o[18] _NC668 _NC669 _NC670 DFFX1
X305 Clk_i S_output_o[19] Output_o[19] _NC671 _NC672 _NC673 DFFX1
X306 Clk_i S_output_o[1] Output_o[1] _NC674 _NC675 _NC676 DFFX1
X307 Clk_i S_output_o[20] Output_o[20] _NC677 _NC678 _NC679 DFFX1
X308 Clk_i S_output_o[22] Output_o[22] _NC680 _NC681 _NC682 DFFX1
X309 Clk_i S_output_o[7] Output_o[7] _NC683 _NC684 _NC685 DFFX1
X310 Clk_i S_output_o[8] Output_o[8] _NC686 _NC687 _NC688 DFFX1
X311 Clk_i S_output_o[9] Output_o[9] _NC689 _NC690 _NC691 DFFX1
X312 Clk_i S_output_o[6] Output_o[6] _NC692 _NC693 _NC694 DFFX1
X313 Clk_i S_output_o[5] Output_o[5] _NC695 _NC696 _NC697 DFFX1
X314 Clk_i S_output_o[4] Output_o[4] _NC698 _NC699 _NC700 DFFX1
X315 Clk_i S_output_o[3] Output_o[3] _NC701 _NC702 _NC703 DFFX1
X316 Clk_i S_output_o[2] Output_o[2] _NC704 _NC705 _NC706 DFFX1
X317 Clk_i S_output_o[21] Output_o[21] _NC707 _NC708 _NC709 DFFX1
X318 Clk_i S_output_o[16] Output_o[16] _NC710 _NC711 _NC712 DFFX1
X319 Clk_i S_output_o[15] Output_o[15] _NC713 _NC714 _NC715 DFFX1
X320 Clk_i S_output_o[14] Output_o[14] _NC716 _NC717 _NC718 DFFX1
X321 Clk_i S_output_o[13] Output_o[13] _NC719 _NC720 _NC721 DFFX1
X322 Clk_i S_output_o[12] Output_o[12] _NC722 _NC723 _NC724 DFFX1
X323 Clk_i S_output_o[11] Output_o[11] _NC725 _NC726 _NC727 DFFX1
X324 Clk_i S_output_o[23] Output_o[23] _NC728 _NC729 _NC730 DFFX1
X325 Clk_i S_output_o[31] Output_o[31] _NC731 _NC732 _NC733 DFFX1
X326 Clk_i N199 Zero_o _NC734 _NC735 _NC736 DFFX1
X327 Clk_i N342 _NC737 N210 _NC738 _NC739 DFFX1
X328 Clk_i N343 _NC740 N211 _NC741 _NC742 DFFX1
X329 Clk_i N344 S_output1[0] _NC743 _NC744 _NC745 DFFX1
X330 Clk_i N345 S_output1[1] _NC746 _NC747 _NC748 DFFX1
X331 Clk_i N346 S_output1[2] _NC749 _NC750 _NC751 DFFX1
X332 Clk_i N347 S_output1[3] _NC752 _NC753 _NC754 DFFX1
X333 Clk_i N348 S_output1[4] _NC755 _NC756 _NC757 DFFX1
X334 Clk_i N349 _NC758 N201 _NC759 _NC760 DFFX1
X335 Clk_i N350 _NC761 N213 _NC762 _NC763 DFFX1
X336 Clk_i N351 _NC764 N206 _NC765 _NC766 DFFX1
X337 Clk_i N352 _NC767 N203 _NC768 _NC769 DFFX1
X338 Clk_i N353 S_output1[9] _NC770 _NC771 _NC772 DFFX1
X339 Clk_i N354 S_output1[10] _NC773 _NC774 _NC775 DFFX1
X340 Clk_i N355 S_output1[11] _NC776 _NC777 _NC778 DFFX1
X341 Clk_i N356 S_output1[12] _NC779 _NC780 _NC781 DFFX1
X342 Clk_i N357 S_output1[13] _NC782 _NC783 _NC784 DFFX1
X343 Clk_i N358 S_output1[14] _NC785 _NC786 _NC787 DFFX1
X344 Clk_i N359 _NC788 N200 _NC789 _NC790 DFFX1
X345 Clk_i N360 _NC791 N212 _NC792 _NC793 DFFX1
X346 Clk_i N361 _NC794 N205 _NC795 _NC796 DFFX1
X347 Clk_i N362 _NC797 N204 _NC798 _NC799 DFFX1
X348 Clk_i N363 S_output1[19] _NC800 _NC801 _NC802 DFFX1
X349 Clk_i N364 S_output1[20] N214 _NC803 _NC804 DFFX1
X350 Clk_i N547 Overflow_o _NC805 _NC806 _NC807 DFFX1
X351 Clk_i N546 Underflow_o _NC808 _NC809 _NC810 DFFX1
X352 Clk_i N365 S_output1[21] N207 _NC811 _NC812 DFFX1
X353 Clk_i S_output_o[24] Output_o[24] _NC813 _NC814 _NC815 DFFX1
X354 Clk_i N366 S_output_o[24] N216 _NC816 _NC817 DFFX1
X355 Clk_i S_output_o[25] Output_o[25] _NC818 _NC819 _NC820 DFFX1
X356 Clk_i N367 S_output_o[25] _NC821 _NC822 _NC823 DFFX1
X357 Clk_i S_output_o[26] Output_o[26] _NC824 _NC825 _NC826 DFFX1
X358 Clk_i N368 S_output_o[26] _NC827 _NC828 _NC829 DFFX1
X359 Clk_i S_output_o[27] Output_o[27] _NC830 _NC831 _NC832 DFFX1
X360 Clk_i N369 S_output_o[27] _NC833 _NC834 _NC835 DFFX1
X361 Clk_i S_output_o[28] Output_o[28] _NC836 _NC837 _NC838 DFFX1
X362 Clk_i N370 S_output_o[28] _NC839 _NC840 _NC841 DFFX1
X363 Clk_i S_output_o[29] Output_o[29] _NC842 _NC843 _NC844 DFFX1
X364 Clk_i N371 S_output_o[29] _NC845 _NC846 _NC847 DFFX1
X365 Clk_i S_output_o[30] Output_o[30] _NC848 _NC849 _NC850 DFFX1
X366 Clk_i N372 S_output_o[30] _NC851 _NC852 _NC853 DFFX1
X367 Clk_i N373 S_output1[29] _NC854 _NC855 _NC856 DFFX1
X368 Clk_i S_ine_o Ine_o _NC857 _NC858 _NC859 DFFX1
X369 Clk_i N374 S_ine_o N217 _NC860 _NC861 DFFX1
X370 Clk_i N581 Snan_o _NC862 _NC863 _NC864 DFFX1
X371 Clk_i N197 Div_zero_o _NC865 _NC866 _NC867 DFFX1
X372 Clk_i Start_i S_start_i N218 _NC868 _NC869 DFFX1
X373 Clk_i Rmode_i[0] S_rmode_i[0] _NC870 _NC871 _NC872 DFFX1
X374 Clk_i Rmode_i[1] S_rmode_i[1] N215 _NC873 _NC874 DFFX1
X375 Clk_i Fpu_op_i[0] S_fpu_op_i[0] _NC875 _NC876 _NC877 DFFX1
X376 Clk_i Fpu_op_i[1] S_fpu_op_i[1] _NC878 _NC879 _NC880 DFFX1
X377 Clk_i Fpu_op_i[2] S_fpu_op_i[2] _NC881 _NC882 _NC883 DFFX1
X378 Clk_i Opb_i[0] S_opb_i[0] _NC884 _NC885 _NC886 DFFX1
X379 Clk_i Opb_i[1] S_opb_i[1] _NC887 _NC888 _NC889 DFFX1
X380 Clk_i Opb_i[2] S_opb_i[2] N135 _NC890 _NC891 DFFX1
X381 Clk_i Opb_i[3] S_opb_i[3] N136 _NC892 _NC893 DFFX1
X382 Clk_i Opb_i[4] S_opb_i[4] _NC894 _NC895 _NC896 DFFX1
X383 Clk_i Opb_i[5] S_opb_i[5] _NC897 _NC898 _NC899 DFFX1
X384 Clk_i Opb_i[6] S_opb_i[6] _NC900 _NC901 _NC902 DFFX1
X385 Clk_i Opb_i[7] S_opb_i[7] N137 _NC903 _NC904 DFFX1
X386 Clk_i Opb_i[8] S_opb_i[8] N138 _NC905 _NC906 DFFX1
X387 Clk_i Opb_i[9] S_opb_i[9] N139 _NC907 _NC908 DFFX1
X388 Clk_i Opb_i[10] S_opb_i[10] N140 _NC909 _NC910 DFFX1
X389 Clk_i Opb_i[11] S_opb_i[11] _NC911 _NC912 _NC913 DFFX1
X390 Clk_i Opb_i[12] S_opb_i[12] _NC914 _NC915 _NC916 DFFX1
X391 Clk_i Opb_i[13] S_opb_i[13] _NC917 _NC918 _NC919 DFFX1
X392 Clk_i Opb_i[14] S_opb_i[14] _NC920 _NC921 _NC922 DFFX1
X393 Clk_i Opb_i[15] S_opb_i[15] _NC923 _NC924 _NC925 DFFX1
X394 Clk_i Opb_i[16] S_opb_i[16] _NC926 _NC927 _NC928 DFFX1
X395 Clk_i Opb_i[17] S_opb_i[17] N131 _NC929 _NC930 DFFX1
X396 Clk_i Opb_i[18] S_opb_i[18] N132 _NC931 _NC932 DFFX1
X397 Clk_i Opb_i[19] S_opb_i[19] N133 _NC933 _NC934 DFFX1
X398 Clk_i Opb_i[20] S_opb_i[20] _NC935 _NC936 _NC937 DFFX1
X399 Clk_i Opb_i[21] S_opb_i[21] _NC938 _NC939 _NC940 DFFX1
X400 Clk_i Opb_i[22] S_opb_i[22] N134 _NC941 _NC942 DFFX1
X401 Clk_i Opb_i[23] S_opb_i[23] N159 _NC943 _NC944 DFFX1
X402 Clk_i Opb_i[24] S_opb_i[24] N160 _NC945 _NC946 DFFX1
X403 Clk_i Opb_i[25] S_opb_i[25] N155 _NC947 _NC948 DFFX1
X404 Clk_i Opb_i[26] S_opb_i[26] N156 _NC949 _NC950 DFFX1
X405 Clk_i Opb_i[27] S_opb_i[27] N157 _NC951 _NC952 DFFX1
X406 Clk_i Opb_i[28] S_opb_i[28] N158 _NC953 _NC954 DFFX1
X407 Clk_i Opb_i[29] S_opb_i[29] _NC955 _NC956 _NC957 DFFX1
X408 Clk_i Opb_i[30] S_opb_i[30] _NC958 _NC959 _NC960 DFFX1
X409 Clk_i Opb_i[31] S_opb_i[31] _NC961 _NC962 _NC963 DFFX1
X410 Clk_i Opa_i[0] S_opa_i[0] _NC964 _NC965 _NC966 DFFX1
X411 Clk_i Opa_i[1] S_opa_i[1] _NC967 _NC968 _NC969 DFFX1
X412 Clk_i Opa_i[2] S_opa_i[2] N145 _NC970 _NC971 DFFX1
X413 Clk_i Opa_i[3] S_opa_i[3] N146 _NC972 _NC973 DFFX1
X414 Clk_i Opa_i[4] S_opa_i[4] _NC974 _NC975 _NC976 DFFX1
X415 Clk_i Opa_i[5] S_opa_i[5] _NC977 _NC978 _NC979 DFFX1
X416 Clk_i Opa_i[6] S_opa_i[6] _NC980 _NC981 _NC982 DFFX1
X417 Clk_i Opa_i[7] S_opa_i[7] N147 _NC983 _NC984 DFFX1
X418 Clk_i Opa_i[8] S_opa_i[8] N148 _NC985 _NC986 DFFX1
X419 Clk_i Opa_i[9] S_opa_i[9] N149 _NC987 _NC988 DFFX1
X420 Clk_i Opa_i[10] S_opa_i[10] N150 _NC989 _NC990 DFFX1
X421 Clk_i Opa_i[11] S_opa_i[11] _NC991 _NC992 _NC993 DFFX1
X422 Clk_i Opa_i[12] S_opa_i[12] _NC994 _NC995 _NC996 DFFX1
X423 Clk_i Opa_i[13] S_opa_i[13] _NC997 _NC998 _NC999 DFFX1
X424 Clk_i Opa_i[14] S_opa_i[14] _NC1000 _NC1001 _NC1002 DFFX1
X425 Clk_i Opa_i[15] S_opa_i[15] _NC1003 _NC1004 _NC1005 DFFX1
X426 Clk_i Opa_i[16] S_opa_i[16] _NC1006 _NC1007 _NC1008 DFFX1
X427 Clk_i Opa_i[17] S_opa_i[17] N141 _NC1009 _NC1010 DFFX1
X428 Clk_i Opa_i[18] S_opa_i[18] N142 _NC1011 _NC1012 DFFX1
X429 Clk_i Opa_i[19] S_opa_i[19] N143 _NC1013 _NC1014 DFFX1
X430 Clk_i Opa_i[20] S_opa_i[20] _NC1015 _NC1016 _NC1017 DFFX1
X431 Clk_i Opa_i[21] S_opa_i[21] _NC1018 _NC1019 _NC1020 DFFX1
X432 Clk_i Opa_i[22] S_opa_i[22] N144 _NC1021 _NC1022 DFFX1
X433 Clk_i Opa_i[23] S_opa_i[23] N161 _NC1023 _NC1024 DFFX1
X434 Clk_i Opa_i[24] S_opa_i[24] N162 _NC1025 _NC1026 DFFX1
X435 Clk_i Opa_i[25] S_opa_i[25] N151 _NC1027 _NC1028 DFFX1
X436 Clk_i Opa_i[26] S_opa_i[26] N152 _NC1029 _NC1030 DFFX1
X437 Clk_i Opa_i[27] S_opa_i[27] N153 _NC1031 _NC1032 DFFX1
X438 Clk_i Opa_i[28] S_opa_i[28] N154 _NC1033 _NC1034 DFFX1
X439 Clk_i Opa_i[29] S_opa_i[29] _NC1035 _NC1036 _NC1037 DFFX1
X440 Clk_i Opa_i[30] S_opa_i[30] _NC1038 _NC1039 _NC1040 DFFX1
X441 Clk_i Opa_i[31] S_opa_i[31] _NC1041 _NC1042 _NC1043 DFFX1
.ENDS fpu

.SUBCKT fpu_DW01_inc_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] SUM[28] SUM[29] SUM[30] SUM[31]
X0 A[0] _NC0 _NC1 SUM[0] INVX0
X1 Carry[29] A[31] SUM[31] _NC2 _NC3 XOR2X1
X2 A[1] A[0] Carry[0] _NC4 _NC5 _NC6 HADDX1
X3 A[2] Carry[0] Carry[1] _NC7 _NC8 _NC9 HADDX1
X4 A[3] Carry[1] Carry[2] _NC10 _NC11 _NC12 HADDX1
X5 A[4] Carry[2] Carry[3] _NC13 _NC14 _NC15 HADDX1
X6 A[5] Carry[3] Carry[4] _NC16 _NC17 _NC18 HADDX1
X7 A[6] Carry[4] Carry[5] _NC19 _NC20 _NC21 HADDX1
X8 A[7] Carry[5] Carry[6] _NC22 _NC23 _NC24 HADDX1
X9 A[8] Carry[6] Carry[7] _NC25 _NC26 _NC27 HADDX1
X10 A[9] Carry[7] Carry[8] _NC28 _NC29 _NC30 HADDX1
X11 A[10] Carry[8] Carry[9] _NC31 _NC32 _NC33 HADDX1
X12 A[11] Carry[9] Carry[10] _NC34 _NC35 _NC36 HADDX1
X13 A[12] Carry[10] Carry[11] _NC37 _NC38 _NC39 HADDX1
X14 A[13] Carry[11] Carry[12] _NC40 _NC41 _NC42 HADDX1
X15 A[14] Carry[12] Carry[13] _NC43 _NC44 _NC45 HADDX1
X16 A[15] Carry[13] Carry[14] _NC46 _NC47 _NC48 HADDX1
X17 A[16] Carry[14] Carry[15] _NC49 _NC50 _NC51 HADDX1
X18 A[17] Carry[15] Carry[16] _NC52 _NC53 _NC54 HADDX1
X19 A[18] Carry[16] Carry[17] _NC55 _NC56 _NC57 HADDX1
X20 A[19] Carry[17] Carry[18] _NC58 _NC59 _NC60 HADDX1
X21 A[20] Carry[18] Carry[19] _NC61 _NC62 _NC63 HADDX1
X22 A[21] Carry[19] Carry[20] _NC64 _NC65 _NC66 HADDX1
X23 A[22] Carry[20] Carry[21] _NC67 _NC68 _NC69 HADDX1
X24 A[23] Carry[21] Carry[22] _NC70 _NC71 _NC72 HADDX1
X25 A[24] Carry[22] Carry[23] _NC73 _NC74 _NC75 HADDX1
X26 A[25] Carry[23] Carry[24] _NC76 _NC77 _NC78 HADDX1
X27 A[26] Carry[24] Carry[25] _NC79 _NC80 _NC81 HADDX1
X28 A[27] Carry[25] Carry[26] _NC82 _NC83 _NC84 HADDX1
X29 A[28] Carry[26] Carry[27] _NC85 _NC86 _NC87 HADDX1
X30 A[29] Carry[27] Carry[28] _NC88 _NC89 _NC90 HADDX1
X31 A[30] Carry[28] Carry[29] _NC91 _NC92 _NC93 HADDX1
.ENDS fpu_DW01_inc_0

.SUBCKT post_norm_sqrt Clk_i Opa_i[0] Opa_i[1] Opa_i[2] Opa_i[3] Opa_i[4] Opa_i[5] Opa_i[6] Opa_i[7] Opa_i[8] Opa_i[9] Opa_i[10] Opa_i[11] Opa_i[12] Opa_i[13] Opa_i[14] Opa_i[15] Opa_i[16] Opa_i[17] Opa_i[18] Opa_i[19] Opa_i[20] Opa_i[21] Opa_i[22] Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Opa_i[31] Fract_26_i[0] Fract_26_i[1] Fract_26_i[2] Fract_26_i[3] Fract_26_i[4] Fract_26_i[5] Fract_26_i[6] Fract_26_i[7] Fract_26_i[8] Fract_26_i[9] Fract_26_i[10] Fract_26_i[11] Fract_26_i[12] Fract_26_i[13] Fract_26_i[14] Fract_26_i[15] Fract_26_i[16] Fract_26_i[17] Fract_26_i[18] Fract_26_i[19] Fract_26_i[20] Fract_26_i[21] Fract_26_i[22] Fract_26_i[23] Fract_26_i[24] Fract_26_i[25] Exp_i[0] Exp_i[1] Exp_i[2] Exp_i[3] Exp_i[4] Exp_i[5] Exp_i[6] Exp_i[7] Ine_i Rmode_i[0] Rmode_i[1] Output_o[0] Output_o[1] Output_o[2] Output_o[3] Output_o[4] Output_o[5] Output_o[6] Output_o[7] Output_o[8] Output_o[9] Output_o[10] Output_o[11] Output_o[12] Output_o[13] Output_o[14] Output_o[15] Output_o[16] Output_o[17] Output_o[18] Output_o[19] Output_o[20] Output_o[21] Output_o[22] Output_o[23] Output_o[24] Output_o[25] Output_o[26] Output_o[27] Output_o[28] Output_o[29] Output_o[30] Output_o[31] Ine_o
X0 S_output_o[31] N360 N280 _NC0 _NC1 NAND2X1
X1 S_rmode_i[1] N23 N340 _NC2 _NC3 NAND2X1
X2 S_output_o[31] N340 N350 N310 _NC4 _NC5 OA21X1
X3 N300 N310 N320 N290 _NC6 _NC7 OA21X1
X4 N470 N480 N260 _NC8 _NC9 NOR2X0
X5 N260 _NC10 _NC11 N500 INVX0
X6 N290 _NC12 _NC13 N19 INVX0
X7 N250 N260 N18 _NC14 _NC15 NOR2X0
X8 N250 N260 N1 _NC16 _NC17 NOR2X0
X9 N250 N260 N24 _NC18 _NC19 NOR2X0
X10 N280 _NC20 _NC21 N490 INVX0
X11 N250 _NC22 _NC23 N20 INVX0
X12 N24 _NC24 _NC25 N21 INVX0
X13 S_fract_26_i[2] S_fract_26_i[3] S_fract_26_i[4] S_fract_26_i[5] S_fract_26_i[6] S_fract_26_i[7] S_fract_26_i[8] S_fract_26_i[9] S_fract_26_i[10] S_fract_26_i[11] S_fract_26_i[12] S_fract_26_i[13] S_fract_26_i[14] S_fract_26_i[15] S_fract_26_i[16] S_fract_26_i[17] S_fract_26_i[18] S_fract_26_i[19] S_fract_26_i[20] S_fract_26_i[21] S_fract_26_i[22] S_fract_26_i[23] S_fract_26_i[24] N25 N26 N27 N28 N29 N30 N31 N32 N33 N34 N35 N36 N37 N38 N39 N40 N41 N42 N43 N44 N45 N46 N47 post_norm_sqrt_DW01_inc_0
X14 S_expa[3] S_expa[2] S_expa[1] S_expa[0] N470 _NC26 _NC27 NAND4X0
X15 S_expa[7] S_expa[6] S_expa[5] S_expa[4] N480 _NC28 _NC29 NAND4X0
X16 S_opa_i[30] S_opa_i[29] S_opa_i[28] N370 _NC30 _NC31 OR3X1
X17 S_opa_i[10] S_opa_i[0] N460 _NC32 _NC33 OR2X1
X18 N460 S_opa_i[11] S_opa_i[13] S_opa_i[12] N390 _NC34 _NC35 NOR4X0
X19 S_opa_i[19] S_opa_i[18] S_opa_i[17] N450 _NC36 _NC37 OR3X1
X20 N450 S_opa_i[14] S_opa_i[16] S_opa_i[15] N400 _NC38 _NC39 NOR4X0
X21 S_opa_i[3] S_opa_i[2] S_opa_i[22] N440 _NC40 _NC41 OR3X1
X22 N440 S_opa_i[1] S_opa_i[21] S_opa_i[20] N410 _NC42 _NC43 NOR4X0
X23 S_opa_i[9] S_opa_i[8] S_opa_i[7] N430 _NC44 _NC45 OR3X1
X24 N430 S_opa_i[4] S_opa_i[6] S_opa_i[5] N420 _NC46 _NC47 NOR4X0
X25 N390 N400 N410 N420 N270 _NC48 _NC49 NAND4X0
X26 S_opa_i[23] N270 S_opa_i[25] S_opa_i[24] N380 _NC50 _NC51 OR4X1
X27 S_opa_i[27] S_opa_i[26] N370 N380 N360 _NC52 _NC53 OR4X1
X28 S_ine_i N500 N280 N134 _NC54 _NC55 AND3X1
X29 S_fract_26_i[0] S_ine_i S_fract_26_i[1] N300 _NC56 _NC57 NOR3X0
X30 S_output_o[31] N340 S_rmode_i[1] N350 _NC58 _NC59 NAND3X0
X31 S_fract_26_i[3] S_ine_i S_fract_26_i[0] N330 _NC60 _NC61 OR3X1
X32 S_fract_26_i[1] N330 N23 N22 N320 _NC62 _NC63 NAND4X0
X33 N25 N19 S_fract_26_i[2] N290 N48 _NC64 _NC65 AO22X1
X34 N26 N19 S_fract_26_i[3] N290 N49 _NC66 _NC67 AO22X1
X35 N27 N19 S_fract_26_i[4] N290 N50 _NC68 _NC69 AO22X1
X36 N28 N19 S_fract_26_i[5] N290 N51 _NC70 _NC71 AO22X1
X37 N29 N19 S_fract_26_i[6] N290 N52 _NC72 _NC73 AO22X1
X38 N30 N19 S_fract_26_i[7] N290 N53 _NC74 _NC75 AO22X1
X39 N31 N19 S_fract_26_i[8] N290 N54 _NC76 _NC77 AO22X1
X40 N32 N19 S_fract_26_i[9] N290 N55 _NC78 _NC79 AO22X1
X41 N33 N19 S_fract_26_i[10] N290 N56 _NC80 _NC81 AO22X1
X42 N34 N19 S_fract_26_i[11] N290 N57 _NC82 _NC83 AO22X1
X43 N35 N19 S_fract_26_i[12] N290 N58 _NC84 _NC85 AO22X1
X44 N36 N19 S_fract_26_i[13] N290 N59 _NC86 _NC87 AO22X1
X45 N37 N19 S_fract_26_i[14] N290 N60 _NC88 _NC89 AO22X1
X46 N38 N19 S_fract_26_i[15] N290 N61 _NC90 _NC91 AO22X1
X47 N39 N19 S_fract_26_i[16] N290 N62 _NC92 _NC93 AO22X1
X48 N40 N19 S_fract_26_i[17] N290 N63 _NC94 _NC95 AO22X1
X49 N41 N19 S_fract_26_i[18] N290 N64 _NC96 _NC97 AO22X1
X50 N42 N19 S_fract_26_i[19] N290 N65 _NC98 _NC99 AO22X1
X51 N43 N19 S_fract_26_i[20] N290 N66 _NC100 _NC101 AO22X1
X52 N44 N19 S_fract_26_i[21] N290 N67 _NC102 _NC103 AO22X1
X53 N45 N19 S_fract_26_i[22] N290 N68 _NC104 _NC105 AO22X1
X54 N46 N19 S_fract_26_i[23] N290 N69 _NC106 _NC107 AO22X1
X55 N47 N19 S_fract_26_i[24] N290 N70 _NC108 _NC109 AO22X1
X56 N260 N270 N490 N250 _NC110 _NC111 AO21X1
X57 S_frac_rnd[0] N1 S_output_o[0] _NC112 _NC113 AND2X1
X58 S_frac_rnd[10] N18 S_output_o[10] _NC114 _NC115 AND2X1
X59 S_frac_rnd[11] N1 S_output_o[11] _NC116 _NC117 AND2X1
X60 S_frac_rnd[12] N18 S_output_o[12] _NC118 _NC119 AND2X1
X61 S_frac_rnd[13] N24 S_output_o[13] _NC120 _NC121 AND2X1
X62 S_frac_rnd[14] N1 S_output_o[14] _NC122 _NC123 AND2X1
X63 S_frac_rnd[15] N18 S_output_o[15] _NC124 _NC125 AND2X1
X64 S_frac_rnd[16] N24 S_output_o[16] _NC126 _NC127 AND2X1
X65 S_frac_rnd[17] N1 S_output_o[17] _NC128 _NC129 AND2X1
X66 S_frac_rnd[18] N18 S_output_o[18] _NC130 _NC131 AND2X1
X67 S_frac_rnd[19] N24 S_output_o[19] _NC132 _NC133 AND2X1
X68 S_frac_rnd[1] N1 S_output_o[1] _NC134 _NC135 AND2X1
X69 S_frac_rnd[20] N18 S_output_o[20] _NC136 _NC137 AND2X1
X70 S_frac_rnd[21] N24 S_output_o[21] _NC138 _NC139 AND2X1
X71 S_frac_rnd[2] N1 S_output_o[2] _NC140 _NC141 AND2X1
X72 S_frac_rnd[3] N18 S_output_o[3] _NC142 _NC143 AND2X1
X73 S_frac_rnd[4] N24 S_output_o[4] _NC144 _NC145 AND2X1
X74 S_frac_rnd[5] N1 S_output_o[5] _NC146 _NC147 AND2X1
X75 S_frac_rnd[6] N18 S_output_o[6] _NC148 _NC149 AND2X1
X76 S_frac_rnd[7] N24 S_output_o[7] _NC150 _NC151 AND2X1
X77 S_frac_rnd[8] N1 S_output_o[8] _NC152 _NC153 AND2X1
X78 S_frac_rnd[9] N18 S_output_o[9] _NC154 _NC155 AND2X1
X79 Clk_i S_output_o[0] Output_o[0] _NC156 _NC157 _NC158 DFFX1
X80 Clk_i N48 S_frac_rnd[0] _NC159 _NC160 _NC161 DFFX1
X81 Clk_i S_output_o[1] Output_o[1] _NC162 _NC163 _NC164 DFFX1
X82 Clk_i N49 S_frac_rnd[1] _NC165 _NC166 _NC167 DFFX1
X83 Clk_i S_output_o[2] Output_o[2] _NC168 _NC169 _NC170 DFFX1
X84 Clk_i N50 S_frac_rnd[2] _NC171 _NC172 _NC173 DFFX1
X85 Clk_i S_output_o[3] Output_o[3] _NC174 _NC175 _NC176 DFFX1
X86 Clk_i N51 S_frac_rnd[3] _NC177 _NC178 _NC179 DFFX1
X87 Clk_i S_output_o[4] Output_o[4] _NC180 _NC181 _NC182 DFFX1
X88 Clk_i N52 S_frac_rnd[4] _NC183 _NC184 _NC185 DFFX1
X89 Clk_i S_output_o[5] Output_o[5] _NC186 _NC187 _NC188 DFFX1
X90 Clk_i N53 S_frac_rnd[5] _NC189 _NC190 _NC191 DFFX1
X91 Clk_i S_output_o[6] Output_o[6] _NC192 _NC193 _NC194 DFFX1
X92 Clk_i N54 S_frac_rnd[6] _NC195 _NC196 _NC197 DFFX1
X93 Clk_i S_output_o[7] Output_o[7] _NC198 _NC199 _NC200 DFFX1
X94 Clk_i N55 S_frac_rnd[7] _NC201 _NC202 _NC203 DFFX1
X95 Clk_i S_output_o[8] Output_o[8] _NC204 _NC205 _NC206 DFFX1
X96 Clk_i N56 S_frac_rnd[8] _NC207 _NC208 _NC209 DFFX1
X97 Clk_i S_output_o[9] Output_o[9] _NC210 _NC211 _NC212 DFFX1
X98 Clk_i N57 S_frac_rnd[9] _NC213 _NC214 _NC215 DFFX1
X99 Clk_i S_output_o[10] Output_o[10] _NC216 _NC217 _NC218 DFFX1
X100 Clk_i N58 S_frac_rnd[10] _NC219 _NC220 _NC221 DFFX1
X101 Clk_i S_output_o[11] Output_o[11] _NC222 _NC223 _NC224 DFFX1
X102 Clk_i N59 S_frac_rnd[11] _NC225 _NC226 _NC227 DFFX1
X103 Clk_i S_output_o[12] Output_o[12] _NC228 _NC229 _NC230 DFFX1
X104 Clk_i N60 S_frac_rnd[12] _NC231 _NC232 _NC233 DFFX1
X105 Clk_i S_output_o[13] Output_o[13] _NC234 _NC235 _NC236 DFFX1
X106 Clk_i N61 S_frac_rnd[13] _NC237 _NC238 _NC239 DFFX1
X107 Clk_i S_output_o[14] Output_o[14] _NC240 _NC241 _NC242 DFFX1
X108 Clk_i N62 S_frac_rnd[14] _NC243 _NC244 _NC245 DFFX1
X109 Clk_i S_output_o[15] Output_o[15] _NC246 _NC247 _NC248 DFFX1
X110 Clk_i N63 S_frac_rnd[15] _NC249 _NC250 _NC251 DFFX1
X111 Clk_i S_output_o[16] Output_o[16] _NC252 _NC253 _NC254 DFFX1
X112 Clk_i N64 S_frac_rnd[16] _NC255 _NC256 _NC257 DFFX1
X113 Clk_i S_output_o[17] Output_o[17] _NC258 _NC259 _NC260 DFFX1
X114 Clk_i N65 S_frac_rnd[17] _NC261 _NC262 _NC263 DFFX1
X115 Clk_i S_output_o[18] Output_o[18] _NC264 _NC265 _NC266 DFFX1
X116 Clk_i N66 S_frac_rnd[18] _NC267 _NC268 _NC269 DFFX1
X117 Clk_i S_output_o[19] Output_o[19] _NC270 _NC271 _NC272 DFFX1
X118 Clk_i N67 S_frac_rnd[19] _NC273 _NC274 _NC275 DFFX1
X119 Clk_i S_output_o[20] Output_o[20] _NC276 _NC277 _NC278 DFFX1
X120 Clk_i N68 S_frac_rnd[20] _NC279 _NC280 _NC281 DFFX1
X121 Clk_i S_output_o[21] Output_o[21] _NC282 _NC283 _NC284 DFFX1
X122 Clk_i N69 S_frac_rnd[21] _NC285 _NC286 _NC287 DFFX1
X123 Clk_i S_frac_rnd[22] Output_o[22] _NC288 N500 N20 _NC289 _NC290 DFFSSRX1
X124 Clk_i N70 S_frac_rnd[22] _NC291 _NC292 _NC293 DFFX1
X125 Clk_i N134 Ine_o _NC294 _NC295 _NC296 DFFX1
X126 Clk_i N21 Output_o[23] _NC297 Vdd N10 _NC298 _NC299 DFFSSRX1
X127 Clk_i N21 Output_o[24] _NC300 Vdd N11 _NC301 _NC302 DFFSSRX1
X128 Clk_i N21 Output_o[25] _NC303 Vdd N12 _NC304 _NC305 DFFSSRX1
X129 Clk_i N21 Output_o[26] _NC306 Vdd N13 _NC307 _NC308 DFFSSRX1
X130 Clk_i N21 Output_o[27] _NC309 Vdd N14 _NC310 _NC311 DFFSSRX1
X131 Clk_i N21 Output_o[28] _NC312 Vdd N15 _NC313 _NC314 DFFSSRX1
X132 Clk_i N21 Output_o[29] _NC315 Vdd N16 _NC316 _NC317 DFFSSRX1
X133 Clk_i N21 Output_o[30] _NC318 Vdd N17 _NC319 _NC320 DFFSSRX1
X134 Clk_i S_output_o[31] Output_o[31] _NC321 _NC322 _NC323 DFFX1
X135 Clk_i Rmode_i[0] _NC324 N23 _NC325 _NC326 DFFX1
X136 Clk_i Rmode_i[1] S_rmode_i[1] N22 _NC327 _NC328 DFFX1
X137 Clk_i Exp_i[0] _NC329 N10 _NC330 _NC331 DFFX1
X138 Clk_i Exp_i[1] _NC332 N11 _NC333 _NC334 DFFX1
X139 Clk_i Exp_i[2] _NC335 N12 _NC336 _NC337 DFFX1
X140 Clk_i Exp_i[3] _NC338 N13 _NC339 _NC340 DFFX1
X141 Clk_i Exp_i[4] _NC341 N14 _NC342 _NC343 DFFX1
X142 Clk_i Exp_i[5] _NC344 N15 _NC345 _NC346 DFFX1
X143 Clk_i Exp_i[6] _NC347 N16 _NC348 _NC349 DFFX1
X144 Clk_i Exp_i[7] _NC350 N17 _NC351 _NC352 DFFX1
X145 Clk_i Ine_i S_ine_i _NC353 _NC354 _NC355 DFFX1
X146 Clk_i Fract_26_i[0] S_fract_26_i[0] _NC356 _NC357 _NC358 DFFX1
X147 Clk_i Fract_26_i[1] S_fract_26_i[1] _NC359 _NC360 _NC361 DFFX1
X148 Clk_i Fract_26_i[2] S_fract_26_i[2] _NC362 _NC363 _NC364 DFFX1
X149 Clk_i Fract_26_i[3] S_fract_26_i[3] _NC365 _NC366 _NC367 DFFX1
X150 Clk_i Fract_26_i[4] S_fract_26_i[4] _NC368 _NC369 _NC370 DFFX1
X151 Clk_i Fract_26_i[5] S_fract_26_i[5] _NC371 _NC372 _NC373 DFFX1
X152 Clk_i Fract_26_i[6] S_fract_26_i[6] _NC374 _NC375 _NC376 DFFX1
X153 Clk_i Fract_26_i[7] S_fract_26_i[7] _NC377 _NC378 _NC379 DFFX1
X154 Clk_i Fract_26_i[8] S_fract_26_i[8] _NC380 _NC381 _NC382 DFFX1
X155 Clk_i Fract_26_i[9] S_fract_26_i[9] _NC383 _NC384 _NC385 DFFX1
X156 Clk_i Fract_26_i[10] S_fract_26_i[10] _NC386 _NC387 _NC388 DFFX1
X157 Clk_i Fract_26_i[11] S_fract_26_i[11] _NC389 _NC390 _NC391 DFFX1
X158 Clk_i Fract_26_i[12] S_fract_26_i[12] _NC392 _NC393 _NC394 DFFX1
X159 Clk_i Fract_26_i[13] S_fract_26_i[13] _NC395 _NC396 _NC397 DFFX1
X160 Clk_i Fract_26_i[14] S_fract_26_i[14] _NC398 _NC399 _NC400 DFFX1
X161 Clk_i Fract_26_i[15] S_fract_26_i[15] _NC401 _NC402 _NC403 DFFX1
X162 Clk_i Fract_26_i[16] S_fract_26_i[16] _NC404 _NC405 _NC406 DFFX1
X163 Clk_i Fract_26_i[17] S_fract_26_i[17] _NC407 _NC408 _NC409 DFFX1
X164 Clk_i Fract_26_i[18] S_fract_26_i[18] _NC410 _NC411 _NC412 DFFX1
X165 Clk_i Fract_26_i[19] S_fract_26_i[19] _NC413 _NC414 _NC415 DFFX1
X166 Clk_i Fract_26_i[20] S_fract_26_i[20] _NC416 _NC417 _NC418 DFFX1
X167 Clk_i Fract_26_i[21] S_fract_26_i[21] _NC419 _NC420 _NC421 DFFX1
X168 Clk_i Fract_26_i[22] S_fract_26_i[22] _NC422 _NC423 _NC424 DFFX1
X169 Clk_i Fract_26_i[23] S_fract_26_i[23] _NC425 _NC426 _NC427 DFFX1
X170 Clk_i Fract_26_i[24] S_fract_26_i[24] _NC428 _NC429 _NC430 DFFX1
X171 Clk_i Opa_i[31] S_output_o[31] _NC431 _NC432 _NC433 DFFX1
X172 Clk_i Opa_i[23] S_expa[0] _NC434 _NC435 _NC436 DFFX1
X173 Clk_i Opa_i[24] S_expa[1] _NC437 _NC438 _NC439 DFFX1
X174 Clk_i Opa_i[25] S_expa[2] _NC440 _NC441 _NC442 DFFX1
X175 Clk_i Opa_i[26] S_expa[3] _NC443 _NC444 _NC445 DFFX1
X176 Clk_i Opa_i[27] S_expa[4] _NC446 _NC447 _NC448 DFFX1
X177 Clk_i Opa_i[28] S_expa[5] _NC449 _NC450 _NC451 DFFX1
X178 Clk_i Opa_i[29] S_expa[6] _NC452 _NC453 _NC454 DFFX1
X179 Clk_i Opa_i[30] S_expa[7] _NC455 _NC456 _NC457 DFFX1
X180 Clk_i Opa_i[0] S_opa_i[0] _NC458 _NC459 _NC460 DFFX1
X181 Clk_i Opa_i[1] S_opa_i[1] _NC461 _NC462 _NC463 DFFX1
X182 Clk_i Opa_i[2] S_opa_i[2] _NC464 _NC465 _NC466 DFFX1
X183 Clk_i Opa_i[3] S_opa_i[3] _NC467 _NC468 _NC469 DFFX1
X184 Clk_i Opa_i[4] S_opa_i[4] _NC470 _NC471 _NC472 DFFX1
X185 Clk_i Opa_i[5] S_opa_i[5] _NC473 _NC474 _NC475 DFFX1
X186 Clk_i Opa_i[6] S_opa_i[6] _NC476 _NC477 _NC478 DFFX1
X187 Clk_i Opa_i[7] S_opa_i[7] _NC479 _NC480 _NC481 DFFX1
X188 Clk_i Opa_i[8] S_opa_i[8] _NC482 _NC483 _NC484 DFFX1
X189 Clk_i Opa_i[9] S_opa_i[9] _NC485 _NC486 _NC487 DFFX1
X190 Clk_i Opa_i[10] S_opa_i[10] _NC488 _NC489 _NC490 DFFX1
X191 Clk_i Opa_i[11] S_opa_i[11] _NC491 _NC492 _NC493 DFFX1
X192 Clk_i Opa_i[12] S_opa_i[12] _NC494 _NC495 _NC496 DFFX1
X193 Clk_i Opa_i[13] S_opa_i[13] _NC497 _NC498 _NC499 DFFX1
X194 Clk_i Opa_i[14] S_opa_i[14] _NC500 _NC501 _NC502 DFFX1
X195 Clk_i Opa_i[15] S_opa_i[15] _NC503 _NC504 _NC505 DFFX1
X196 Clk_i Opa_i[16] S_opa_i[16] _NC506 _NC507 _NC508 DFFX1
X197 Clk_i Opa_i[17] S_opa_i[17] _NC509 _NC510 _NC511 DFFX1
X198 Clk_i Opa_i[18] S_opa_i[18] _NC512 _NC513 _NC514 DFFX1
X199 Clk_i Opa_i[19] S_opa_i[19] _NC515 _NC516 _NC517 DFFX1
X200 Clk_i Opa_i[20] S_opa_i[20] _NC518 _NC519 _NC520 DFFX1
X201 Clk_i Opa_i[21] S_opa_i[21] _NC521 _NC522 _NC523 DFFX1
X202 Clk_i Opa_i[22] S_opa_i[22] _NC524 _NC525 _NC526 DFFX1
X203 Clk_i Opa_i[23] S_opa_i[23] _NC527 _NC528 _NC529 DFFX1
X204 Clk_i Opa_i[24] S_opa_i[24] _NC530 _NC531 _NC532 DFFX1
X205 Clk_i Opa_i[25] S_opa_i[25] _NC533 _NC534 _NC535 DFFX1
X206 Clk_i Opa_i[26] S_opa_i[26] _NC536 _NC537 _NC538 DFFX1
X207 Clk_i Opa_i[27] S_opa_i[27] _NC539 _NC540 _NC541 DFFX1
X208 Clk_i Opa_i[28] S_opa_i[28] _NC542 _NC543 _NC544 DFFX1
X209 Clk_i Opa_i[29] S_opa_i[29] _NC545 _NC546 _NC547 DFFX1
X210 Clk_i Opa_i[30] S_opa_i[30] _NC548 _NC549 _NC550 DFFX1
.ENDS post_norm_sqrt

.SUBCKT post_norm_sqrt_DW01_inc_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22]
X0 A[0] _NC0 _NC1 SUM[0] INVX0
X1 Carry[20] A[22] SUM[22] _NC2 _NC3 XOR2X1
X2 A[1] A[0] Carry[0] _NC4 _NC5 _NC6 HADDX1
X3 A[2] Carry[0] Carry[1] _NC7 _NC8 _NC9 HADDX1
X4 A[3] Carry[1] Carry[2] _NC10 _NC11 _NC12 HADDX1
X5 A[4] Carry[2] Carry[3] _NC13 _NC14 _NC15 HADDX1
X6 A[5] Carry[3] Carry[4] _NC16 _NC17 _NC18 HADDX1
X7 A[6] Carry[4] Carry[5] _NC19 _NC20 _NC21 HADDX1
X8 A[7] Carry[5] Carry[6] _NC22 _NC23 _NC24 HADDX1
X9 A[8] Carry[6] Carry[7] _NC25 _NC26 _NC27 HADDX1
X10 A[9] Carry[7] Carry[8] _NC28 _NC29 _NC30 HADDX1
X11 A[10] Carry[8] Carry[9] _NC31 _NC32 _NC33 HADDX1
X12 A[11] Carry[9] Carry[10] _NC34 _NC35 _NC36 HADDX1
X13 A[12] Carry[10] Carry[11] _NC37 _NC38 _NC39 HADDX1
X14 A[13] Carry[11] Carry[12] _NC40 _NC41 _NC42 HADDX1
X15 A[14] Carry[12] Carry[13] _NC43 _NC44 _NC45 HADDX1
X16 A[15] Carry[13] Carry[14] _NC46 _NC47 _NC48 HADDX1
X17 A[16] Carry[14] Carry[15] _NC49 _NC50 _NC51 HADDX1
X18 A[17] Carry[15] Carry[16] _NC52 _NC53 _NC54 HADDX1
X19 A[18] Carry[16] Carry[17] _NC55 _NC56 _NC57 HADDX1
X20 A[19] Carry[17] Carry[18] _NC58 _NC59 _NC60 HADDX1
X21 A[20] Carry[18] Carry[19] _NC61 _NC62 _NC63 HADDX1
X22 A[21] Carry[19] Carry[20] _NC64 _NC65 _NC66 HADDX1
.ENDS post_norm_sqrt_DW01_inc_0

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26 Clk_i Rad_i[0] Rad_i[1] Rad_i[2] Rad_i[3] Rad_i[4] Rad_i[5] Rad_i[6] Rad_i[7] Rad_i[8] Rad_i[9] Rad_i[10] Rad_i[11] Rad_i[12] Rad_i[13] Rad_i[14] Rad_i[15] Rad_i[16] Rad_i[17] Rad_i[18] Rad_i[19] Rad_i[20] Rad_i[21] Rad_i[22] Rad_i[23] Rad_i[24] Rad_i[25] Rad_i[26] Rad_i[27] Rad_i[28] Rad_i[29] Rad_i[30] Rad_i[31] Rad_i[32] Rad_i[33] Rad_i[34] Rad_i[35] Rad_i[36] Rad_i[37] Rad_i[38] Rad_i[39] Rad_i[40] Rad_i[41] Rad_i[42] Rad_i[43] Rad_i[44] Rad_i[45] Rad_i[46] Rad_i[47] Rad_i[48] Rad_i[49] Rad_i[50] Rad_i[51] Start_i Ready_o Sqr_o[0] Sqr_o[1] Sqr_o[2] Sqr_o[3] Sqr_o[4] Sqr_o[5] Sqr_o[6] Sqr_o[7] Sqr_o[8] Sqr_o[9] Sqr_o[10] Sqr_o[11] Sqr_o[12] Sqr_o[13] Sqr_o[14] Sqr_o[15] Sqr_o[16] Sqr_o[17] Sqr_o[18] Sqr_o[19] Sqr_o[20] Sqr_o[21] Sqr_o[22] Sqr_o[23] Sqr_o[24] Sqr_o[25] Ine_o
X0 N3410 N605 S_op2[7] _NC0 _NC1 AND2X1
X1 N3410 N604 S_op2[6] _NC2 _NC3 AND2X1
X2 N3311 N603 S_op2[5] _NC4 _NC5 AND2X1
X3 N602 C[4] S_op2[51] _NC6 _NC7 AND2X1
X4 C[4] N601 S_op2[50] _NC8 _NC9 AND2X1
X5 N3311 N600 S_op2[4] _NC10 _NC11 AND2X1
X6 C[4] N599 S_op2[49] _NC12 _NC13 AND2X1
X7 N4460 N591 S_op2[40] N3211 _NC14 _NC15 MUX21X1
X8 N3311 N588 S_op2[3] _NC16 _NC17 AND2X1
X9 N587 N586 S_op2[39] N3211 _NC18 _NC19 MUX21X1
X10 N4440 N584 S_op2[38] N3211 _NC20 _NC21 MUX21X1
X11 N582 N581 S_op2[37] N3211 _NC22 _NC23 MUX21X1
X12 N4420 N579 S_op2[36] N3211 _NC24 _NC25 MUX21X1
X13 N577 N602 S_op2[35] N3211 _NC26 _NC27 MUX21X1
X14 N4400 N601 S_op2[34] N3311 _NC28 _NC29 MUX21X1
X15 N574 N599 S_op2[33] N3311 _NC30 _NC31 MUX21X1
X16 C[3] N573 N599 _NC32 _NC33 AND2X1
X17 N571 N598 N572 N3311 _NC34 _NC35 MUX21X1
X18 N5700 N5900 N598 N30 _NC36 _NC37 MUX21X1
X19 N4480 N597 N568 N3311 _NC38 _NC39 MUX21X1
X20 N4590 N585 N597 N30 _NC40 _NC41 MUX21X1
X21 N567 N29 N585 _NC42 _NC43 OR2X1
X22 N564 N596 N565 N3311 _NC44 _NC45 MUX21X1
X23 N563 N583 N596 N30 _NC46 _NC47 MUX21X1
X24 N29 N562 N583 _NC48 _NC49 OR2X1
X25 N3410 N561 S_op2[2] _NC50 _NC51 AND2X1
X26 N559 N595 N5600 N3311 _NC52 _NC53 MUX21X1
X27 N4570 N5800 N595 N30 _NC54 _NC55 MUX21X1
X28 N555 N594 N556 N3311 _NC56 _NC57 MUX21X1
X29 N554 N578 N594 N30 _NC58 _NC59 MUX21X1
X30 N553 N4650 N578 N28 _NC60 _NC61 MUX21X1
X31 N5500 N593 N551 N3311 _NC62 _NC63 MUX21X1
X32 N4550 N576 N593 N30 _NC64 _NC65 MUX21X1
X33 N4620 N567 N576 N28 _NC66 _NC67 MUX21X1
X34 N545 N592 N546 N3311 _NC68 _NC69 MUX21X1
X35 N544 N575 N592 N30 _NC70 _NC71 MUX21X1
X36 N543 N562 N575 N28 _NC72 _NC73 MUX21X1
X37 N4640 N552 N562 N26 _NC74 _NC75 MUX21X1
X38 N607 N4530 N542 N3311 _NC76 _NC77 MUX21X1
X39 N5400 N573 N541 N3111 _NC78 _NC79 MUX21X1
X40 N539 N558 N573 N28 _NC80 _NC81 MUX21X1
X41 N538 N549 N558 N26 _NC82 _NC83 MUX21X1
X42 R0[24] R0[25] N549 N24 _NC84 _NC85 MUX21X1
X43 N537 N4500 N607 N3111 _NC86 _NC87 MUX21X1
X44 N606 N589 N535 N3311 _NC88 _NC89 MUX21X1
X45 N534 N5700 N589 N3111 _NC90 _NC91 MUX21X1
X46 N533 N553 N5700 N28 _NC92 _NC93 MUX21X1
X47 N4630 N4640 N553 N26 _NC94 _NC95 MUX21X1
X48 R0[23] R0[24] N532 N24 _NC96 _NC97 MUX21X1
X49 N531 N5300 N606 N3111 _NC98 _NC99 MUX21X1
X50 N605 N587 S_op2[23] N3311 _NC100 _NC101 MUX21X1
X51 N566 N529 N587 C[3] _NC102 _NC103 MUX21X1
X52 N528 N548 N566 N28 _NC104 _NC105 MUX21X1
X53 N527 N538 N548 N26 _NC106 _NC107 MUX21X1
X54 R0[22] R0[23] N538 N24 _NC108 _NC109 MUX21X1
X55 N526 N3111 N605 _NC110 _NC111 AND2X1
X56 N604 N4440 S_op2[22] N3311 _NC112 _NC113 MUX21X1
X57 N524 N563 N525 N3111 _NC114 _NC115 MUX21X1
X58 N523 N543 N563 N28 _NC116 _NC117 MUX21X1
X59 N4610 N4630 N543 N26 _NC118 _NC119 MUX21X1
X60 R0[21] R0[22] N522 N24 _NC120 _NC121 MUX21X1
X61 N603 N582 S_op2[21] N3311 _NC122 _NC123 MUX21X1
X62 N557 N5200 N582 C[3] _NC124 _NC125 MUX21X1
X63 N519 N539 N557 N28 _NC126 _NC127 MUX21X1
X64 N518 N527 N539 N26 _NC128 _NC129 MUX21X1
X65 R0[20] R0[21] N527 N24 _NC130 _NC131 MUX21X1
X66 N600 N4420 S_op2[20] N3311 _NC132 _NC133 MUX21X1
X67 N515 N554 N516 N3111 _NC134 _NC135 MUX21X1
X68 N514 N533 N554 N28 _NC136 _NC137 MUX21X1
X69 N4600 N4610 N533 N26 _NC138 _NC139 MUX21X1
X70 R0[19] R0[20] N513 N24 _NC140 _NC141 MUX21X1
X71 N3410 N511 S_op2[1] _NC142 _NC143 AND2X1
X72 N588 N577 S_op2[19] N3311 _NC144 _NC145 MUX21X1
X73 N547 N5100 N577 C[3] _NC146 _NC147 MUX21X1
X74 N509 N528 N547 N28 _NC148 _NC149 MUX21X1
X75 N508 N518 N528 N26 _NC150 _NC151 MUX21X1
X76 R0[18] R0[19] N518 N24 _NC152 _NC153 MUX21X1
X77 N561 N4400 S_op2[18] N3311 _NC154 _NC155 MUX21X1
X78 N505 N544 N506 N3111 _NC156 _NC157 MUX21X1
X79 N504 N523 N544 N28 _NC158 _NC159 MUX21X1
X80 N4580 N4600 N523 N26 _NC160 _NC161 MUX21X1
X81 R0[17] R0[18] N503 N24 _NC162 _NC163 MUX21X1
X82 N511 N574 S_op2[17] N3211 _NC164 _NC165 MUX21X1
X83 N5400 N536 N574 C[3] _NC166 _NC167 MUX21X1
X84 N501 N5000 N536 N28 _NC168 _NC169 MUX21X1
X85 N499 N519 N5400 N28 _NC170 _NC171 MUX21X1
X86 N498 N508 N519 N26 _NC172 _NC173 MUX21X1
X87 R0[16] R0[17] N508 N24 _NC174 _NC175 MUX21X1
X88 N497 C[2] N537 _NC176 _NC177 OR2X1
X89 N495 N571 N496 N3311 _NC178 _NC179 MUX21X1
X90 N5300 N534 N571 N3111 _NC180 _NC181 MUX21X1
X91 N494 N514 N534 N28 _NC182 _NC183 MUX21X1
X92 N4560 N4580 N514 N26 _NC184 _NC185 MUX21X1
X93 R0[15] R0[16] N493 N24 _NC186 _NC187 MUX21X1
X94 N492 N491 N5300 N28 _NC188 _NC189 MUX21X1
X95 N526 N529 N4900 N3111 _NC190 _NC191 MUX21X1
X96 N489 N509 N529 N29 _NC192 _NC193 MUX21X1
X97 N488 N498 N509 N26 _NC194 _NC195 MUX21X1
X98 R0[14] R0[15] N498 N24 _NC196 _NC197 MUX21X1
X99 N487 N486 N526 N29 _NC198 _NC199 MUX21X1
X100 N521 N524 N564 N3111 _NC200 _NC201 MUX21X1
X101 N485 N504 N524 N29 _NC202 _NC203 MUX21X1
X102 N4540 N4560 N504 N26 _NC204 _NC205 MUX21X1
X103 R0[13] R0[14] N484 N24 _NC206 _NC207 MUX21X1
X104 N483 N482 N521 N29 _NC208 _NC209 MUX21X1
X105 N517 N4520 N559 N3111 _NC210 _NC211 MUX21X1
X106 N5000 N499 N5200 N29 _NC212 _NC213 MUX21X1
X107 N481 N488 N499 N26 _NC214 _NC215 MUX21X1
X108 R0[12] R0[13] N488 N24 _NC216 _NC217 MUX21X1
X109 N4800 N479 N5000 N26 _NC218 _NC219 MUX21X1
X110 N497 N4490 N517 N29 _NC220 _NC221 MUX21X1
X111 N478 N477 N501 N26 _NC222 _NC223 MUX21X1
X112 N512 N515 N555 N3111 _NC224 _NC225 MUX21X1
X113 N491 N494 N515 N29 _NC226 _NC227 MUX21X1
X114 N4470 N4540 N494 N26 _NC228 _NC229 MUX21X1
X115 R0[11] R0[12] N475 N24 _NC230 _NC231 MUX21X1
X116 N4430 N4450 N491 N27 _NC232 _NC233 MUX21X1
X117 N474 N492 N512 N29 _NC234 _NC235 MUX21X1
X118 N4390 N4411 N492 N27 _NC236 _NC237 MUX21X1
X119 N507 N4511 N5500 N30 _NC238 _NC239 MUX21X1
X120 N486 N489 N5100 N29 _NC240 _NC241 MUX21X1
X121 N479 N481 N489 N27 _NC242 _NC243 MUX21X1
X122 R0[10] R0[11] N481 N24 _NC244 _NC245 MUX21X1
X123 R0[8] R0[9] N479 N24 _NC246 _NC247 MUX21X1
X124 N477 N4800 N486 N27 _NC248 _NC249 MUX21X1
X125 R0[6] R0[7] N4800 N25 _NC250 _NC251 MUX21X1
X126 R0[4] R0[5] N477 N25 _NC252 _NC253 MUX21X1
X127 N476 N478 N487 N27 _NC254 _NC255 MUX21X1
X128 R0[2] R0[3] N478 N25 _NC256 _NC257 MUX21X1
X129 R0[0] R0[1] N476 N25 _NC258 _NC259 MUX21X1
X130 N502 N505 N545 N30 _NC260 _NC261 MUX21X1
X131 N482 N485 N505 N28 _NC262 _NC263 MUX21X1
X132 N4450 N4470 N485 N27 _NC264 _NC265 MUX21X1
X133 R0[9] R0[10] N473 N25 _NC266 _NC267 MUX21X1
X134 R0[7] R0[8] N472 N25 _NC268 _NC269 MUX21X1
X135 N4411 N4430 N482 N27 _NC270 _NC271 MUX21X1
X136 R0[5] R0[6] N471 N25 _NC272 _NC273 MUX21X1
X137 R0[3] R0[4] N4700 N25 _NC274 _NC275 MUX21X1
X138 N483 C[2] N502 _NC276 _NC277 OR2X1
X139 N469 N4390 N483 N27 _NC278 _NC279 MUX21X1
X140 R0[1] R0[2] N468 N25 _NC280 _NC281 MUX21X1
X141 N531 C[3] N495 _NC282 _NC283 OR2X1
X142 N474 C[2] N531 _NC284 _NC285 OR2X1
X143 N469 C[1] N474 _NC286 _NC287 OR2X1
X144 C[4] N4330 N34 _NC288 _NC289 XOR2X1
X145 C[3] N4350 N4330 _NC290 _NC291 NOR2X0
X146 C[3] N4350 N33 _NC292 _NC293 XNOR2X1
X147 C[2] N4340 N4320 N32 _NC294 _NC295 AO21X1
X148 N4340 C[2] N4320 _NC296 _NC297 NOR2X0
X149 C[1] C[0] N4311 N31 _NC298 _NC299 AO21X1
X150 C[1] C[0] N4311 _NC300 _NC301 NOR2X0
X151 S_count[4] N4280 N14 _NC302 _NC303 XOR2X1
X152 S_count[3] N4300 N4280 _NC304 _NC305 NOR2X0
X153 S_count[3] N4300 N13 _NC306 _NC307 XNOR2X1
X154 S_count[2] N4290 N4270 N12 _NC308 _NC309 AO21X1
X155 N4290 S_count[2] N4270 _NC310 _NC311 NOR2X0
X156 S_count[1] S_count[0] N4260 N11 _NC312 _NC313 AO21X1
X157 S_count[1] S_count[0] N4260 _NC314 _NC315 NOR2X0
X158 N1240 _NC316 _NC317 N3510 INVX0
X159 N121 _NC318 _NC319 N4030 NBUFFX4
X160 N121 _NC320 _NC321 N4020 NBUFFX2
X161 N125 _NC322 _NC323 N3311 NBUFFX4
X162 N1410 _NC324 _NC325 N30 NBUFFX4
X163 N1310 _NC326 _NC327 N28 NBUFFX4
X164 N2 _NC328 _NC329 N26 NBUFFX4
X165 N17 _NC330 _NC331 N24 NBUFFX4
X166 N4220 N143 N120 _NC332 _NC333 NOR2X0
X167 N4220 N1420 N118 _NC334 _NC335 NOR2X0
X168 N4220 N1400 N114 _NC336 _NC337 NOR2X0
X169 N4220 N1390 N112 _NC338 _NC339 NOR2X0
X170 N4220 N1380 N110 _NC340 _NC341 NOR2X0
X171 N4220 N1370 N108 _NC342 _NC343 NOR2X0
X172 N4220 N1360 N106 _NC344 _NC345 NOR2X0
X173 N4220 N135 N104 _NC346 _NC347 NOR2X0
X174 N4220 N1340 N102 _NC348 _NC349 NOR2X0
X175 N4220 N133 N100 _NC350 _NC351 NOR2X0
X176 N4250 N203 N59 _NC352 _NC353 NOR2X0
X177 N4250 N202 N58 _NC354 _NC355 NOR2X0
X178 N4250 N201 N57 _NC356 _NC357 NOR2X0
X179 N4250 N200 N56 _NC358 _NC359 NOR2X0
X180 N4250 N199 N55 _NC360 _NC361 NOR2X0
X181 N4250 N210 N98 _NC362 _NC363 NOR2X0
X182 N4250 N209 N96 _NC364 _NC365 NOR2X0
X183 N4250 N208 N94 _NC366 _NC367 NOR2X0
X184 N4250 N207 N92 _NC368 _NC369 NOR2X0
X185 N4250 N206 N90 _NC370 _NC371 NOR2X0
X186 N4250 N205 N88 _NC372 _NC373 NOR2X0
X187 N4250 N204 N86 _NC374 _NC375 NOR2X0
X188 N4240 N198 N54 _NC376 _NC377 NOR2X0
X189 N4240 N197 N53 _NC378 _NC379 NOR2X0
X190 N4240 N196 N52 _NC380 _NC381 NOR2X0
X191 N4240 N195 N51 _NC382 _NC383 NOR2X0
X192 N4240 N194 N50 _NC384 _NC385 NOR2X0
X193 N4240 N193 N49 _NC386 _NC387 NOR2X0
X194 N4240 N192 N48 _NC388 _NC389 NOR2X0
X195 N4240 N191 N47 _NC390 _NC391 NOR2X0
X196 N4240 N162 N46 _NC392 _NC393 NOR2X0
X197 N4240 N161 N45 _NC394 _NC395 NOR2X0
X198 N4240 N160 N44 _NC396 _NC397 NOR2X0
X199 N4240 N159 N43 _NC398 _NC399 NOR2X0
X200 N4240 N158 N42 _NC400 _NC401 NOR2X0
X201 N4240 N141 N116 _NC402 _NC403 NOR2X0
X202 N4230 N157 N41 _NC404 _NC405 NOR2X0
X203 N4230 N156 N40 _NC406 _NC407 NOR2X0
X204 N4230 N155 N39 _NC408 _NC409 NOR2X0
X205 N4230 N154 N38 _NC410 _NC411 NOR2X0
X206 N4230 N153 N37 _NC412 _NC413 NOR2X0
X207 N4230 N152 N36 _NC414 _NC415 NOR2X0
X208 N4230 N151 N35 _NC416 _NC417 NOR2X0
X209 N4230 N150 N134 _NC418 _NC419 NOR2X0
X210 N4230 N149 N132 _NC420 _NC421 NOR2X0
X211 N4230 N148 N130 _NC422 _NC423 NOR2X0
X212 N4230 N147 N128 _NC424 _NC425 NOR2X0
X213 N4230 N146 N126 _NC426 _NC427 NOR2X0
X214 N4230 N145 N124 _NC428 _NC429 NOR2X0
X215 N4230 N144 N122 _NC430 _NC431 NOR2X0
X216 N131 _NC432 _NC433 N4380 INVX0
X217 S_state N4510 N131 _NC434 _NC435 NAND2X1
X218 S_state N1 N121 _NC436 _NC437 NAND2X1
X219 N4220 S_state N1240 _NC438 _NC439 NOR2X0
X220 N569 C[2] N5900 _NC440 _NC441 NAND2X1
X221 C[1] N549 N567 _NC442 _NC443 NAND2X1
X222 C[2] N558 N5800 _NC444 _NC445 NAND2X1
X223 R0[25] C[0] N552 _NC446 _NC447 NAND2X1
X224 N532 _NC448 _NC449 N4640 INVX0
X225 N522 _NC450 _NC451 N4630 INVX0
X226 N513 _NC452 _NC453 N4610 INVX0
X227 N503 _NC454 _NC455 N4600 INVX0
X228 N493 _NC456 _NC457 N4580 INVX0
X229 C[4] N4480 S_op2[15] _NC458 _NC459 NOR2X0
X230 N484 _NC460 _NC461 N4560 INVX0
X231 N475 _NC462 _NC463 N4540 INVX0
X232 C[4] N564 S_op2[14] _NC464 _NC465 NOR2X0
X233 C[4] N559 S_op2[13] _NC466 _NC467 NOR2X0
X234 C[4] N555 S_op2[12] _NC468 _NC469 NOR2X0
X235 C[4] N5500 S_op2[11] _NC470 _NC471 NOR2X0
X236 N473 _NC472 _NC473 N4470 INVX0
X237 N472 _NC474 _NC475 N4450 INVX0
X238 C[4] N545 S_op2[10] _NC476 _NC477 NOR2X0
X239 C[4] N607 S_op2[9] _NC478 _NC479 NOR2X0
X240 C[4] N606 S_op2[8] _NC480 _NC481 NOR2X0
X241 N471 _NC482 _NC483 N4430 INVX0
X242 N4700 _NC484 _NC485 N4411 INVX0
X243 N466 N467 N4410 _NC486 _NC487 NOR2X0
X244 N4510 _NC488 _NC489 N4370 INVX0
X245 N521 C[3] N604 _NC490 _NC491 NOR2X0
X246 N517 C[3] N603 _NC492 _NC493 NOR2X0
X247 N512 C[3] N600 _NC494 _NC495 NOR2X0
X248 N507 C[3] N588 _NC496 _NC497 NOR2X0
X249 N468 _NC498 _NC499 N4390 INVX0
X250 R0[0] N24 N469 _NC500 _NC501 NAND2X1
X251 N502 C[3] N561 _NC502 _NC503 NOR2X0
X252 N537 C[3] N511 _NC504 _NC505 NOR2X0
X253 C[4] N495 S_op2[0] _NC506 _NC507 NOR2X0
X254 N121 _NC508 _NC509 N4040 NBUFFX2
X255 N1 _NC510 _NC511 N4250 INVX0
X256 N1 _NC512 _NC513 N4240 INVX0
X257 N1 _NC514 _NC515 N4230 INVX0
X258 N4260 _NC516 _NC517 N4290 INVX0
X259 N4311 _NC518 _NC519 N4340 INVX0
X260 N4270 _NC520 _NC521 N4300 INVX0
X261 N4320 _NC522 _NC523 N4350 INVX0
X262 N1 N131 N1280 _NC524 _NC525 NAND2X1
X263 N1 _NC526 _NC527 N4220 INVX0
X264 N589 _NC528 _NC529 N4460 INVX0
X265 N30 N5900 N591 _NC530 _NC531 NOR2X0
X266 N30 N585 N586 _NC532 _NC533 NOR2X0
X267 N30 N5800 N581 _NC534 _NC535 NOR2X0
X268 N557 _NC536 _NC537 N4570 INVX0
X269 N548 _NC538 _NC539 N4620 INVX0
X270 N552 N26 N569 _NC540 _NC541 NOR2X0
X271 N496 _NC542 _NC543 S_op2[16] INVX0
X272 N536 _NC544 _NC545 N4500 INVX0
X273 N1410 _NC546 _NC547 N3111 NBUFFX2
X274 N470 N480 N467 _NC548 _NC549 NOR2X0
X275 N1310 _NC550 _NC551 N29 NBUFFX2
X276 N125 _NC552 _NC553 N3410 NBUFFX2
X277 N476 N26 N497 _NC554 _NC555 NAND2X1
X278 N2 _NC556 _NC557 N27 NBUFFX2
X279 N17 _NC558 _NC559 N25 NBUFFX2
X280 N4020 _NC560 _NC561 N23 NBUFFX2
X281 N4020 _NC562 _NC563 N22 NBUFFX2
X282 N18 N1280 N129 _NC564 _NC565 NOR2X0
X283 N142 _NC566 _NC567 N4360 INVX0
X284 N4020 _NC568 _NC569 N21 NBUFFX2
X285 N1220 _NC570 _NC571 N4310 NBUFFX2
X286 N1220 _NC572 _NC573 N1250 NBUFFX2
X287 N1220 _NC574 _NC575 N117 NBUFFX2
X288 N1220 _NC576 _NC577 N1260 NBUFFX2
X289 N1220 _NC578 _NC579 N1300 NBUFFX2
X290 N1220 _NC580 _NC581 N127 NBUFFX2
X291 N123 _NC582 _NC583 N3610 NBUFFX2
X292 N123 _NC584 _NC585 N3811 NBUFFX2
X293 N123 _NC586 _NC587 N3711 NBUFFX2
X294 N123 _NC588 _NC589 N3911 NBUFFX2
X295 N21 N142 N1200 _NC590 _NC591 NOR2X0
X296 N123 _NC592 _NC593 N4110 NBUFFX2
X297 N123 _NC594 _NC595 N4010 NBUFFX2
X298 N15 N4220 N1180 _NC596 _NC597 NOR2X0
X299 N1220 _NC598 _NC599 N4011 NBUFFX2
X300 N123 _NC600 _NC601 N4210 NBUFFX2
X301 N598 N3211 S_op2[48] _NC602 _NC603 NOR2X0
X302 N597 N3211 S_op2[47] _NC604 _NC605 NOR2X0
X303 N596 N3211 S_op2[46] _NC606 _NC607 NOR2X0
X304 N595 N3211 S_op2[45] _NC608 _NC609 NOR2X0
X305 N594 N3211 S_op2[44] _NC610 _NC611 NOR2X0
X306 N593 N3211 S_op2[43] _NC612 _NC613 NOR2X0
X307 N592 N3211 S_op2[42] _NC614 _NC615 NOR2X0
X308 N4530 N3211 S_op2[41] _NC616 _NC617 NOR2X0
X309 N30 N583 N584 _NC618 _NC619 NOR2X0
X310 N30 N576 N602 _NC620 _NC621 NOR2X0
X311 N30 N575 N601 _NC622 _NC623 NOR2X0
X312 N578 N30 N579 _NC624 _NC625 NOR2X0
X313 N566 _NC626 _NC627 N4590 INVX0
X314 N572 _NC628 _NC629 S_op2[32] INVX0
X315 N568 _NC630 _NC631 S_op2[31] INVX0
X316 N565 _NC632 _NC633 S_op2[30] INVX0
X317 N569 _NC634 _NC635 N4650 INVX0
X318 N547 _NC636 _NC637 N4550 INVX0
X319 N5600 _NC638 _NC639 S_op2[29] INVX0
X320 N556 _NC640 _NC641 S_op2[28] INVX0
X321 N551 _NC642 _NC643 S_op2[27] INVX0
X322 N541 _NC644 _NC645 N4530 INVX0
X323 N542 _NC646 _NC647 S_op2[25] INVX0
X324 N535 _NC648 _NC649 S_op2[24] INVX0
X325 N546 _NC650 _NC651 S_op2[26] INVX0
X326 N525 _NC652 _NC653 N4440 INVX0
X327 N516 _NC654 _NC655 N4420 INVX0
X328 N506 _NC656 _NC657 N4400 INVX0
X329 N4900 _NC658 _NC659 N4480 INVX0
X330 N5200 _NC660 _NC661 N4520 INVX0
X331 N5100 _NC662 _NC663 N4511 INVX0
X332 N501 _NC664 _NC665 N4490 INVX0
X333 N487 N28 N507 _NC666 _NC667 NAND2X1
X334 N1240 _NC668 _NC669 N20 NBUFFX2
X335 N1240 _NC670 _NC671 N19 NBUFFX2
X336 N1180 _NC672 _NC673 N4211 NBUFFX2
X337 N1180 _NC674 _NC675 N4200 NBUFFX2
X338 N1180 _NC676 _NC677 N4190 NBUFFX2
X339 N4360 N21 N119 _NC678 _NC679 NOR2X0
X340 N1240 _NC680 _NC681 N18 NBUFFX2
X341 N1200 _NC682 _NC683 N4090 NBUFFX2
X342 N1200 _NC684 _NC685 N4100 NBUFFX2
X343 N1200 _NC686 _NC687 N4080 NBUFFX2
X344 N1200 _NC688 _NC689 N4070 NBUFFX2
X345 N1200 _NC690 _NC691 N4060 NBUFFX2
X346 N1200 _NC692 _NC693 N4050 NBUFFX2
X347 N1200 _NC694 _NC695 N4111 NBUFFX2
X348 N119 _NC696 _NC697 N4160 NBUFFX2
X349 N119 _NC698 _NC699 N4170 NBUFFX2
X350 N119 _NC700 _NC701 N4150 NBUFFX2
X351 N119 _NC702 _NC703 N4140 NBUFFX2
X352 N119 _NC704 _NC705 N4130 NBUFFX2
X353 N119 _NC706 _NC707 N4120 NBUFFX2
X354 N119 _NC708 _NC709 N4180 NBUFFX2
X355 N4510 N4220 N15 _NC710 _NC711 NOR2X0
X356 N125 _NC712 _NC713 N3211 NBUFFX2
X357 Clk_i N140 C[4] N125 _NC714 _NC715 DFFX1
X358 Clk_i N139 C[3] N1410 _NC716 _NC717 DFFX1
X359 N362 N363 N364 N365 N366 N367 N368 N369 N370 N371 N372 N373 N374 N375 N376 N377 N378 N379 N380 N381 N382 N383 N384 N385 N386 N387 N388 N389 N390 N391 N392 N393 N394 N395 N396 N397 N398 N399 N400 N401 N402 N403 N404 N405 N406 N407 N408 N409 N410 N411 N412 N413 N414 N415 N416 N417 N418 N419 N420 N421 N422 N423 N424 N425 N426 N427 N428 N429 N430 N431 N432 N433 N434 N435 N436 N437 N438 N439 N440 N441 N442 N443 N444 N445 N446 N447 N448 N449 N450 N451 N452 N453 N454 N455 N456 N457 N458 N459 N460 N461 N462 N463 N464 N465 sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_inc_0
X360 R1_2[0] R1_2[1] R1_2[2] R1_2[3] R1_2[4] R1_2[5] R1_2[6] R1_2[7] R1_2[8] R1_2[9] R1_2[10] R1_2[11] R1_2[12] R1_2[13] R1_2[14] R1_2[15] R1_2[16] R1_2[17] R1_2[18] R1_2[19] R1_2[20] R1_2[21] R1_2[22] R1_2[23] R1_2[24] R1_2[25] R1_2[26] R1_2[27] R1_2[28] R1_2[29] R1_2[30] R1_2[31] R1_2[32] R1_2[33] R1_2[34] R1_2[35] R1_2[36] R1_2[37] R1_2[38] R1_2[39] R1_2[40] R1_2[41] R1_2[42] R1_2[43] R1_2[44] R1_2[45] R1_2[46] R1_2[47] R1_2[48] R1_2[49] R1_2[50] R1_2[51] Vss R1[0] R1[1] R1[2] R1[3] R1[4] R1[5] R1[6] R1[7] R1[8] R1[9] R1[10] R1[11] R1[12] R1[13] R1[14] R1[15] R1[16] R1[17] R1[18] R1[19] R1[20] R1[21] R1[22] R1[23] R1[24] R1[25] Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss N362 N363 N364 N365 N366 N367 N368 N369 N370 N371 N372 N373 N374 N375 N376 N377 N378 N379 N380 N381 N382 N383 N384 N385 N386 N387 N388 N389 N390 N391 N392 N393 N394 N395 N396 N397 N398 N399 N400 N401 N402 N403 N404 N405 N406 N407 N408 N409 N410 N411 N412 N413 _NC718 sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_3
X361 S_rad_i[0] S_rad_i[1] S_rad_i[2] S_rad_i[3] S_rad_i[4] S_rad_i[5] S_rad_i[6] S_rad_i[7] S_rad_i[8] S_rad_i[9] S_rad_i[10] S_rad_i[11] S_rad_i[12] S_rad_i[13] S_rad_i[14] S_rad_i[15] S_rad_i[16] S_rad_i[17] S_rad_i[18] S_rad_i[19] S_rad_i[20] S_rad_i[21] S_rad_i[22] S_rad_i[23] S_rad_i[24] S_rad_i[25] S_rad_i[26] S_rad_i[27] S_rad_i[28] S_rad_i[29] S_rad_i[30] S_rad_i[31] S_rad_i[32] S_rad_i[33] S_rad_i[34] S_rad_i[35] S_rad_i[36] S_rad_i[37] S_rad_i[38] S_rad_i[39] S_rad_i[40] S_rad_i[41] S_rad_i[42] S_rad_i[43] S_rad_i[44] S_rad_i[45] S_rad_i[46] S_rad_i[47] S_rad_i[48] S_rad_i[49] S_rad_i[50] S_rad_i[51] R1_2[0] R1_2[1] R1_2[2] R1_2[3] R1_2[4] R1_2[5] R1_2[6] R1_2[7] R1_2[8] R1_2[9] R1_2[10] R1_2[11] R1_2[12] R1_2[13] R1_2[14] R1_2[15] R1_2[16] R1_2[17] R1_2[18] R1_2[19] R1_2[20] R1_2[21] R1_2[22] R1_2[23] R1_2[24] R1_2[25] R1_2[26] R1_2[27] R1_2[28] R1_2[29] R1_2[30] R1_2[31] R1_2[32] R1_2[33] R1_2[34] R1_2[35] R1_2[36] R1_2[37] R1_2[38] R1_2[39] R1_2[40] R1_2[41] R1_2[42] R1_2[43] R1_2[44] R1_2[45] R1_2[46] R1_2[47] R1_2[48] R1_2[49] R1_2[50] R1_2[51] Vss N306 _NC719 N466 _NC720 _NC721 _NC722 sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_cmp6_0
X362 R0_2[0] R0_2[1] R0_2[2] R0_2[3] R0_2[4] R0_2[5] R0_2[6] R0_2[7] R0_2[8] R0_2[9] R0_2[10] R0_2[11] R0_2[12] R0_2[13] R0_2[14] R0_2[15] R0_2[16] R0_2[17] R0_2[18] R0_2[19] R0_2[20] R0_2[21] R0_2[22] R0_2[23] R0_2[24] R0_2[25] R0_2[26] R0_2[27] R0_2[28] R0_2[29] R0_2[30] R0_2[31] R0_2[32] R0_2[33] R0_2[34] R0_2[35] R0_2[36] R0_2[37] R0_2[38] R0_2[39] R0_2[40] R0_2[41] R0_2[42] R0_2[43] R0_2[44] R0_2[45] R0_2[46] R0_2[47] R0_2[48] R0_2[49] R0_2[50] R0_2[51] B_2[0] Vss B_2[2] Vss B_2[4] Vss B_2[6] Vss B_2[8] Vss B_2[10] Vss B_2[12] Vss B_2[14] Vss B_2[16] Vss B_2[18] Vss B_2[20] Vss B_2[22] Vss B_2[24] Vss B_2[26] Vss B_2[28] Vss B_2[30] Vss B_2[32] Vss B_2[34] Vss B_2[36] Vss B_2[38] Vss B_2[40] Vss B_2[42] Vss B_2[44] Vss B_2[46] Vss B_2[48] Vss B_2[50] Vss Vss S_op1[0] S_op1[1] S_op1[2] S_op1[3] S_op1[4] S_op1[5] S_op1[6] S_op1[7] S_op1[8] S_op1[9] S_op1[10] S_op1[11] S_op1[12] S_op1[13] S_op1[14] S_op1[15] S_op1[16] S_op1[17] S_op1[18] S_op1[19] S_op1[20] S_op1[21] S_op1[22] S_op1[23] S_op1[24] S_op1[25] S_op1[26] S_op1[27] S_op1[28] S_op1[29] S_op1[30] S_op1[31] S_op1[32] S_op1[33] S_op1[34] S_op1[35] S_op1[36] S_op1[37] S_op1[38] S_op1[39] S_op1[40] S_op1[41] S_op1[42] S_op1[43] S_op1[44] S_op1[45] S_op1[46] S_op1[47] S_op1[48] S_op1[49] S_op1[50] S_op1[51] _NC723 sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_add_2
X363 R0[0] R0[1] R0[2] R0[3] R0[4] R0[5] R0[6] R0[7] R0[8] R0[9] R0[10] R0[11] R0[12] R0[13] R0[14] R0[15] R0[16] R0[17] R0[18] R0[19] R0[20] R0[21] R0[22] R0[23] R0[24] R0[25] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] Vss S_sum1a[0] S_sum1a[1] S_sum1a[2] S_sum1a[3] S_sum1a[4] S_sum1a[5] S_sum1a[6] S_sum1a[7] S_sum1a[8] S_sum1a[9] S_sum1a[10] S_sum1a[11] S_sum1a[12] S_sum1a[13] S_sum1a[14] S_sum1a[15] S_sum1a[16] S_sum1a[17] S_sum1a[18] S_sum1a[19] S_sum1a[20] S_sum1a[21] S_sum1a[22] S_sum1a[23] S_sum1a[24] S_sum1a[25] _NC724 sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_2
X364 R0[0] R0[1] R0[2] R0[3] R0[4] R0[5] R0[6] R0[7] R0[8] R0[9] R0[10] R0[11] R0[12] R0[13] R0[14] R0[15] R0[16] R0[17] R0[18] R0[19] R0[20] R0[21] R0[22] R0[23] R0[24] R0[25] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] Vss S_sum2a[0] S_sum2a[1] S_sum2a[2] S_sum2a[3] S_sum2a[4] S_sum2a[5] S_sum2a[6] S_sum2a[7] S_sum2a[8] S_sum2a[9] S_sum2a[10] S_sum2a[11] S_sum2a[12] S_sum2a[13] S_sum2a[14] S_sum2a[15] S_sum2a[16] S_sum2a[17] S_sum2a[18] S_sum2a[19] S_sum2a[20] S_sum2a[21] S_sum2a[22] S_sum2a[23] S_sum2a[24] S_sum2a[25] _NC725 sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_add_1
X365 S_op1[0] S_op1[1] S_op1[2] S_op1[3] S_op1[4] S_op1[5] S_op1[6] S_op1[7] S_op1[8] S_op1[9] S_op1[10] S_op1[11] S_op1[12] S_op1[13] S_op1[14] S_op1[15] S_op1[16] S_op1[17] S_op1[18] S_op1[19] S_op1[20] S_op1[21] S_op1[22] S_op1[23] S_op1[24] S_op1[25] S_op1[26] S_op1[27] S_op1[28] S_op1[29] S_op1[30] S_op1[31] S_op1[32] S_op1[33] S_op1[34] S_op1[35] S_op1[36] S_op1[37] S_op1[38] S_op1[39] S_op1[40] S_op1[41] S_op1[42] S_op1[43] S_op1[44] S_op1[45] S_op1[46] S_op1[47] S_op1[48] S_op1[49] S_op1[50] S_op1[51] S_op2[0] S_op2[1] S_op2[2] S_op2[3] S_op2[4] S_op2[5] S_op2[6] S_op2[7] S_op2[8] S_op2[9] S_op2[10] S_op2[11] S_op2[12] S_op2[13] S_op2[14] S_op2[15] S_op2[16] S_op2[17] S_op2[18] S_op2[19] S_op2[20] S_op2[21] S_op2[22] S_op2[23] S_op2[24] S_op2[25] S_op2[26] S_op2[27] S_op2[28] S_op2[29] S_op2[30] S_op2[31] S_op2[32] S_op2[33] S_op2[34] S_op2[35] S_op2[36] S_op2[37] S_op2[38] S_op2[39] S_op2[40] S_op2[41] S_op2[42] S_op2[43] S_op2[44] S_op2[45] S_op2[46] S_op2[47] S_op2[48] S_op2[49] S_op2[50] S_op2[51] Vss S_sum1b[0] S_sum1b[1] S_sum1b[2] S_sum1b[3] S_sum1b[4] S_sum1b[5] S_sum1b[6] S_sum1b[7] S_sum1b[8] S_sum1b[9] S_sum1b[10] S_sum1b[11] S_sum1b[12] S_sum1b[13] S_sum1b[14] S_sum1b[15] S_sum1b[16] S_sum1b[17] S_sum1b[18] S_sum1b[19] S_sum1b[20] S_sum1b[21] S_sum1b[22] S_sum1b[23] S_sum1b[24] S_sum1b[25] S_sum1b[26] S_sum1b[27] S_sum1b[28] S_sum1b[29] S_sum1b[30] S_sum1b[31] S_sum1b[32] S_sum1b[33] S_sum1b[34] S_sum1b[35] S_sum1b[36] S_sum1b[37] S_sum1b[38] S_sum1b[39] S_sum1b[40] S_sum1b[41] S_sum1b[42] S_sum1b[43] S_sum1b[44] S_sum1b[45] S_sum1b[46] S_sum1b[47] S_sum1b[48] S_sum1b[49] S_sum1b[50] S_sum1b[51] _NC726 sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_1
X366 S_op1[0] S_op1[1] S_op1[2] S_op1[3] S_op1[4] S_op1[5] S_op1[6] S_op1[7] S_op1[8] S_op1[9] S_op1[10] S_op1[11] S_op1[12] S_op1[13] S_op1[14] S_op1[15] S_op1[16] S_op1[17] S_op1[18] S_op1[19] S_op1[20] S_op1[21] S_op1[22] S_op1[23] S_op1[24] S_op1[25] S_op1[26] S_op1[27] S_op1[28] S_op1[29] S_op1[30] S_op1[31] S_op1[32] S_op1[33] S_op1[34] S_op1[35] S_op1[36] S_op1[37] S_op1[38] S_op1[39] S_op1[40] S_op1[41] S_op1[42] S_op1[43] S_op1[44] S_op1[45] S_op1[46] S_op1[47] S_op1[48] S_op1[49] S_op1[50] S_op1[51] S_op2[0] S_op2[1] S_op2[2] S_op2[3] S_op2[4] S_op2[5] S_op2[6] S_op2[7] S_op2[8] S_op2[9] S_op2[10] S_op2[11] S_op2[12] S_op2[13] S_op2[14] S_op2[15] S_op2[16] S_op2[17] S_op2[18] S_op2[19] S_op2[20] S_op2[21] S_op2[22] S_op2[23] S_op2[24] S_op2[25] S_op2[26] S_op2[27] S_op2[28] S_op2[29] S_op2[30] S_op2[31] S_op2[32] S_op2[33] S_op2[34] S_op2[35] S_op2[36] S_op2[37] S_op2[38] S_op2[39] S_op2[40] S_op2[41] S_op2[42] S_op2[43] S_op2[44] S_op2[45] S_op2[46] S_op2[47] S_op2[48] S_op2[49] S_op2[50] S_op2[51] Vss S_sum2b[0] S_sum2b[1] S_sum2b[2] S_sum2b[3] S_sum2b[4] S_sum2b[5] S_sum2b[6] S_sum2b[7] S_sum2b[8] S_sum2b[9] S_sum2b[10] S_sum2b[11] S_sum2b[12] S_sum2b[13] S_sum2b[14] S_sum2b[15] S_sum2b[16] S_sum2b[17] S_sum2b[18] S_sum2b[19] S_sum2b[20] S_sum2b[21] S_sum2b[22] S_sum2b[23] S_sum2b[24] S_sum2b[25] S_sum2b[26] S_sum2b[27] S_sum2b[28] S_sum2b[29] S_sum2b[30] S_sum2b[31] S_sum2b[32] S_sum2b[33] S_sum2b[34] S_sum2b[35] S_sum2b[36] S_sum2b[37] S_sum2b[38] S_sum2b[39] S_sum2b[40] S_sum2b[41] S_sum2b[42] S_sum2b[43] S_sum2b[44] S_sum2b[45] S_sum2b[46] S_sum2b[47] S_sum2b[48] S_sum2b[49] S_sum2b[50] S_sum2b[51] _NC727 sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_add_0
X367 S_rad_i[0] S_rad_i[1] S_rad_i[2] S_rad_i[3] S_rad_i[4] S_rad_i[5] S_rad_i[6] S_rad_i[7] S_rad_i[8] S_rad_i[9] S_rad_i[10] S_rad_i[11] S_rad_i[12] S_rad_i[13] S_rad_i[14] S_rad_i[15] S_rad_i[16] S_rad_i[17] S_rad_i[18] S_rad_i[19] S_rad_i[20] S_rad_i[21] S_rad_i[22] S_rad_i[23] S_rad_i[24] S_rad_i[25] S_rad_i[26] S_rad_i[27] S_rad_i[28] S_rad_i[29] S_rad_i[30] S_rad_i[31] S_rad_i[32] S_rad_i[33] S_rad_i[34] S_rad_i[35] S_rad_i[36] S_rad_i[37] S_rad_i[38] S_rad_i[39] S_rad_i[40] S_rad_i[41] S_rad_i[42] S_rad_i[43] S_rad_i[44] S_rad_i[45] S_rad_i[46] S_rad_i[47] S_rad_i[48] S_rad_i[49] S_rad_i[50] S_rad_i[51] R0_2[0] R0_2[1] R0_2[2] R0_2[3] R0_2[4] R0_2[5] R0_2[6] R0_2[7] R0_2[8] R0_2[9] R0_2[10] R0_2[11] R0_2[12] R0_2[13] R0_2[14] R0_2[15] R0_2[16] R0_2[17] R0_2[18] R0_2[19] R0_2[20] R0_2[21] R0_2[22] R0_2[23] R0_2[24] R0_2[25] R0_2[26] R0_2[27] R0_2[28] R0_2[29] R0_2[30] R0_2[31] R0_2[32] R0_2[33] R0_2[34] R0_2[35] R0_2[36] R0_2[37] R0_2[38] R0_2[39] R0_2[40] R0_2[41] R0_2[42] R0_2[43] R0_2[44] R0_2[45] R0_2[46] R0_2[47] R0_2[48] R0_2[49] R0_2[50] R0_2[51] Vss Vdd Vss N142 _NC728 sqrt_RD_WIDTH52_SQ_WIDTH26_DW_cmp_0
X368 R1[0] R1[1] R1[2] R1[3] R1[4] R1[5] R1[6] R1[7] R1[8] R1[9] R1[10] R1[11] R1[12] R1[13] R1[14] R1[15] R1[16] R1[17] R1[18] R1[19] R1[20] R1[21] R1[22] R1[23] R1[24] R1[25] N306 Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss N309 N310 N311 N312 N313 N314 N315 N316 N317 N318 N319 N320 N321 N322 N323 N324 N325 N326 N327 N328 N329 N330 N331 N332 N333 N334 _NC729 sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_0
X369 N17 N1 N136 _NC730 _NC731 AND2X1
X370 N31 N4250 N137 _NC732 _NC733 OR2X1
X371 N32 N1 N138 _NC734 _NC735 AND2X1
X372 N33 N4250 N139 _NC736 _NC737 OR2X1
X373 N34 N4250 N140 _NC738 _NC739 OR2X1
X374 S_count[4] S_count[3] N1320 _NC740 _NC741 OR2X1
X375 S_count[0] S_count[1] N1320 S_count[2] N4510 _NC742 _NC743 NOR4X0
X376 S_count[0] N18 N129 N16 N4000 _NC744 _NC745 AO22X1
X377 N14 N3510 S_count[4] N20 N1280 N3990 _NC746 _NC747 AO221X1
X378 S_state N131 N4230 N3980 _NC748 _NC749 AO21X1
X379 S_ready_o N3510 N4380 N1 N3970 _NC750 _NC751 AO22X1
X380 N11 N3510 S_count[1] N19 N1280 N3960 _NC752 _NC753 AO221X1
X381 S_count[2] N18 N129 N12 N3950 _NC754 _NC755 AO22X1
X382 N13 N3510 S_count[3] N18 N1280 N3940 _NC756 _NC757 AO221X1
X383 N3510 N1 N142 N1220 _NC758 _NC759 AND3X1
X384 N4360 N1 N3510 N123 _NC760 _NC761 AND3X1
X385 N4310 S_sum1b[0] N3610 S_sum2b[0] R0_2[0] N18 N3930 _NC762 _NC763 AO222X1
X386 S_sum1a[0] N4180 S_sum2a[0] N4111 R1[0] N23 N3920 _NC764 _NC765 AO222X1
X387 S_sum1a[1] N4180 S_sum2a[1] N4111 R1[1] N22 N3910 _NC766 _NC767 AO222X1
X388 S_sum1a[2] N4180 S_sum2a[2] N4111 R1[2] N23 N3900 _NC768 _NC769 AO222X1
X389 S_sum1a[3] N4180 S_sum2a[3] N4111 R1[3] N22 N3890 _NC770 _NC771 AO222X1
X390 S_sum1a[4] N4180 S_sum2a[4] N4111 R1[4] N23 N3880 _NC772 _NC773 AO222X1
X391 S_sum1a[5] N4180 S_sum2a[5] N4111 R1[5] N22 N3870 _NC774 _NC775 AO222X1
X392 S_sum1a[6] N4170 S_sum2a[6] N4100 R1[6] N23 N3860 _NC776 _NC777 AO222X1
X393 S_sum1a[7] N4170 S_sum2a[7] N4100 R1[7] N22 N3850 _NC778 _NC779 AO222X1
X394 S_sum1a[8] N4170 S_sum2a[8] N4100 R1[8] N23 N3840 _NC780 _NC781 AO222X1
X395 S_sum1a[9] N4170 S_sum2a[9] N4100 R1[9] N22 N3830 _NC782 _NC783 AO222X1
X396 S_sum1a[10] N4170 S_sum2a[10] N4100 R1[10] N23 N3820 _NC784 _NC785 AO222X1
X397 S_sum1a[11] N4170 S_sum2a[11] N4100 R1[11] N22 N3810 _NC786 _NC787 AO222X1
X398 S_sum1a[12] N4170 S_sum2a[12] N4100 R1[12] N23 N3800 _NC788 _NC789 AO222X1
X399 S_sum1a[13] N4170 S_sum2a[13] N4100 R1[13] N22 N3790 _NC790 _NC791 AO222X1
X400 S_sum1a[14] N4170 S_sum2a[14] N4100 R1[14] N23 N3780 _NC792 _NC793 AO222X1
X401 S_sum1a[15] N4170 S_sum2a[15] N4100 R1[15] N22 N3770 _NC794 _NC795 AO222X1
X402 S_sum1a[16] N4170 S_sum2a[16] N4100 R1[16] N23 N3760 _NC796 _NC797 AO222X1
X403 S_sum1a[17] N4170 S_sum2a[17] N4100 R1[17] N22 N3750 _NC798 _NC799 AO222X1
X404 S_sum1a[18] N4160 S_sum2a[18] N4090 R1[18] N4030 N3740 _NC800 _NC801 AO222X1
X405 S_sum1a[19] N4160 S_sum2a[19] N4090 R1[19] N23 N3730 _NC802 _NC803 AO222X1
X406 S_sum1a[20] N4160 S_sum2a[20] N4090 R1[20] N22 N3720 _NC804 _NC805 AO222X1
X407 S_sum1a[21] N4160 S_sum2a[21] N4090 R1[21] N23 N3710 _NC806 _NC807 AO222X1
X408 S_sum1a[22] N4160 S_sum2a[22] N4090 R1[22] N22 N3700 _NC808 _NC809 AO222X1
X409 S_sum1a[23] N4160 S_sum2a[23] N4090 R1[23] N23 N3690 _NC810 _NC811 AO222X1
X410 S_sum1a[24] N4160 S_sum2a[24] N4090 R1[24] N22 N3680 _NC812 _NC813 AO222X1
X411 S_sum1a[25] N4160 S_sum2a[25] N4090 R1[25] N23 N3670 _NC814 _NC815 AO222X1
X412 S_sum1a[0] N4011 S_sum2a[0] N4210 R0[0] N18 N3660 _NC816 _NC817 AO222X1
X413 S_sum1a[1] N4011 S_sum2a[1] N4210 R0[1] N18 N3650 _NC818 _NC819 AO222X1
X414 S_sum1a[2] N4011 S_sum2a[2] N4210 R0[2] N18 N3640 _NC820 _NC821 AO222X1
X415 S_sum1a[3] N1300 S_sum2a[3] N4110 R0[3] N18 N3630 _NC822 _NC823 AO222X1
X416 S_sum1a[4] N1300 S_sum2a[4] N4110 R0[4] N20 N3620 _NC824 _NC825 AO222X1
X417 S_sum1a[5] N1300 S_sum2a[5] N4110 R0[5] N18 N361 _NC826 _NC827 AO222X1
X418 S_sum1a[6] N1300 S_sum2a[6] N4110 R0[6] N19 N360 _NC828 _NC829 AO222X1
X419 S_sum1a[7] N1300 S_sum2a[7] N4110 R0[7] N20 N359 _NC830 _NC831 AO222X1
X420 S_sum1a[8] N1300 S_sum2a[8] N4110 R0[8] N18 N358 _NC832 _NC833 AO222X1
X421 S_sum1a[9] N1300 S_sum2a[9] N4110 R0[9] N19 N357 _NC834 _NC835 AO222X1
X422 S_sum1a[10] N1300 S_sum2a[10] N4110 R0[10] N20 N356 _NC836 _NC837 AO222X1
X423 S_sum1a[11] N1300 S_sum2a[11] N4110 R0[11] N18 N355 _NC838 _NC839 AO222X1
X424 S_sum1a[12] N1300 S_sum2a[12] N4110 R0[12] N19 N354 _NC840 _NC841 AO222X1
X425 S_sum1a[13] N1300 S_sum2a[13] N4110 R0[13] N20 N353 _NC842 _NC843 AO222X1
X426 S_sum1a[14] N1300 S_sum2a[14] N4110 R0[14] N18 N352 _NC844 _NC845 AO222X1
X427 S_sum1a[15] N1300 S_sum2a[15] N4110 R0[15] N19 N351 _NC846 _NC847 AO222X1
X428 S_sum1a[16] N127 S_sum2a[16] N4010 R0[16] N20 N350 _NC848 _NC849 AO222X1
X429 S_sum1a[17] N127 S_sum2a[17] N4010 R0[17] N18 N349 _NC850 _NC851 AO222X1
X430 S_sum1a[18] N127 S_sum2a[18] N4010 R0[18] N19 N348 _NC852 _NC853 AO222X1
X431 S_sum1a[19] N127 S_sum2a[19] N4010 R0[19] N20 N347 _NC854 _NC855 AO222X1
X432 S_sum1a[20] N127 S_sum2a[20] N4010 R0[20] N18 N346 _NC856 _NC857 AO222X1
X433 S_sum1a[21] N127 S_sum2a[21] N4010 R0[21] N19 N345 _NC858 _NC859 AO222X1
X434 S_sum1a[22] N4011 S_sum2a[22] N4210 R0[22] N1240 N344 _NC860 _NC861 AO222X1
X435 S_sum1a[23] N127 S_sum2a[23] N4010 R0[23] N20 N343 _NC862 _NC863 AO222X1
X436 S_sum1a[24] N127 S_sum2a[24] N4010 R0[24] N18 N342 _NC864 _NC865 AO222X1
X437 S_sum1a[25] N127 S_sum2a[25] N4010 R0[25] N19 N341 _NC866 _NC867 AO222X1
X438 N4310 S_sum1b[1] N3610 S_sum2b[1] R0_2[1] N20 N340 _NC868 _NC869 AO222X1
X439 N4310 S_sum1b[2] N3610 S_sum2b[2] R0_2[2] N18 N339 _NC870 _NC871 AO222X1
X440 N4310 S_sum1b[3] N3610 S_sum2b[3] R0_2[3] N19 N338 _NC872 _NC873 AO222X1
X441 N4310 S_sum1b[4] N3610 S_sum2b[4] R0_2[4] N20 N337 _NC874 _NC875 AO222X1
X442 N4310 S_sum1b[5] N3610 S_sum2b[5] R0_2[5] N18 N336 _NC876 _NC877 AO222X1
X443 N4310 S_sum1b[6] N3610 S_sum2b[6] R0_2[6] N18 N335 _NC878 _NC879 AO222X1
X444 N4310 S_sum1b[7] N3610 S_sum2b[7] R0_2[7] N18 N3340 _NC880 _NC881 AO222X1
X445 N4310 S_sum1b[8] N3610 S_sum2b[8] R0_2[8] N18 N3330 _NC882 _NC883 AO222X1
X446 N4310 S_sum1b[9] N3610 S_sum2b[9] R0_2[9] N18 N3320 _NC884 _NC885 AO222X1
X447 N4310 S_sum1b[10] N3610 S_sum2b[10] R0_2[10] N18 N3310 _NC886 _NC887 AO222X1
X448 N4310 S_sum1b[11] N3610 S_sum2b[11] R0_2[11] N1240 N3300 _NC888 _NC889 AO222X1
X449 N117 S_sum1b[12] N3711 S_sum2b[12] R0_2[12] N1240 N3290 _NC890 _NC891 AO222X1
X450 N117 S_sum1b[13] N3711 S_sum2b[13] R0_2[13] N1240 N3280 _NC892 _NC893 AO222X1
X451 N117 S_sum1b[14] N3711 S_sum2b[14] R0_2[14] N1240 N3270 _NC894 _NC895 AO222X1
X452 N117 S_sum1b[15] N3711 S_sum2b[15] R0_2[15] N1240 N3260 _NC896 _NC897 AO222X1
X453 N117 S_sum1b[16] N3711 S_sum2b[16] R0_2[16] N1240 N3250 _NC898 _NC899 AO222X1
X454 N117 S_sum1b[17] N3711 S_sum2b[17] R0_2[17] N1240 N3240 _NC900 _NC901 AO222X1
X455 N117 S_sum1b[18] N3711 S_sum2b[18] R0_2[18] N1240 N3230 _NC902 _NC903 AO222X1
X456 N117 S_sum1b[19] N3711 S_sum2b[19] R0_2[19] N1240 N3220 _NC904 _NC905 AO222X1
X457 N117 S_sum1b[20] N3711 S_sum2b[20] R0_2[20] N1240 N3210 _NC906 _NC907 AO222X1
X458 N117 S_sum1b[21] N3711 S_sum2b[21] R0_2[21] N1240 N3200 _NC908 _NC909 AO222X1
X459 N117 S_sum1b[22] N3711 S_sum2b[22] R0_2[22] N1240 N3190 _NC910 _NC911 AO222X1
X460 N117 S_sum1b[23] N3711 S_sum2b[23] R0_2[23] N1240 N3180 _NC912 _NC913 AO222X1
X461 N1250 S_sum1b[24] N3811 S_sum2b[24] R0_2[24] N19 N3170 _NC914 _NC915 AO222X1
X462 N1250 S_sum1b[25] N3811 S_sum2b[25] R0_2[25] N20 N3160 _NC916 _NC917 AO222X1
X463 N1250 S_sum1b[26] N3811 S_sum2b[26] R0_2[26] N19 N3150 _NC918 _NC919 AO222X1
X464 N1250 S_sum1b[27] N3811 S_sum2b[27] R0_2[27] N20 N3140 _NC920 _NC921 AO222X1
X465 N1250 S_sum1b[28] N3811 S_sum2b[28] R0_2[28] N19 N3130 _NC922 _NC923 AO222X1
X466 N1250 S_sum1b[29] N3811 S_sum2b[29] R0_2[29] N20 N3120 _NC924 _NC925 AO222X1
X467 N1250 S_sum1b[30] N3811 S_sum2b[30] R0_2[30] N19 N3110 _NC926 _NC927 AO222X1
X468 N1250 S_sum1b[31] N3811 S_sum2b[31] R0_2[31] N20 N3100 _NC928 _NC929 AO222X1
X469 N1250 S_sum1b[32] N3811 S_sum2b[32] R0_2[32] N19 N3090 _NC930 _NC931 AO222X1
X470 N1250 S_sum1b[33] N3811 S_sum2b[33] R0_2[33] N20 N308 _NC932 _NC933 AO222X1
X471 N1250 S_sum1b[34] N3811 S_sum2b[34] R0_2[34] N19 N307 _NC934 _NC935 AO222X1
X472 N1260 S_sum1b[35] N3911 S_sum2b[35] R0_2[35] N20 N3060 _NC936 _NC937 AO222X1
X473 N1260 S_sum1b[36] N3911 S_sum2b[36] R0_2[36] N19 N305 _NC938 _NC939 AO222X1
X474 N1260 S_sum1b[37] N3911 S_sum2b[37] R0_2[37] N20 N304 _NC940 _NC941 AO222X1
X475 N1260 S_sum1b[38] N3911 S_sum2b[38] R0_2[38] N19 N303 _NC942 _NC943 AO222X1
X476 N1260 S_sum1b[39] N3911 S_sum2b[39] R0_2[39] N20 N302 _NC944 _NC945 AO222X1
X477 N1260 S_sum1b[40] N3911 S_sum2b[40] R0_2[40] N19 N301 _NC946 _NC947 AO222X1
X478 N1260 S_sum1b[41] N3911 S_sum2b[41] R0_2[41] N20 N300 _NC948 _NC949 AO222X1
X479 N1260 S_sum1b[42] N3911 S_sum2b[42] R0_2[42] N19 N299 _NC950 _NC951 AO222X1
X480 N1260 S_sum1b[43] N3911 S_sum2b[43] R0_2[43] N20 N298 _NC952 _NC953 AO222X1
X481 N1260 S_sum1b[44] N3911 S_sum2b[44] R0_2[44] N19 N297 _NC954 _NC955 AO222X1
X482 N1260 S_sum1b[45] N3911 S_sum2b[45] R0_2[45] N20 N296 _NC956 _NC957 AO222X1
X483 N1260 S_sum1b[46] N3911 S_sum2b[46] R0_2[46] N19 N295 _NC958 _NC959 AO222X1
X484 N127 S_sum1b[47] N4010 S_sum2b[47] R0_2[47] N20 N294 _NC960 _NC961 AO222X1
X485 N127 S_sum1b[48] N4010 S_sum2b[48] R0_2[48] N19 N293 _NC962 _NC963 AO222X1
X486 N127 S_sum1b[49] N4010 S_sum2b[49] R0_2[49] N20 N292 _NC964 _NC965 AO222X1
X487 N127 S_sum1b[50] N4010 S_sum2b[50] R0_2[50] N19 N291 _NC966 _NC967 AO222X1
X488 N1250 S_sum1b[51] N3811 S_sum2b[51] R0_2[51] N1240 N290 _NC968 _NC969 AO222X1
X489 S_sum1b[51] N4160 S_sum2b[51] N4090 R1_2[51] N22 N289 _NC970 _NC971 AO222X1
X490 S_sum1b[50] N4160 S_sum2b[50] N4090 R1_2[50] N23 N288 _NC972 _NC973 AO222X1
X491 S_sum1b[49] N4160 S_sum2b[49] N4090 R1_2[49] N22 N287 _NC974 _NC975 AO222X1
X492 S_sum1b[48] N4160 S_sum2b[48] N4090 R1_2[48] N23 N286 _NC976 _NC977 AO222X1
X493 S_sum1b[47] N4150 S_sum2b[47] N4080 R1_2[47] N4030 N285 _NC978 _NC979 AO222X1
X494 S_sum1b[46] N4150 S_sum2b[46] N4080 R1_2[46] N4030 N284 _NC980 _NC981 AO222X1
X495 S_sum1b[45] N4150 S_sum2b[45] N4080 R1_2[45] N4030 N283 _NC982 _NC983 AO222X1
X496 S_sum1b[44] N4150 S_sum2b[44] N4080 R1_2[44] N4030 N282 _NC984 _NC985 AO222X1
X497 S_sum1b[43] N4150 S_sum2b[43] N4080 R1_2[43] N4030 N281 _NC986 _NC987 AO222X1
X498 S_sum1b[42] N4150 S_sum2b[42] N4080 R1_2[42] N4030 N280 _NC988 _NC989 AO222X1
X499 S_sum1b[41] N4150 S_sum2b[41] N4080 R1_2[41] N4030 N279 _NC990 _NC991 AO222X1
X500 S_sum1b[40] N4150 S_sum2b[40] N4080 R1_2[40] N4030 N278 _NC992 _NC993 AO222X1
X501 S_sum1b[39] N4150 S_sum2b[39] N4080 R1_2[39] N4030 N277 _NC994 _NC995 AO222X1
X502 S_sum1b[38] N4150 S_sum2b[38] N4080 R1_2[38] N4030 N276 _NC996 _NC997 AO222X1
X503 S_sum1b[37] N4150 S_sum2b[37] N4080 R1_2[37] N4030 N275 _NC998 _NC999 AO222X1
X504 S_sum1b[36] N4150 S_sum2b[36] N4080 R1_2[36] N4030 N274 _NC1000 _NC1001 AO222X1
X505 S_sum1b[35] N4140 S_sum2b[35] N4070 R1_2[35] N4030 N273 _NC1002 _NC1003 AO222X1
X506 S_sum1b[34] N4140 S_sum2b[34] N4070 R1_2[34] N4030 N272 _NC1004 _NC1005 AO222X1
X507 S_sum1b[33] N4140 S_sum2b[33] N4070 R1_2[33] N4030 N271 _NC1006 _NC1007 AO222X1
X508 S_sum1b[32] N4140 S_sum2b[32] N4070 R1_2[32] N4030 N270 _NC1008 _NC1009 AO222X1
X509 S_sum1b[31] N4140 S_sum2b[31] N4070 R1_2[31] N4030 N269 _NC1010 _NC1011 AO222X1
X510 S_sum1b[30] N4140 S_sum2b[30] N4070 R1_2[30] N4030 N268 _NC1012 _NC1013 AO222X1
X511 S_sum1b[29] N4140 S_sum2b[29] N4070 R1_2[29] N4030 N267 _NC1014 _NC1015 AO222X1
X512 S_sum1b[28] N4140 S_sum2b[28] N4070 R1_2[28] N4030 N266 _NC1016 _NC1017 AO222X1
X513 S_sum1b[27] N4140 S_sum2b[27] N4070 R1_2[27] N4030 N265 _NC1018 _NC1019 AO222X1
X514 S_sum1b[26] N4140 S_sum2b[26] N4070 R1_2[26] N4030 N264 _NC1020 _NC1021 AO222X1
X515 S_sum1b[25] N4140 S_sum2b[25] N4070 R1_2[25] N4030 N263 _NC1022 _NC1023 AO222X1
X516 S_sum1b[24] N4140 S_sum2b[24] N4070 R1_2[24] N4030 N262 _NC1024 _NC1025 AO222X1
X517 S_sum1b[23] N4130 S_sum2b[23] N4060 R1_2[23] N4030 N261 _NC1026 _NC1027 AO222X1
X518 S_sum1b[22] N4130 S_sum2b[22] N4060 R1_2[22] N4030 N260 _NC1028 _NC1029 AO222X1
X519 S_sum1b[21] N4130 S_sum2b[21] N4060 R1_2[21] N4030 N259 _NC1030 _NC1031 AO222X1
X520 S_sum1b[20] N4130 S_sum2b[20] N4060 R1_2[20] N4030 N258 _NC1032 _NC1033 AO222X1
X521 S_sum1b[19] N4130 S_sum2b[19] N4060 R1_2[19] N4030 N257 _NC1034 _NC1035 AO222X1
X522 S_sum1b[18] N4130 S_sum2b[18] N4060 R1_2[18] N4030 N256 _NC1036 _NC1037 AO222X1
X523 S_sum1b[17] N4130 S_sum2b[17] N4060 R1_2[17] N4030 N255 _NC1038 _NC1039 AO222X1
X524 S_sum1b[16] N4130 S_sum2b[16] N4060 R1_2[16] N4030 N254 _NC1040 _NC1041 AO222X1
X525 S_sum1b[15] N4130 S_sum2b[15] N4060 R1_2[15] N4030 N253 _NC1042 _NC1043 AO222X1
X526 S_sum1b[14] N4130 S_sum2b[14] N4060 R1_2[14] N4030 N252 _NC1044 _NC1045 AO222X1
X527 S_sum1b[13] N4130 S_sum2b[13] N4060 R1_2[13] N4030 N251 _NC1046 _NC1047 AO222X1
X528 S_sum1b[12] N4130 S_sum2b[12] N4060 R1_2[12] N4040 N250 _NC1048 _NC1049 AO222X1
X529 S_sum1b[11] N4120 S_sum2b[11] N4050 R1_2[11] N4040 N249 _NC1050 _NC1051 AO222X1
X530 S_sum1b[10] N4120 S_sum2b[10] N4050 R1_2[10] N4040 N248 _NC1052 _NC1053 AO222X1
X531 S_sum1b[9] N4120 S_sum2b[9] N4050 R1_2[9] N4040 N247 _NC1054 _NC1055 AO222X1
X532 S_sum1b[8] N4120 S_sum2b[8] N4050 R1_2[8] N4040 N246 _NC1056 _NC1057 AO222X1
X533 S_sum1b[7] N4120 S_sum2b[7] N4050 R1_2[7] N4040 N245 _NC1058 _NC1059 AO222X1
X534 S_sum1b[6] N4120 S_sum2b[6] N4050 R1_2[6] N4040 N244 _NC1060 _NC1061 AO222X1
X535 S_sum1b[5] N4120 S_sum2b[5] N4050 R1_2[5] N4040 N243 _NC1062 _NC1063 AO222X1
X536 S_sum1b[4] N4120 S_sum2b[4] N4050 R1_2[4] N4040 N242 _NC1064 _NC1065 AO222X1
X537 S_sum1b[3] N4120 S_sum2b[3] N4050 R1_2[3] N4040 N241 _NC1066 _NC1067 AO222X1
X538 S_sum1b[2] N4120 S_sum2b[2] N4050 R1_2[2] N4040 N240 _NC1068 _NC1069 AO222X1
X539 S_sum1b[1] N4120 S_sum2b[1] N4050 R1_2[1] N4040 N239 _NC1070 _NC1071 AO222X1
X540 S_sum1b[0] N4120 S_sum2b[0] N4050 R1_2[0] N22 N238 _NC1072 _NC1073 AO222X1
X541 S_sqr_o[25] N15 N334 N4211 N237 _NC1074 _NC1075 AO22X1
X542 S_sqr_o[24] N15 N333 N4211 N236 _NC1076 _NC1077 AO22X1
X543 S_sqr_o[23] N15 N332 N4200 N235 _NC1078 _NC1079 AO22X1
X544 S_sqr_o[22] N15 N331 N4200 N234 _NC1080 _NC1081 AO22X1
X545 S_sqr_o[21] N15 N330 N4200 N233 _NC1082 _NC1083 AO22X1
X546 S_sqr_o[20] N15 N329 N4200 N232 _NC1084 _NC1085 AO22X1
X547 S_sqr_o[19] N15 N328 N4200 N231 _NC1086 _NC1087 AO22X1
X548 S_sqr_o[18] N15 N327 N4200 N230 _NC1088 _NC1089 AO22X1
X549 S_sqr_o[17] N15 N326 N4200 N229 _NC1090 _NC1091 AO22X1
X550 S_sqr_o[16] N15 N325 N4200 N228 _NC1092 _NC1093 AO22X1
X551 S_sqr_o[15] N15 N324 N4200 N227 _NC1094 _NC1095 AO22X1
X552 S_sqr_o[14] N15 N323 N4200 N226 _NC1096 _NC1097 AO22X1
X553 S_sqr_o[13] N15 N322 N4200 N225 _NC1098 _NC1099 AO22X1
X554 S_sqr_o[12] N15 N321 N4200 N224 _NC1100 _NC1101 AO22X1
X555 S_sqr_o[11] N15 N320 N4190 N223 _NC1102 _NC1103 AO22X1
X556 S_sqr_o[10] N15 N319 N4190 N222 _NC1104 _NC1105 AO22X1
X557 S_sqr_o[9] N15 N318 N4190 N221 _NC1106 _NC1107 AO22X1
X558 S_sqr_o[8] N15 N317 N4190 N220 _NC1108 _NC1109 AO22X1
X559 S_sqr_o[7] N15 N316 N4190 N219 _NC1110 _NC1111 AO22X1
X560 S_sqr_o[6] N15 N315 N4190 N218 _NC1112 _NC1113 AO22X1
X561 S_sqr_o[5] N15 N314 N4190 N217 _NC1114 _NC1115 AO22X1
X562 S_sqr_o[4] N15 N313 N4190 N216 _NC1116 _NC1117 AO22X1
X563 S_sqr_o[3] N15 N312 N4190 N215 _NC1118 _NC1119 AO22X1
X564 S_sqr_o[2] N15 N311 N4190 N214 _NC1120 _NC1121 AO22X1
X565 S_sqr_o[1] N15 N310 N4190 N213 _NC1122 _NC1123 AO22X1
X566 S_sqr_o[0] N15 N309 N4190 N212 _NC1124 _NC1125 AO22X1
X567 N183 N418 N1140 _NC1126 _NC1127 XOR2X1
X568 N185 N426 N115 _NC1128 _NC1129 XOR2X1
X569 N184 N431 N1160 _NC1130 _NC1131 XOR2X1
X570 N1140 N115 N1160 N1100 _NC1132 _NC1133 NAND3X0
X571 S_rad_i[25] N439 N1110 _NC1134 _NC1135 XOR2X1
X572 S_rad_i[24] N438 N1120 _NC1136 _NC1137 XOR2X1
X573 S_rad_i[11] N425 N113 _NC1138 _NC1139 XOR2X1
X574 N1100 N1110 N1120 N113 N83 _NC1140 _NC1141 NOR4X0
X575 N179 N452 N1060 _NC1142 _NC1143 XOR2X1
X576 N178 N450 N107 _NC1144 _NC1145 XOR2X1
X577 N177 N451 N1080 _NC1146 _NC1147 XOR2X1
X578 N175 N434 N109 _NC1148 _NC1149 XOR2X1
X579 N1060 N107 N1080 N109 N1020 _NC1150 _NC1151 NAND4X0
X580 S_rad_i[51] N465 N103 _NC1152 _NC1153 XOR2X1
X581 S_rad_i[50] N464 N1040 _NC1154 _NC1155 XOR2X1
X582 S_rad_i[49] N463 N105 _NC1156 _NC1157 XOR2X1
X583 N1020 N103 N1040 N105 N84 _NC1158 _NC1159 NOR4X0
X584 N170 N421 N99 _NC1160 _NC1161 XOR2X1
X585 N172 N423 N1000 _NC1162 _NC1163 XOR2X1
X586 N171 N422 N101 _NC1164 _NC1165 XOR2X1
X587 N99 N1000 N101 N95 _NC1166 _NC1167 NAND3X0
X588 S_rad_i[21] N435 N960 _NC1168 _NC1169 XOR2X1
X589 S_rad_i[22] N436 N97 _NC1170 _NC1171 XOR2X1
X590 S_rad_i[16] N430 N980 _NC1172 _NC1173 XOR2X1
X591 N95 N960 N97 N980 N85 _NC1174 _NC1175 NOR4X0
X592 N168 N461 N91 _NC1176 _NC1177 XOR2X1
X593 N165 N447 N920 _NC1178 _NC1179 XOR2X1
X594 N164 N449 N93 _NC1180 _NC1181 XOR2X1
X595 N163 N453 N940 _NC1182 _NC1183 XOR2X1
X596 N91 N920 N93 N940 N87 _NC1184 _NC1185 NAND4X0
X597 S_rad_i[46] N460 N880 _NC1186 _NC1187 XOR2X1
X598 S_rad_i[0] N414 N89 _NC1188 _NC1189 XOR2X1
X599 S_rad_i[48] N462 N900 _NC1190 _NC1191 XOR2X1
X600 N87 N880 N89 N900 N860 _NC1192 _NC1193 NOR4X0
X601 N83 N84 N85 N860 N470 _NC1194 _NC1195 NAND4X0
X602 N186 N419 N80 _NC1196 _NC1197 XOR2X1
X603 N188 N424 N81 _NC1198 _NC1199 XOR2X1
X604 N187 N420 N82 _NC1200 _NC1201 XOR2X1
X605 N80 N81 N82 N76 _NC1202 _NC1203 NAND3X0
X606 S_rad_i[19] N433 N77 _NC1204 _NC1205 XOR2X1
X607 S_rad_i[23] N437 N78 _NC1206 _NC1207 XOR2X1
X608 S_rad_i[18] N432 N79 _NC1208 _NC1209 XOR2X1
X609 N76 N77 N78 N79 N490 _NC1210 _NC1211 NOR4X0
X610 N182 N445 N72 _NC1212 _NC1213 XOR2X1
X611 N181 N444 N73 _NC1214 _NC1215 XOR2X1
X612 N180 N446 N74 _NC1216 _NC1217 XOR2X1
X613 N176 N429 N75 _NC1218 _NC1219 XOR2X1
X614 N72 N73 N74 N75 N68 _NC1220 _NC1221 NAND4X0
X615 S_rad_i[43] N457 N69 _NC1222 _NC1223 XOR2X1
X616 S_rad_i[44] N458 N70 _NC1224 _NC1225 XOR2X1
X617 S_rad_i[45] N459 N71 _NC1226 _NC1227 XOR2X1
X618 N68 N69 N70 N71 N500 _NC1228 _NC1229 NOR4X0
X619 N169 N456 N65 _NC1230 _NC1231 XOR2X1
X620 N174 N415 N66 _NC1232 _NC1233 XOR2X1
X621 N173 N416 N67 _NC1234 _NC1235 XOR2X1
X622 N65 N66 N67 N61 _NC1236 _NC1237 NAND3X0
X623 S_rad_i[14] N428 N62 _NC1238 _NC1239 XOR2X1
X624 S_rad_i[13] N427 N63 _NC1240 _NC1241 XOR2X1
X625 S_rad_i[3] N417 N64 _NC1242 _NC1243 XOR2X1
X626 N61 N62 N63 N64 N510 _NC1244 _NC1245 NOR4X0
X627 N167 N442 N570 _NC1246 _NC1247 XOR2X1
X628 N166 N443 N580 _NC1248 _NC1249 XOR2X1
X629 N190 N441 N590 _NC1250 _NC1251 XOR2X1
X630 N189 N440 N60 _NC1252 _NC1253 XOR2X1
X631 N570 N580 N590 N60 N530 _NC1254 _NC1255 NAND4X0
X632 S_rad_i[41] N455 N540 _NC1256 _NC1257 XOR2X1
X633 S_rad_i[40] N454 N550 _NC1258 _NC1259 XOR2X1
X634 S_rad_i[34] N448 N560 _NC1260 _NC1261 XOR2X1
X635 N530 N540 N550 N560 N520 _NC1262 _NC1263 NOR4X0
X636 N490 N500 N510 N520 N480 _NC1264 _NC1265 NAND4X0
X637 S_ine_o N4370 N4410 N4510 N211 _NC1266 _NC1267 AO22X1
X638 Clk_i S_ine_o Ine_o _NC1268 _NC1269 _NC1270 DFFX1
X639 Clk_i N211 S_ine_o _NC1271 _NC1272 _NC1273 DFFX1
X640 Clk_i S_sqr_o[0] Sqr_o[0] _NC1274 _NC1275 _NC1276 DFFX1
X641 Clk_i N212 S_sqr_o[0] _NC1277 _NC1278 _NC1279 DFFX1
X642 Clk_i S_sqr_o[1] Sqr_o[1] _NC1280 _NC1281 _NC1282 DFFX1
X643 Clk_i N213 S_sqr_o[1] _NC1283 _NC1284 _NC1285 DFFX1
X644 Clk_i S_sqr_o[2] Sqr_o[2] _NC1286 _NC1287 _NC1288 DFFX1
X645 Clk_i N214 S_sqr_o[2] _NC1289 _NC1290 _NC1291 DFFX1
X646 Clk_i S_sqr_o[3] Sqr_o[3] _NC1292 _NC1293 _NC1294 DFFX1
X647 Clk_i N215 S_sqr_o[3] _NC1295 _NC1296 _NC1297 DFFX1
X648 Clk_i S_sqr_o[4] Sqr_o[4] _NC1298 _NC1299 _NC1300 DFFX1
X649 Clk_i N216 S_sqr_o[4] _NC1301 _NC1302 _NC1303 DFFX1
X650 Clk_i S_sqr_o[5] Sqr_o[5] _NC1304 _NC1305 _NC1306 DFFX1
X651 Clk_i N217 S_sqr_o[5] _NC1307 _NC1308 _NC1309 DFFX1
X652 Clk_i S_sqr_o[6] Sqr_o[6] _NC1310 _NC1311 _NC1312 DFFX1
X653 Clk_i N218 S_sqr_o[6] _NC1313 _NC1314 _NC1315 DFFX1
X654 Clk_i S_sqr_o[7] Sqr_o[7] _NC1316 _NC1317 _NC1318 DFFX1
X655 Clk_i N219 S_sqr_o[7] _NC1319 _NC1320 _NC1321 DFFX1
X656 Clk_i S_sqr_o[8] Sqr_o[8] _NC1322 _NC1323 _NC1324 DFFX1
X657 Clk_i N220 S_sqr_o[8] _NC1325 _NC1326 _NC1327 DFFX1
X658 Clk_i S_sqr_o[9] Sqr_o[9] _NC1328 _NC1329 _NC1330 DFFX1
X659 Clk_i N221 S_sqr_o[9] _NC1331 _NC1332 _NC1333 DFFX1
X660 Clk_i S_sqr_o[10] Sqr_o[10] _NC1334 _NC1335 _NC1336 DFFX1
X661 Clk_i N222 S_sqr_o[10] _NC1337 _NC1338 _NC1339 DFFX1
X662 Clk_i S_sqr_o[11] Sqr_o[11] _NC1340 _NC1341 _NC1342 DFFX1
X663 Clk_i N223 S_sqr_o[11] _NC1343 _NC1344 _NC1345 DFFX1
X664 Clk_i S_sqr_o[12] Sqr_o[12] _NC1346 _NC1347 _NC1348 DFFX1
X665 Clk_i N224 S_sqr_o[12] _NC1349 _NC1350 _NC1351 DFFX1
X666 Clk_i S_sqr_o[13] Sqr_o[13] _NC1352 _NC1353 _NC1354 DFFX1
X667 Clk_i N225 S_sqr_o[13] _NC1355 _NC1356 _NC1357 DFFX1
X668 Clk_i S_sqr_o[14] Sqr_o[14] _NC1358 _NC1359 _NC1360 DFFX1
X669 Clk_i N226 S_sqr_o[14] _NC1361 _NC1362 _NC1363 DFFX1
X670 Clk_i S_sqr_o[15] Sqr_o[15] _NC1364 _NC1365 _NC1366 DFFX1
X671 Clk_i N227 S_sqr_o[15] _NC1367 _NC1368 _NC1369 DFFX1
X672 Clk_i S_sqr_o[16] Sqr_o[16] _NC1370 _NC1371 _NC1372 DFFX1
X673 Clk_i N228 S_sqr_o[16] _NC1373 _NC1374 _NC1375 DFFX1
X674 Clk_i S_sqr_o[17] Sqr_o[17] _NC1376 _NC1377 _NC1378 DFFX1
X675 Clk_i N229 S_sqr_o[17] _NC1379 _NC1380 _NC1381 DFFX1
X676 Clk_i S_sqr_o[18] Sqr_o[18] _NC1382 _NC1383 _NC1384 DFFX1
X677 Clk_i N230 S_sqr_o[18] _NC1385 _NC1386 _NC1387 DFFX1
X678 Clk_i S_sqr_o[19] Sqr_o[19] _NC1388 _NC1389 _NC1390 DFFX1
X679 Clk_i N231 S_sqr_o[19] _NC1391 _NC1392 _NC1393 DFFX1
X680 Clk_i S_sqr_o[20] Sqr_o[20] _NC1394 _NC1395 _NC1396 DFFX1
X681 Clk_i N232 S_sqr_o[20] _NC1397 _NC1398 _NC1399 DFFX1
X682 Clk_i S_sqr_o[21] Sqr_o[21] _NC1400 _NC1401 _NC1402 DFFX1
X683 Clk_i N233 S_sqr_o[21] _NC1403 _NC1404 _NC1405 DFFX1
X684 Clk_i S_sqr_o[22] Sqr_o[22] _NC1406 _NC1407 _NC1408 DFFX1
X685 Clk_i N234 S_sqr_o[22] _NC1409 _NC1410 _NC1411 DFFX1
X686 Clk_i S_sqr_o[23] Sqr_o[23] _NC1412 _NC1413 _NC1414 DFFX1
X687 Clk_i N235 S_sqr_o[23] _NC1415 _NC1416 _NC1417 DFFX1
X688 Clk_i S_sqr_o[24] Sqr_o[24] _NC1418 _NC1419 _NC1420 DFFX1
X689 Clk_i N236 S_sqr_o[24] _NC1421 _NC1422 _NC1423 DFFX1
X690 Clk_i S_sqr_o[25] Sqr_o[25] _NC1424 _NC1425 _NC1426 DFFX1
X691 Clk_i N237 S_sqr_o[25] _NC1427 _NC1428 _NC1429 DFFX1
X692 Clk_i N238 R1_2[0] _NC1430 _NC1431 _NC1432 DFFX1
X693 Clk_i N239 R1_2[1] _NC1433 _NC1434 _NC1435 DFFX1
X694 Clk_i N240 R1_2[2] _NC1436 _NC1437 _NC1438 DFFX1
X695 Clk_i N241 R1_2[3] _NC1439 _NC1440 _NC1441 DFFX1
X696 Clk_i N242 R1_2[4] _NC1442 _NC1443 _NC1444 DFFX1
X697 Clk_i N243 R1_2[5] _NC1445 _NC1446 _NC1447 DFFX1
X698 Clk_i N244 R1_2[6] _NC1448 _NC1449 _NC1450 DFFX1
X699 Clk_i N245 R1_2[7] _NC1451 _NC1452 _NC1453 DFFX1
X700 Clk_i N246 R1_2[8] _NC1454 _NC1455 _NC1456 DFFX1
X701 Clk_i N247 R1_2[9] _NC1457 _NC1458 _NC1459 DFFX1
X702 Clk_i N248 R1_2[10] _NC1460 _NC1461 _NC1462 DFFX1
X703 Clk_i N249 R1_2[11] _NC1463 _NC1464 _NC1465 DFFX1
X704 Clk_i N250 R1_2[12] _NC1466 _NC1467 _NC1468 DFFX1
X705 Clk_i N251 R1_2[13] _NC1469 _NC1470 _NC1471 DFFX1
X706 Clk_i N252 R1_2[14] _NC1472 _NC1473 _NC1474 DFFX1
X707 Clk_i N253 R1_2[15] _NC1475 _NC1476 _NC1477 DFFX1
X708 Clk_i N254 R1_2[16] _NC1478 _NC1479 _NC1480 DFFX1
X709 Clk_i N255 R1_2[17] _NC1481 _NC1482 _NC1483 DFFX1
X710 Clk_i N256 R1_2[18] _NC1484 _NC1485 _NC1486 DFFX1
X711 Clk_i N257 R1_2[19] _NC1487 _NC1488 _NC1489 DFFX1
X712 Clk_i N258 R1_2[20] _NC1490 _NC1491 _NC1492 DFFX1
X713 Clk_i N259 R1_2[21] _NC1493 _NC1494 _NC1495 DFFX1
X714 Clk_i N260 R1_2[22] _NC1496 _NC1497 _NC1498 DFFX1
X715 Clk_i N261 R1_2[23] _NC1499 _NC1500 _NC1501 DFFX1
X716 Clk_i N262 R1_2[24] _NC1502 _NC1503 _NC1504 DFFX1
X717 Clk_i N263 R1_2[25] _NC1505 _NC1506 _NC1507 DFFX1
X718 Clk_i N264 R1_2[26] _NC1508 _NC1509 _NC1510 DFFX1
X719 Clk_i N265 R1_2[27] _NC1511 _NC1512 _NC1513 DFFX1
X720 Clk_i N266 R1_2[28] _NC1514 _NC1515 _NC1516 DFFX1
X721 Clk_i N267 R1_2[29] _NC1517 _NC1518 _NC1519 DFFX1
X722 Clk_i N268 R1_2[30] _NC1520 _NC1521 _NC1522 DFFX1
X723 Clk_i N269 R1_2[31] _NC1523 _NC1524 _NC1525 DFFX1
X724 Clk_i N270 R1_2[32] _NC1526 _NC1527 _NC1528 DFFX1
X725 Clk_i N271 R1_2[33] _NC1529 _NC1530 _NC1531 DFFX1
X726 Clk_i N272 R1_2[34] _NC1532 _NC1533 _NC1534 DFFX1
X727 Clk_i N273 R1_2[35] _NC1535 _NC1536 _NC1537 DFFX1
X728 Clk_i N274 R1_2[36] _NC1538 _NC1539 _NC1540 DFFX1
X729 Clk_i N275 R1_2[37] _NC1541 _NC1542 _NC1543 DFFX1
X730 Clk_i N276 R1_2[38] _NC1544 _NC1545 _NC1546 DFFX1
X731 Clk_i N277 R1_2[39] _NC1547 _NC1548 _NC1549 DFFX1
X732 Clk_i N278 R1_2[40] _NC1550 _NC1551 _NC1552 DFFX1
X733 Clk_i N279 R1_2[41] _NC1553 _NC1554 _NC1555 DFFX1
X734 Clk_i N280 R1_2[42] _NC1556 _NC1557 _NC1558 DFFX1
X735 Clk_i N281 R1_2[43] _NC1559 _NC1560 _NC1561 DFFX1
X736 Clk_i N282 R1_2[44] _NC1562 _NC1563 _NC1564 DFFX1
X737 Clk_i N283 R1_2[45] _NC1565 _NC1566 _NC1567 DFFX1
X738 Clk_i N284 R1_2[46] _NC1568 _NC1569 _NC1570 DFFX1
X739 Clk_i N285 R1_2[47] _NC1571 _NC1572 _NC1573 DFFX1
X740 Clk_i N286 R1_2[48] _NC1574 _NC1575 _NC1576 DFFX1
X741 Clk_i N287 R1_2[49] _NC1577 _NC1578 _NC1579 DFFX1
X742 Clk_i N288 R1_2[50] _NC1580 _NC1581 _NC1582 DFFX1
X743 Clk_i N289 R1_2[51] _NC1583 _NC1584 _NC1585 DFFX1
X744 Clk_i N3920 R1[0] _NC1586 _NC1587 _NC1588 DFFX1
X745 Clk_i N3910 R1[1] _NC1589 _NC1590 _NC1591 DFFX1
X746 Clk_i N3900 R1[2] _NC1592 _NC1593 _NC1594 DFFX1
X747 Clk_i N3890 R1[3] _NC1595 _NC1596 _NC1597 DFFX1
X748 Clk_i N3880 R1[4] _NC1598 _NC1599 _NC1600 DFFX1
X749 Clk_i N3870 R1[5] _NC1601 _NC1602 _NC1603 DFFX1
X750 Clk_i N3860 R1[6] _NC1604 _NC1605 _NC1606 DFFX1
X751 Clk_i N3850 R1[7] _NC1607 _NC1608 _NC1609 DFFX1
X752 Clk_i N3840 R1[8] _NC1610 _NC1611 _NC1612 DFFX1
X753 Clk_i N3830 R1[9] _NC1613 _NC1614 _NC1615 DFFX1
X754 Clk_i N3820 R1[10] _NC1616 _NC1617 _NC1618 DFFX1
X755 Clk_i N3810 R1[11] _NC1619 _NC1620 _NC1621 DFFX1
X756 Clk_i N3800 R1[12] _NC1622 _NC1623 _NC1624 DFFX1
X757 Clk_i N3790 R1[13] _NC1625 _NC1626 _NC1627 DFFX1
X758 Clk_i N3780 R1[14] _NC1628 _NC1629 _NC1630 DFFX1
X759 Clk_i N3770 R1[15] _NC1631 _NC1632 _NC1633 DFFX1
X760 Clk_i N3760 R1[16] _NC1634 _NC1635 _NC1636 DFFX1
X761 Clk_i N3750 R1[17] _NC1637 _NC1638 _NC1639 DFFX1
X762 Clk_i N3740 R1[18] _NC1640 _NC1641 _NC1642 DFFX1
X763 Clk_i N3730 R1[19] _NC1643 _NC1644 _NC1645 DFFX1
X764 Clk_i N3720 R1[20] _NC1646 _NC1647 _NC1648 DFFX1
X765 Clk_i N3710 R1[21] _NC1649 _NC1650 _NC1651 DFFX1
X766 Clk_i N3700 R1[22] _NC1652 _NC1653 _NC1654 DFFX1
X767 Clk_i N3690 R1[23] _NC1655 _NC1656 _NC1657 DFFX1
X768 Clk_i N3680 R1[24] _NC1658 _NC1659 _NC1660 DFFX1
X769 Clk_i N3670 R1[25] _NC1661 _NC1662 _NC1663 DFFX1
X770 Clk_i N291 R0_2[50] _NC1664 _NC1665 _NC1666 DFFX1
X771 Clk_i N292 R0_2[49] _NC1667 _NC1668 _NC1669 DFFX1
X772 Clk_i N293 R0_2[48] _NC1670 _NC1671 _NC1672 DFFX1
X773 Clk_i N294 R0_2[47] _NC1673 _NC1674 _NC1675 DFFX1
X774 Clk_i N295 R0_2[46] _NC1676 _NC1677 _NC1678 DFFX1
X775 Clk_i N296 R0_2[45] _NC1679 _NC1680 _NC1681 DFFX1
X776 Clk_i N297 R0_2[44] _NC1682 _NC1683 _NC1684 DFFX1
X777 Clk_i N298 R0_2[43] _NC1685 _NC1686 _NC1687 DFFX1
X778 Clk_i N299 R0_2[42] _NC1688 _NC1689 _NC1690 DFFX1
X779 Clk_i N300 R0_2[41] _NC1691 _NC1692 _NC1693 DFFX1
X780 Clk_i N301 R0_2[40] _NC1694 _NC1695 _NC1696 DFFX1
X781 Clk_i N302 R0_2[39] _NC1697 _NC1698 _NC1699 DFFX1
X782 Clk_i N303 R0_2[38] _NC1700 _NC1701 _NC1702 DFFX1
X783 Clk_i N304 R0_2[37] _NC1703 _NC1704 _NC1705 DFFX1
X784 Clk_i N305 R0_2[36] _NC1706 _NC1707 _NC1708 DFFX1
X785 Clk_i N3060 R0_2[35] _NC1709 _NC1710 _NC1711 DFFX1
X786 Clk_i N307 R0_2[34] _NC1712 _NC1713 _NC1714 DFFX1
X787 Clk_i N308 R0_2[33] _NC1715 _NC1716 _NC1717 DFFX1
X788 Clk_i N3090 R0_2[32] _NC1718 _NC1719 _NC1720 DFFX1
X789 Clk_i N3100 R0_2[31] _NC1721 _NC1722 _NC1723 DFFX1
X790 Clk_i N3110 R0_2[30] _NC1724 _NC1725 _NC1726 DFFX1
X791 Clk_i N3120 R0_2[29] _NC1727 _NC1728 _NC1729 DFFX1
X792 Clk_i N3130 R0_2[28] _NC1730 _NC1731 _NC1732 DFFX1
X793 Clk_i N3140 R0_2[27] _NC1733 _NC1734 _NC1735 DFFX1
X794 Clk_i N3150 R0_2[26] _NC1736 _NC1737 _NC1738 DFFX1
X795 Clk_i N3160 R0_2[25] _NC1739 _NC1740 _NC1741 DFFX1
X796 Clk_i N3170 R0_2[24] _NC1742 _NC1743 _NC1744 DFFX1
X797 Clk_i N3180 R0_2[23] _NC1745 _NC1746 _NC1747 DFFX1
X798 Clk_i N3190 R0_2[22] _NC1748 _NC1749 _NC1750 DFFX1
X799 Clk_i N3200 R0_2[21] _NC1751 _NC1752 _NC1753 DFFX1
X800 Clk_i N3210 R0_2[20] _NC1754 _NC1755 _NC1756 DFFX1
X801 Clk_i N3220 R0_2[19] _NC1757 _NC1758 _NC1759 DFFX1
X802 Clk_i N3230 R0_2[18] _NC1760 _NC1761 _NC1762 DFFX1
X803 Clk_i N3240 R0_2[17] _NC1763 _NC1764 _NC1765 DFFX1
X804 Clk_i N3250 R0_2[16] _NC1766 _NC1767 _NC1768 DFFX1
X805 Clk_i N3260 R0_2[15] _NC1769 _NC1770 _NC1771 DFFX1
X806 Clk_i N3270 R0_2[14] _NC1772 _NC1773 _NC1774 DFFX1
X807 Clk_i N3280 R0_2[13] _NC1775 _NC1776 _NC1777 DFFX1
X808 Clk_i N3290 R0_2[12] _NC1778 _NC1779 _NC1780 DFFX1
X809 Clk_i N3300 R0_2[11] _NC1781 _NC1782 _NC1783 DFFX1
X810 Clk_i N3310 R0_2[10] _NC1784 _NC1785 _NC1786 DFFX1
X811 Clk_i N3320 R0_2[9] _NC1787 _NC1788 _NC1789 DFFX1
X812 Clk_i N3330 R0_2[8] _NC1790 _NC1791 _NC1792 DFFX1
X813 Clk_i N3340 R0_2[7] _NC1793 _NC1794 _NC1795 DFFX1
X814 Clk_i N335 R0_2[6] _NC1796 _NC1797 _NC1798 DFFX1
X815 Clk_i N336 R0_2[5] _NC1799 _NC1800 _NC1801 DFFX1
X816 Clk_i N337 R0_2[4] _NC1802 _NC1803 _NC1804 DFFX1
X817 Clk_i N338 R0_2[3] _NC1805 _NC1806 _NC1807 DFFX1
X818 Clk_i N339 R0_2[2] _NC1808 _NC1809 _NC1810 DFFX1
X819 Clk_i N340 R0_2[1] _NC1811 _NC1812 _NC1813 DFFX1
X820 Clk_i N290 R0_2[51] _NC1814 _NC1815 _NC1816 DFFX1
X821 Clk_i N342 R0[24] _NC1817 _NC1818 _NC1819 DFFX1
X822 Clk_i N343 R0[23] _NC1820 _NC1821 _NC1822 DFFX1
X823 Clk_i N344 R0[22] _NC1823 _NC1824 _NC1825 DFFX1
X824 Clk_i N345 R0[21] _NC1826 _NC1827 _NC1828 DFFX1
X825 Clk_i N346 R0[20] _NC1829 _NC1830 _NC1831 DFFX1
X826 Clk_i N347 R0[19] _NC1832 _NC1833 _NC1834 DFFX1
X827 Clk_i N348 R0[18] _NC1835 _NC1836 _NC1837 DFFX1
X828 Clk_i N349 R0[17] _NC1838 _NC1839 _NC1840 DFFX1
X829 Clk_i N350 R0[16] _NC1841 _NC1842 _NC1843 DFFX1
X830 Clk_i N351 R0[15] _NC1844 _NC1845 _NC1846 DFFX1
X831 Clk_i N352 R0[14] _NC1847 _NC1848 _NC1849 DFFX1
X832 Clk_i N353 R0[13] _NC1850 _NC1851 _NC1852 DFFX1
X833 Clk_i N354 R0[12] _NC1853 _NC1854 _NC1855 DFFX1
X834 Clk_i N355 R0[11] _NC1856 _NC1857 _NC1858 DFFX1
X835 Clk_i N356 R0[10] _NC1859 _NC1860 _NC1861 DFFX1
X836 Clk_i N357 R0[9] _NC1862 _NC1863 _NC1864 DFFX1
X837 Clk_i N358 R0[8] _NC1865 _NC1866 _NC1867 DFFX1
X838 Clk_i N359 R0[7] _NC1868 _NC1869 _NC1870 DFFX1
X839 Clk_i N360 R0[6] _NC1871 _NC1872 _NC1873 DFFX1
X840 Clk_i N361 R0[5] _NC1874 _NC1875 _NC1876 DFFX1
X841 Clk_i N3620 R0[4] _NC1877 _NC1878 _NC1879 DFFX1
X842 Clk_i N3630 R0[3] _NC1880 _NC1881 _NC1882 DFFX1
X843 Clk_i N3640 R0[2] _NC1883 _NC1884 _NC1885 DFFX1
X844 Clk_i N3650 R0[1] _NC1886 _NC1887 _NC1888 DFFX1
X845 Clk_i N341 R0[25] _NC1889 _NC1890 _NC1891 DFFX1
X846 Clk_i N3660 R0[0] _NC1892 _NC1893 _NC1894 DFFX1
X847 Clk_i N3930 R0_2[0] _NC1895 _NC1896 _NC1897 DFFX1
X848 Clk_i N86 B_2[0] _NC1898 _NC1899 _NC1900 DFFX1
X849 Clk_i N88 B_2[2] N204 _NC1901 _NC1902 DFFX1
X850 Clk_i N90 B_2[4] N205 _NC1903 _NC1904 DFFX1
X851 Clk_i N92 B_2[6] N206 _NC1905 _NC1906 DFFX1
X852 Clk_i N94 B_2[8] N207 _NC1907 _NC1908 DFFX1
X853 Clk_i N96 B_2[10] N208 _NC1909 _NC1910 DFFX1
X854 Clk_i N98 B_2[12] N209 _NC1911 _NC1912 DFFX1
X855 Clk_i N100 B_2[14] N210 _NC1913 _NC1914 DFFX1
X856 Clk_i N102 B_2[16] N133 _NC1915 _NC1916 DFFX1
X857 Clk_i N104 B_2[18] N1340 _NC1917 _NC1918 DFFX1
X858 Clk_i N106 B_2[20] N135 _NC1919 _NC1920 DFFX1
X859 Clk_i N108 B_2[22] N1360 _NC1921 _NC1922 DFFX1
X860 Clk_i N110 B_2[24] N1370 _NC1923 _NC1924 DFFX1
X861 Clk_i N112 B_2[26] N1380 _NC1925 _NC1926 DFFX1
X862 Clk_i N114 B_2[28] N1390 _NC1927 _NC1928 DFFX1
X863 Clk_i N116 B_2[30] N1400 _NC1929 _NC1930 DFFX1
X864 Clk_i N118 B_2[32] N141 _NC1931 _NC1932 DFFX1
X865 Clk_i N120 B_2[34] N1420 _NC1933 _NC1934 DFFX1
X866 Clk_i N122 B_2[36] N143 _NC1935 _NC1936 DFFX1
X867 Clk_i N124 B_2[38] N144 _NC1937 _NC1938 DFFX1
X868 Clk_i N126 B_2[40] N145 _NC1939 _NC1940 DFFX1
X869 Clk_i N128 B_2[42] N146 _NC1941 _NC1942 DFFX1
X870 Clk_i N130 B_2[44] N147 _NC1943 _NC1944 DFFX1
X871 Clk_i N132 B_2[46] N148 _NC1945 _NC1946 DFFX1
X872 Clk_i N134 B_2[48] N149 _NC1947 _NC1948 DFFX1
X873 Clk_i N4230 B_2[50] N150 _NC1949 _NC1950 DFFX1
X874 Clk_i N35 B[0] _NC1951 _NC1952 _NC1953 DFFX1
X875 Clk_i N36 B[1] N151 _NC1954 _NC1955 DFFX1
X876 Clk_i N37 B[2] N152 _NC1956 _NC1957 DFFX1
X877 Clk_i N38 B[3] N153 _NC1958 _NC1959 DFFX1
X878 Clk_i N39 B[4] N154 _NC1960 _NC1961 DFFX1
X879 Clk_i N40 B[5] N155 _NC1962 _NC1963 DFFX1
X880 Clk_i N41 B[6] N156 _NC1964 _NC1965 DFFX1
X881 Clk_i N42 B[7] N157 _NC1966 _NC1967 DFFX1
X882 Clk_i N43 B[8] N158 _NC1968 _NC1969 DFFX1
X883 Clk_i N44 B[9] N159 _NC1970 _NC1971 DFFX1
X884 Clk_i N45 B[10] N160 _NC1972 _NC1973 DFFX1
X885 Clk_i N46 B[11] N161 _NC1974 _NC1975 DFFX1
X886 Clk_i N47 B[12] N162 _NC1976 _NC1977 DFFX1
X887 Clk_i N48 B[13] N191 _NC1978 _NC1979 DFFX1
X888 Clk_i N49 B[14] N192 _NC1980 _NC1981 DFFX1
X889 Clk_i N50 B[15] N193 _NC1982 _NC1983 DFFX1
X890 Clk_i N51 B[16] N194 _NC1984 _NC1985 DFFX1
X891 Clk_i N52 B[17] N195 _NC1986 _NC1987 DFFX1
X892 Clk_i N53 B[18] N196 _NC1988 _NC1989 DFFX1
X893 Clk_i N54 B[19] N197 _NC1990 _NC1991 DFFX1
X894 Clk_i N55 B[20] N198 _NC1992 _NC1993 DFFX1
X895 Clk_i N56 B[21] N199 _NC1994 _NC1995 DFFX1
X896 Clk_i N57 B[22] N200 _NC1996 _NC1997 DFFX1
X897 Clk_i N58 B[23] N201 _NC1998 _NC1999 DFFX1
X898 Clk_i N59 B[24] N202 _NC2000 _NC2001 DFFX1
X899 Clk_i N4240 B[25] N203 _NC2002 _NC2003 DFFX1
X900 Clk_i N138 C[2] N1310 _NC2004 _NC2005 DFFX1
X901 Clk_i N137 C[1] N2 _NC2006 _NC2007 DFFX1
X902 Clk_i N136 C[0] N17 _NC2008 _NC2009 DFFX1
X903 Clk_i N3940 S_count[3] _NC2010 _NC2011 _NC2012 DFFX1
X904 Clk_i N3950 S_count[2] _NC2013 _NC2014 _NC2015 DFFX1
X905 Clk_i N3960 S_count[1] _NC2016 _NC2017 _NC2018 DFFX1
X906 Clk_i N3990 S_count[4] _NC2019 _NC2020 _NC2021 DFFX1
X907 Clk_i S_ready_o Ready_o _NC2022 _NC2023 _NC2024 DFFX1
X908 Clk_i N3970 S_ready_o _NC2025 _NC2026 _NC2027 DFFX1
X909 Clk_i N3980 S_state _NC2028 _NC2029 _NC2030 DFFX1
X910 Clk_i N4000 S_count[0] N16 _NC2031 _NC2032 DFFX1
X911 Clk_i Start_i _NC2033 N1 _NC2034 _NC2035 DFFX1
X912 Clk_i Rad_i[0] S_rad_i[0] _NC2036 _NC2037 _NC2038 DFFX1
X913 Clk_i Rad_i[1] S_rad_i[1] N174 _NC2039 _NC2040 DFFX1
X914 Clk_i Rad_i[2] S_rad_i[2] N173 _NC2041 _NC2042 DFFX1
X915 Clk_i Rad_i[3] S_rad_i[3] _NC2043 _NC2044 _NC2045 DFFX1
X916 Clk_i Rad_i[4] S_rad_i[4] N183 _NC2046 _NC2047 DFFX1
X917 Clk_i Rad_i[5] S_rad_i[5] N186 _NC2048 _NC2049 DFFX1
X918 Clk_i Rad_i[6] S_rad_i[6] N187 _NC2050 _NC2051 DFFX1
X919 Clk_i Rad_i[7] S_rad_i[7] N170 _NC2052 _NC2053 DFFX1
X920 Clk_i Rad_i[8] S_rad_i[8] N171 _NC2054 _NC2055 DFFX1
X921 Clk_i Rad_i[9] S_rad_i[9] N172 _NC2056 _NC2057 DFFX1
X922 Clk_i Rad_i[10] S_rad_i[10] N188 _NC2058 _NC2059 DFFX1
X923 Clk_i Rad_i[11] S_rad_i[11] _NC2060 _NC2061 _NC2062 DFFX1
X924 Clk_i Rad_i[12] S_rad_i[12] N185 _NC2063 _NC2064 DFFX1
X925 Clk_i Rad_i[13] S_rad_i[13] _NC2065 _NC2066 _NC2067 DFFX1
X926 Clk_i Rad_i[14] S_rad_i[14] _NC2068 _NC2069 _NC2070 DFFX1
X927 Clk_i Rad_i[15] S_rad_i[15] N176 _NC2071 _NC2072 DFFX1
X928 Clk_i Rad_i[16] S_rad_i[16] _NC2073 _NC2074 _NC2075 DFFX1
X929 Clk_i Rad_i[17] S_rad_i[17] N184 _NC2076 _NC2077 DFFX1
X930 Clk_i Rad_i[18] S_rad_i[18] _NC2078 _NC2079 _NC2080 DFFX1
X931 Clk_i Rad_i[19] S_rad_i[19] _NC2081 _NC2082 _NC2083 DFFX1
X932 Clk_i Rad_i[20] S_rad_i[20] N175 _NC2084 _NC2085 DFFX1
X933 Clk_i Rad_i[21] S_rad_i[21] _NC2086 _NC2087 _NC2088 DFFX1
X934 Clk_i Rad_i[22] S_rad_i[22] _NC2089 _NC2090 _NC2091 DFFX1
X935 Clk_i Rad_i[23] S_rad_i[23] _NC2092 _NC2093 _NC2094 DFFX1
X936 Clk_i Rad_i[24] S_rad_i[24] _NC2095 _NC2096 _NC2097 DFFX1
X937 Clk_i Rad_i[25] S_rad_i[25] _NC2098 _NC2099 _NC2100 DFFX1
X938 Clk_i Rad_i[26] S_rad_i[26] N189 _NC2101 _NC2102 DFFX1
X939 Clk_i Rad_i[27] S_rad_i[27] N190 _NC2103 _NC2104 DFFX1
X940 Clk_i Rad_i[28] S_rad_i[28] N167 _NC2105 _NC2106 DFFX1
X941 Clk_i Rad_i[29] S_rad_i[29] N166 _NC2107 _NC2108 DFFX1
X942 Clk_i Rad_i[30] S_rad_i[30] N181 _NC2109 _NC2110 DFFX1
X943 Clk_i Rad_i[31] S_rad_i[31] N182 _NC2111 _NC2112 DFFX1
X944 Clk_i Rad_i[32] S_rad_i[32] N180 _NC2113 _NC2114 DFFX1
X945 Clk_i Rad_i[33] S_rad_i[33] N165 _NC2115 _NC2116 DFFX1
X946 Clk_i Rad_i[34] S_rad_i[34] _NC2117 _NC2118 _NC2119 DFFX1
X947 Clk_i Rad_i[35] S_rad_i[35] N164 _NC2120 _NC2121 DFFX1
X948 Clk_i Rad_i[36] S_rad_i[36] N178 _NC2122 _NC2123 DFFX1
X949 Clk_i Rad_i[37] S_rad_i[37] N177 _NC2124 _NC2125 DFFX1
X950 Clk_i Rad_i[38] S_rad_i[38] N179 _NC2126 _NC2127 DFFX1
X951 Clk_i Rad_i[39] S_rad_i[39] N163 _NC2128 _NC2129 DFFX1
X952 Clk_i Rad_i[40] S_rad_i[40] _NC2130 _NC2131 _NC2132 DFFX1
X953 Clk_i Rad_i[41] S_rad_i[41] _NC2133 _NC2134 _NC2135 DFFX1
X954 Clk_i Rad_i[42] S_rad_i[42] N169 _NC2136 _NC2137 DFFX1
X955 Clk_i Rad_i[43] S_rad_i[43] _NC2138 _NC2139 _NC2140 DFFX1
X956 Clk_i Rad_i[44] S_rad_i[44] _NC2141 _NC2142 _NC2143 DFFX1
X957 Clk_i Rad_i[45] S_rad_i[45] _NC2144 _NC2145 _NC2146 DFFX1
X958 Clk_i Rad_i[46] S_rad_i[46] _NC2147 _NC2148 _NC2149 DFFX1
X959 Clk_i Rad_i[47] S_rad_i[47] N168 _NC2150 _NC2151 DFFX1
X960 Clk_i Rad_i[48] S_rad_i[48] _NC2152 _NC2153 _NC2154 DFFX1
X961 Clk_i Rad_i[49] S_rad_i[49] _NC2155 _NC2156 _NC2157 DFFX1
X962 Clk_i Rad_i[50] S_rad_i[50] _NC2158 _NC2159 _NC2160 DFFX1
X963 Clk_i Rad_i[51] S_rad_i[51] _NC2161 _NC2162 _NC2163 DFFX1
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_inc_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] A[48] A[49] A[50] A[51] SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] SUM[28] SUM[29] SUM[30] SUM[31] SUM[32] SUM[33] SUM[34] SUM[35] SUM[36] SUM[37] SUM[38] SUM[39] SUM[40] SUM[41] SUM[42] SUM[43] SUM[44] SUM[45] SUM[46] SUM[47] SUM[48] SUM[49] SUM[50] SUM[51]
X0 A[0] _NC0 _NC1 SUM[0] INVX0
X1 Carry[49] A[51] SUM[51] _NC2 _NC3 XOR2X1
X2 A[1] A[0] Carry[0] _NC4 _NC5 _NC6 HADDX1
X3 A[2] Carry[0] Carry[1] _NC7 _NC8 _NC9 HADDX1
X4 A[3] Carry[1] Carry[2] _NC10 _NC11 _NC12 HADDX1
X5 A[4] Carry[2] Carry[3] _NC13 _NC14 _NC15 HADDX1
X6 A[5] Carry[3] Carry[4] _NC16 _NC17 _NC18 HADDX1
X7 A[6] Carry[4] Carry[5] _NC19 _NC20 _NC21 HADDX1
X8 A[7] Carry[5] Carry[6] _NC22 _NC23 _NC24 HADDX1
X9 A[8] Carry[6] Carry[7] _NC25 _NC26 _NC27 HADDX1
X10 A[9] Carry[7] Carry[8] _NC28 _NC29 _NC30 HADDX1
X11 A[10] Carry[8] Carry[9] _NC31 _NC32 _NC33 HADDX1
X12 A[11] Carry[9] Carry[10] _NC34 _NC35 _NC36 HADDX1
X13 A[12] Carry[10] Carry[11] _NC37 _NC38 _NC39 HADDX1
X14 A[13] Carry[11] Carry[12] _NC40 _NC41 _NC42 HADDX1
X15 A[14] Carry[12] Carry[13] _NC43 _NC44 _NC45 HADDX1
X16 A[15] Carry[13] Carry[14] _NC46 _NC47 _NC48 HADDX1
X17 A[16] Carry[14] Carry[15] _NC49 _NC50 _NC51 HADDX1
X18 A[17] Carry[15] Carry[16] _NC52 _NC53 _NC54 HADDX1
X19 A[18] Carry[16] Carry[17] _NC55 _NC56 _NC57 HADDX1
X20 A[19] Carry[17] Carry[18] _NC58 _NC59 _NC60 HADDX1
X21 A[20] Carry[18] Carry[19] _NC61 _NC62 _NC63 HADDX1
X22 A[21] Carry[19] Carry[20] _NC64 _NC65 _NC66 HADDX1
X23 A[22] Carry[20] Carry[21] _NC67 _NC68 _NC69 HADDX1
X24 A[23] Carry[21] Carry[22] _NC70 _NC71 _NC72 HADDX1
X25 A[24] Carry[22] Carry[23] _NC73 _NC74 _NC75 HADDX1
X26 A[25] Carry[23] Carry[24] _NC76 _NC77 _NC78 HADDX1
X27 A[26] Carry[24] Carry[25] _NC79 _NC80 _NC81 HADDX1
X28 A[27] Carry[25] Carry[26] _NC82 _NC83 _NC84 HADDX1
X29 A[28] Carry[26] Carry[27] _NC85 _NC86 _NC87 HADDX1
X30 A[29] Carry[27] Carry[28] _NC88 _NC89 _NC90 HADDX1
X31 A[30] Carry[28] Carry[29] _NC91 _NC92 _NC93 HADDX1
X32 A[31] Carry[29] Carry[30] _NC94 _NC95 _NC96 HADDX1
X33 A[32] Carry[30] Carry[31] _NC97 _NC98 _NC99 HADDX1
X34 A[33] Carry[31] Carry[32] _NC100 _NC101 _NC102 HADDX1
X35 A[34] Carry[32] Carry[33] _NC103 _NC104 _NC105 HADDX1
X36 A[35] Carry[33] Carry[34] _NC106 _NC107 _NC108 HADDX1
X37 A[36] Carry[34] Carry[35] _NC109 _NC110 _NC111 HADDX1
X38 A[37] Carry[35] Carry[36] _NC112 _NC113 _NC114 HADDX1
X39 A[38] Carry[36] Carry[37] _NC115 _NC116 _NC117 HADDX1
X40 A[39] Carry[37] Carry[38] _NC118 _NC119 _NC120 HADDX1
X41 A[40] Carry[38] Carry[39] _NC121 _NC122 _NC123 HADDX1
X42 A[41] Carry[39] Carry[40] _NC124 _NC125 _NC126 HADDX1
X43 A[42] Carry[40] Carry[41] _NC127 _NC128 _NC129 HADDX1
X44 A[43] Carry[41] Carry[42] _NC130 _NC131 _NC132 HADDX1
X45 A[44] Carry[42] Carry[43] _NC133 _NC134 _NC135 HADDX1
X46 A[45] Carry[43] Carry[44] _NC136 _NC137 _NC138 HADDX1
X47 A[46] Carry[44] Carry[45] _NC139 _NC140 _NC141 HADDX1
X48 A[47] Carry[45] Carry[46] _NC142 _NC143 _NC144 HADDX1
X49 A[48] Carry[46] Carry[47] _NC145 _NC146 _NC147 HADDX1
X50 A[49] Carry[47] Carry[48] _NC148 _NC149 _NC150 HADDX1
X51 A[50] Carry[48] Carry[49] _NC151 _NC152 _NC153 HADDX1
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_inc_0

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_3 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] A[48] A[49] A[50] A[51] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] B[48] B[49] B[50] B[51] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] DIFF[9] DIFF[10] DIFF[11] DIFF[12] DIFF[13] DIFF[14] DIFF[15] DIFF[16] DIFF[17] DIFF[18] DIFF[19] DIFF[20] DIFF[21] DIFF[22] DIFF[23] DIFF[24] DIFF[25] DIFF[26] DIFF[27] DIFF[28] DIFF[29] DIFF[30] DIFF[31] DIFF[32] DIFF[33] DIFF[34] DIFF[35] DIFF[36] DIFF[37] DIFF[38] DIFF[39] DIFF[40] DIFF[41] DIFF[42] DIFF[43] DIFF[44] DIFF[45] DIFF[46] DIFF[47] DIFF[48] DIFF[49] DIFF[50] DIFF[51] CO
X0 N20 A[39] DIFF[39] _NC0 _NC1 XOR2X1
X1 N21 A[40] DIFF[40] _NC2 _NC3 XOR2X1
X2 N10 A[41] DIFF[41] _NC4 _NC5 XOR2X1
X3 N11 A[42] DIFF[42] _NC6 _NC7 XOR2X1
X4 N12 A[43] DIFF[43] _NC8 _NC9 XOR2X1
X5 N13 A[44] DIFF[44] _NC10 _NC11 XOR2X1
X6 N14 A[45] DIFF[45] _NC12 _NC13 XOR2X1
X7 N15 A[46] DIFF[46] _NC14 _NC15 XOR2X1
X8 N22 A[47] DIFF[47] _NC16 _NC17 XOR2X1
X9 N23 A[48] DIFF[48] _NC18 _NC19 XOR2X1
X10 N16 A[49] DIFF[49] _NC20 _NC21 XOR2X1
X11 N17 A[50] DIFF[50] _NC22 _NC23 XOR2X1
X12 N38 A[27] DIFF[27] _NC24 _NC25 XOR2X1
X13 N1 A[28] DIFF[28] _NC26 _NC27 XOR2X1
X14 N2 A[29] DIFF[29] _NC28 _NC29 XOR2X1
X15 N3 A[30] DIFF[30] _NC30 _NC31 XOR2X1
X16 N18 A[31] DIFF[31] _NC32 _NC33 XOR2X1
X17 N19 A[32] DIFF[32] _NC34 _NC35 XOR2X1
X18 N4 A[33] DIFF[33] _NC36 _NC37 XOR2X1
X19 N5 A[34] DIFF[34] _NC38 _NC39 XOR2X1
X20 N6 A[35] DIFF[35] _NC40 _NC41 XOR2X1
X21 N7 A[36] DIFF[36] _NC42 _NC43 XOR2X1
X22 N8 A[37] DIFF[37] _NC44 _NC45 XOR2X1
X23 N9 A[38] DIFF[38] _NC46 _NC47 XOR2X1
X24 B[1] A[1] DIFF[1] _NC48 _NC49 XOR2X1
X25 A[0] _NC50 _NC51 DIFF[0] NBUFFX2
X26 A[50] _NC52 _NC53 N39 INVX0
X27 N39 N17 Carry[49] _NC54 _NC55 NAND2X1
X28 N42 N22 N23 _NC56 _NC57 AND2X1
X29 N43 N15 N22 _NC58 _NC59 AND2X1
X30 N50 N20 N21 _NC60 _NC61 AND2X1
X31 N26 N9 N20 _NC62 _NC63 AND2X1
X32 N33 N18 N19 _NC64 _NC65 AND2X1
X33 N34 N3 N18 _NC66 _NC67 AND2X1
X34 Carry[49] A[51] DIFF[51] _NC68 _NC69 XNOR2X1
X35 N40 N16 N17 _NC70 _NC71 AND2X1
X36 N41 N23 N16 _NC72 _NC73 AND2X1
X37 N44 N14 N15 _NC74 _NC75 AND2X1
X38 N45 N13 N14 _NC76 _NC77 AND2X1
X39 N46 N12 N13 _NC78 _NC79 AND2X1
X40 N47 N11 N12 _NC80 _NC81 AND2X1
X41 N48 N10 N11 _NC82 _NC83 AND2X1
X42 N49 N21 N10 _NC84 _NC85 AND2X1
X43 N27 N8 N9 _NC86 _NC87 AND2X1
X44 N28 N7 N8 _NC88 _NC89 AND2X1
X45 N29 N6 N7 _NC90 _NC91 AND2X1
X46 N30 N5 N6 _NC92 _NC93 AND2X1
X47 N31 N4 N5 _NC94 _NC95 AND2X1
X48 N32 N19 N4 _NC96 _NC97 AND2X1
X49 N35 N2 N3 _NC98 _NC99 AND2X1
X50 N36 N1 N2 _NC100 _NC101 AND2X1
X51 N37 N38 N1 _NC102 _NC103 AND2X1
X52 B[26] _NC104 _NC105 N51 INVX0
X53 B[25] _NC106 _NC107 N52 INVX0
X54 B[24] _NC108 _NC109 N53 INVX0
X55 B[23] _NC110 _NC111 N54 INVX0
X56 B[22] _NC112 _NC113 N55 INVX0
X57 B[21] _NC114 _NC115 N56 INVX0
X58 B[20] _NC116 _NC117 N57 INVX0
X59 B[19] _NC118 _NC119 N58 INVX0
X60 B[18] _NC120 _NC121 N59 INVX0
X61 B[17] _NC122 _NC123 N60 INVX0
X62 B[16] _NC124 _NC125 N61 INVX0
X63 B[15] _NC126 _NC127 N62 INVX0
X64 B[14] _NC128 _NC129 N63 INVX0
X65 B[13] _NC130 _NC131 N64 INVX0
X66 B[12] _NC132 _NC133 N65 INVX0
X67 B[11] _NC134 _NC135 N66 INVX0
X68 B[10] _NC136 _NC137 N67 INVX0
X69 B[9] _NC138 _NC139 N68 INVX0
X70 B[8] _NC140 _NC141 N69 INVX0
X71 B[7] _NC142 _NC143 N70 INVX0
X72 B[6] _NC144 _NC145 N71 INVX0
X73 B[5] _NC146 _NC147 N72 INVX0
X74 B[4] _NC148 _NC149 N73 INVX0
X75 B[3] _NC150 _NC151 N74 INVX0
X76 A[1] _NC152 _NC153 N25 INVX0
X77 N25 B[1] Carry[0] _NC154 _NC155 NAND2X1
X78 B[2] _NC156 _NC157 N75 INVX0
X79 Carry[25] _NC158 _NC159 N38 INVX0
X80 A[33] _NC160 _NC161 N31 INVX0
X81 A[39] _NC162 _NC163 N50 INVX0
X82 A[42] _NC164 _NC165 N47 INVX0
X83 A[43] _NC166 _NC167 N46 INVX0
X84 A[45] _NC168 _NC169 N44 INVX0
X85 A[49] _NC170 _NC171 N40 INVX0
X86 A[48] _NC172 _NC173 N41 INVX0
X87 A[40] _NC174 _NC175 N49 INVX0
X88 A[27] _NC176 _NC177 N37 INVX0
X89 A[28] _NC178 _NC179 N36 INVX0
X90 A[32] _NC180 _NC181 N32 INVX0
X91 A[38] _NC182 _NC183 N26 INVX0
X92 A[41] _NC184 _NC185 N48 INVX0
X93 A[44] _NC186 _NC187 N45 INVX0
X94 A[29] _NC188 _NC189 N35 INVX0
X95 A[30] _NC190 _NC191 N34 INVX0
X96 A[31] _NC192 _NC193 N33 INVX0
X97 A[47] _NC194 _NC195 N42 INVX0
X98 A[34] _NC196 _NC197 N30 INVX0
X99 A[46] _NC198 _NC199 N43 INVX0
X100 A[35] _NC200 _NC201 N29 INVX0
X101 A[36] _NC202 _NC203 N28 INVX0
X102 A[37] _NC204 _NC205 N27 INVX0
X103 A[2] N75 Carry[0] Carry[1] DIFF[2] _NC206 _NC207 FADDX1
X104 A[3] N74 Carry[1] Carry[2] DIFF[3] _NC208 _NC209 FADDX1
X105 A[4] N73 Carry[2] Carry[3] DIFF[4] _NC210 _NC211 FADDX1
X106 A[5] N72 Carry[3] Carry[4] DIFF[5] _NC212 _NC213 FADDX1
X107 A[6] N71 Carry[4] Carry[5] DIFF[6] _NC214 _NC215 FADDX1
X108 A[7] N70 Carry[5] Carry[6] DIFF[7] _NC216 _NC217 FADDX1
X109 A[8] N69 Carry[6] Carry[7] DIFF[8] _NC218 _NC219 FADDX1
X110 A[9] N68 Carry[7] Carry[8] DIFF[9] _NC220 _NC221 FADDX1
X111 A[10] N67 Carry[8] Carry[9] DIFF[10] _NC222 _NC223 FADDX1
X112 A[11] N66 Carry[9] Carry[10] DIFF[11] _NC224 _NC225 FADDX1
X113 A[12] N65 Carry[10] Carry[11] DIFF[12] _NC226 _NC227 FADDX1
X114 A[13] N64 Carry[11] Carry[12] DIFF[13] _NC228 _NC229 FADDX1
X115 A[14] N63 Carry[12] Carry[13] DIFF[14] _NC230 _NC231 FADDX1
X116 A[15] N62 Carry[13] Carry[14] DIFF[15] _NC232 _NC233 FADDX1
X117 A[16] N61 Carry[14] Carry[15] DIFF[16] _NC234 _NC235 FADDX1
X118 A[17] N60 Carry[15] Carry[16] DIFF[17] _NC236 _NC237 FADDX1
X119 A[18] N59 Carry[16] Carry[17] DIFF[18] _NC238 _NC239 FADDX1
X120 A[19] N58 Carry[17] Carry[18] DIFF[19] _NC240 _NC241 FADDX1
X121 A[20] N57 Carry[18] Carry[19] DIFF[20] _NC242 _NC243 FADDX1
X122 A[21] N56 Carry[19] Carry[20] DIFF[21] _NC244 _NC245 FADDX1
X123 A[22] N55 Carry[20] Carry[21] DIFF[22] _NC246 _NC247 FADDX1
X124 A[23] N54 Carry[21] Carry[22] DIFF[23] _NC248 _NC249 FADDX1
X125 A[24] N53 Carry[22] Carry[23] DIFF[24] _NC250 _NC251 FADDX1
X126 A[25] N52 Carry[23] Carry[24] DIFF[25] _NC252 _NC253 FADDX1
X127 A[26] N51 Carry[24] Carry[25] DIFF[26] _NC254 _NC255 FADDX1
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_3

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_cmp6_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] A[48] A[49] A[50] A[51] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] B[48] B[49] B[50] B[51] TC LT GT EQ LE GE NE
X0 A[21] N37 N141 _NC0 _NC1 NAND2X0
X1 A[20] N38 N144 _NC2 _NC3 NAND2X0
X2 A[22] N36 N140 _NC4 _NC5 NAND2X0
X3 N141 N144 N140 N179 _NC6 _NC7 AND3X1
X4 A[25] N33 N133 _NC8 _NC9 NAND2X0
X5 A[23] N35 N137 _NC10 _NC11 NAND2X0
X6 A[24] N34 N136 _NC12 _NC13 NAND2X0
X7 N179 N133 N137 N136 N95 _NC14 _NC15 AND4X1
X8 A[16] N42 N152 _NC16 _NC17 NAND2X0
X9 A[15] N43 N153 _NC18 _NC19 NAND2X0
X10 A[14] N44 N156 _NC20 _NC21 NAND2X0
X11 A[13] N45 N157 _NC22 _NC23 NAND2X0
X12 N152 N153 N156 N157 N178 _NC24 _NC25 AND4X1
X13 A[19] N39 N145 _NC26 _NC27 NAND2X0
X14 A[17] N41 N149 _NC28 _NC29 NAND2X0
X15 A[18] N40 N148 _NC30 _NC31 NAND2X0
X16 N178 N145 N149 N148 N96 _NC32 _NC33 AND4X1
X17 A[8] N50 N168 _NC34 _NC35 NAND2X0
X18 A[7] N51 N169 _NC36 _NC37 NAND2X0
X19 A[9] N49 N165 _NC38 _NC39 NAND2X0
X20 N168 N169 N165 N177 _NC40 _NC41 AND3X1
X21 A[12] N46 N160 _NC42 _NC43 NAND2X0
X22 A[10] N48 N164 _NC44 _NC45 NAND2X0
X23 A[11] N47 N161 _NC46 _NC47 NAND2X0
X24 N177 N160 N164 N161 N97 _NC48 _NC49 AND4X1
X25 N4 B[3] N103 _NC50 _NC51 OR2X1
X26 N5 B[2] N104 _NC52 _NC53 OR2X1
X27 A[51] N7 N105 _NC54 _NC55 NAND2X0
X28 A[4] N54 N101 _NC56 _NC57 NAND2X0
X29 N56 A[0] N175 _NC58 _NC59 NOR2X0
X30 N6 N175 N176 _NC60 _NC61 AND2X1
X31 N175 N6 B[1] N176 N104 N174 _NC62 _NC63 OA221X1
X32 B[2] N5 B[3] N4 N174 N173 _NC64 _NC65 AO221X1
X33 N101 N103 N173 N172 _NC66 _NC67 NAND3X0
X34 A[5] N53 A[4] N54 N172 N170 _NC68 _NC69 OA221X1
X35 A[6] N52 N100 _NC70 _NC71 NAND2X0
X36 A[5] N53 N102 _NC72 _NC73 NAND2X0
X37 N100 N102 N171 _NC74 _NC75 NAND2X0
X38 A[7] N51 A[6] N52 N170 N171 N166 _NC76 _NC77 OA222X1
X39 N168 N169 N167 _NC78 _NC79 NAND2X0
X40 A[9] N49 A[8] N50 N166 N167 N162 _NC80 _NC81 OA222X1
X41 N164 N165 N163 _NC82 _NC83 NAND2X0
X42 A[11] N47 A[10] N48 N162 N163 N158 _NC84 _NC85 OA222X1
X43 N160 N161 N159 _NC86 _NC87 NAND2X0
X44 A[13] N45 A[12] N46 N158 N159 N154 _NC88 _NC89 OA222X1
X45 N156 N157 N155 _NC90 _NC91 NAND2X0
X46 A[15] N43 A[14] N44 N154 N155 N150 _NC92 _NC93 OA222X1
X47 N152 N153 N151 _NC94 _NC95 NAND2X0
X48 A[17] N41 A[16] N42 N150 N151 N146 _NC96 _NC97 OA222X1
X49 N148 N149 N147 _NC98 _NC99 NAND2X0
X50 A[19] N39 A[18] N40 N146 N147 N142 _NC100 _NC101 OA222X1
X51 N144 N145 N143 _NC102 _NC103 NAND2X0
X52 A[21] N37 A[20] N38 N142 N143 N138 _NC104 _NC105 OA222X1
X53 N140 N141 N139 _NC106 _NC107 NAND2X0
X54 A[23] N35 A[22] N36 N138 N139 N134 _NC108 _NC109 OA222X1
X55 N136 N137 N135 _NC110 _NC111 NAND2X0
X56 A[25] N33 A[24] N34 N134 N135 N131 _NC112 _NC113 OA222X1
X57 A[26] N32 N71 _NC114 _NC115 NAND2X0
X58 N71 N133 N132 _NC116 _NC117 NAND2X0
X59 A[27] N31 A[26] N32 N131 N132 N129 _NC118 _NC119 OA222X1
X60 A[28] N30 N69 _NC120 _NC121 NAND2X0
X61 A[27] N31 N70 _NC122 _NC123 NAND2X0
X62 N69 N70 N130 _NC124 _NC125 NAND2X0
X63 A[29] N29 A[28] N30 N129 N130 N127 _NC126 _NC127 OA222X1
X64 A[30] N28 N66 _NC128 _NC129 NAND2X0
X65 A[29] N29 N68 _NC130 _NC131 NAND2X0
X66 N66 N68 N128 _NC132 _NC133 NAND2X0
X67 A[31] N27 A[30] N28 N127 N128 N125 _NC134 _NC135 OA222X1
X68 A[32] N26 N65 _NC136 _NC137 NAND2X0
X69 A[31] N27 N67 _NC138 _NC139 NAND2X0
X70 N65 N67 N126 _NC140 _NC141 NAND2X0
X71 A[33] N25 A[32] N26 N125 N126 N123 _NC142 _NC143 OA222X1
X72 A[34] N24 N76 _NC144 _NC145 NAND2X0
X73 A[33] N25 N77 _NC146 _NC147 NAND2X0
X74 N76 N77 N124 _NC148 _NC149 NAND2X0
X75 A[35] N23 A[34] N24 N123 N124 N121 _NC150 _NC151 OA222X1
X76 A[36] N22 N74 _NC152 _NC153 NAND2X0
X77 A[35] N23 N78 _NC154 _NC155 NAND2X0
X78 N74 N78 N122 _NC156 _NC157 NAND2X0
X79 A[37] N21 A[36] N22 N121 N122 N119 _NC158 _NC159 OA222X1
X80 A[38] N20 N73 _NC160 _NC161 NAND2X0
X81 A[37] N21 N75 _NC162 _NC163 NAND2X0
X82 N73 N75 N120 _NC164 _NC165 NAND2X0
X83 A[39] N19 A[38] N20 N119 N120 N117 _NC166 _NC167 OA222X1
X84 A[40] N18 N85 _NC168 _NC169 NAND2X0
X85 A[39] N19 N86 _NC170 _NC171 NAND2X0
X86 N85 N86 N118 _NC172 _NC173 NAND2X0
X87 A[41] N17 A[40] N18 N117 N118 N115 _NC174 _NC175 OA222X1
X88 A[42] N16 N83 _NC176 _NC177 NAND2X0
X89 A[41] N17 N84 _NC178 _NC179 NAND2X0
X90 N83 N84 N116 _NC180 _NC181 NAND2X0
X91 A[43] N15 A[42] N16 N115 N116 N113 _NC182 _NC183 OA222X1
X92 A[44] N14 N82 _NC184 _NC185 NAND2X0
X93 A[43] N15 N81 _NC186 _NC187 NAND2X0
X94 N82 N81 N114 _NC188 _NC189 NAND2X0
X95 A[45] N13 A[44] N14 N113 N114 N111 _NC190 _NC191 OA222X1
X96 A[46] N12 N93 _NC192 _NC193 NAND2X0
X97 A[45] N13 N80 _NC194 _NC195 NAND2X0
X98 N93 N80 N112 _NC196 _NC197 NAND2X0
X99 A[47] N11 A[46] N12 N111 N112 N109 _NC198 _NC199 OA222X1
X100 A[48] N10 N94 _NC200 _NC201 NAND2X0
X101 A[47] N11 N92 _NC202 _NC203 NAND2X0
X102 N94 N92 N110 _NC204 _NC205 NAND2X0
X103 A[49] N9 A[48] N10 N109 N110 N107 _NC206 _NC207 OA222X1
X104 A[49] N9 N89 _NC208 _NC209 NAND2X0
X105 A[50] N8 N90 _NC210 _NC211 NAND2X0
X106 N89 N90 N108 _NC212 _NC213 NAND2X0
X107 A[50] N8 N107 N108 N106 _NC214 _NC215 OA22X1
X108 A[51] N7 N1 N106 N57 _NC216 _NC217 OA22X1
X109 N103 N104 N105 N57 N99 _NC218 _NC219 AND4X1
X110 N99 N100 N101 N102 N98 _NC220 _NC221 AND4X1
X111 N95 N96 N97 N98 N58 _NC222 _NC223 NAND4X0
X112 N92 N93 N94 N87 _NC224 _NC225 NAND3X0
X113 A[0] N56 N91 _NC226 _NC227 AND2X1
X114 N91 N55 A[1] N91 N88 _NC228 _NC229 OA22X1
X115 N87 N88 N2 N3 N60 _NC230 _NC231 NOR4X0
X116 N83 N84 N85 N86 N79 _NC232 _NC233 AND4X1
X117 N79 N80 N81 N82 N61 _NC234 _NC235 AND4X1
X118 N76 N77 N78 N72 _NC236 _NC237 AND3X1
X119 N72 N73 N74 N75 N62 _NC238 _NC239 AND4X1
X120 N68 N69 N70 N71 N64 _NC240 _NC241 AND4X1
X121 N64 N65 N66 N67 N63 _NC242 _NC243 AND4X1
X122 N60 N61 N62 N63 N59 _NC244 _NC245 NAND4X0
X123 N58 N59 EQ _NC246 _NC247 NOR2X0
X124 N57 _NC248 _NC249 LT INVX0
X125 B[1] _NC250 _NC251 N55 INVX0
X126 B[51] _NC252 _NC253 N7 INVX0
X127 B[48] _NC254 _NC255 N10 INVX0
X128 B[49] _NC256 _NC257 N9 INVX0
X129 B[47] _NC258 _NC259 N11 INVX0
X130 B[50] _NC260 _NC261 N8 INVX0
X131 B[46] _NC262 _NC263 N12 INVX0
X132 B[44] _NC264 _NC265 N14 INVX0
X133 B[42] _NC266 _NC267 N16 INVX0
X134 B[38] _NC268 _NC269 N20 INVX0
X135 B[40] _NC270 _NC271 N18 INVX0
X136 B[36] _NC272 _NC273 N22 INVX0
X137 B[32] _NC274 _NC275 N26 INVX0
X138 B[34] _NC276 _NC277 N24 INVX0
X139 B[30] _NC278 _NC279 N28 INVX0
X140 B[45] _NC280 _NC281 N13 INVX0
X141 B[43] _NC282 _NC283 N15 INVX0
X142 B[41] _NC284 _NC285 N17 INVX0
X143 B[39] _NC286 _NC287 N19 INVX0
X144 B[37] _NC288 _NC289 N21 INVX0
X145 B[35] _NC290 _NC291 N23 INVX0
X146 B[33] _NC292 _NC293 N25 INVX0
X147 B[31] _NC294 _NC295 N27 INVX0
X148 B[29] _NC296 _NC297 N29 INVX0
X149 B[28] _NC298 _NC299 N30 INVX0
X150 B[27] _NC300 _NC301 N31 INVX0
X151 B[24] _NC302 _NC303 N34 INVX0
X152 B[26] _NC304 _NC305 N32 INVX0
X153 B[22] _NC306 _NC307 N36 INVX0
X154 B[18] _NC308 _NC309 N40 INVX0
X155 B[20] _NC310 _NC311 N38 INVX0
X156 B[16] _NC312 _NC313 N42 INVX0
X157 B[14] _NC314 _NC315 N44 INVX0
X158 B[25] _NC316 _NC317 N33 INVX0
X159 B[23] _NC318 _NC319 N35 INVX0
X160 B[21] _NC320 _NC321 N37 INVX0
X161 B[19] _NC322 _NC323 N39 INVX0
X162 B[17] _NC324 _NC325 N41 INVX0
X163 B[15] _NC326 _NC327 N43 INVX0
X164 B[13] _NC328 _NC329 N45 INVX0
X165 A[1] _NC330 _NC331 N6 INVX0
X166 B[12] _NC332 _NC333 N46 INVX0
X167 B[10] _NC334 _NC335 N48 INVX0
X168 B[8] _NC336 _NC337 N50 INVX0
X169 B[6] _NC338 _NC339 N52 INVX0
X170 A[2] _NC340 _NC341 N5 INVX0
X171 N105 _NC342 _NC343 N1 INVX0
X172 B[5] _NC344 _NC345 N53 INVX0
X173 B[4] _NC346 _NC347 N54 INVX0
X174 B[11] _NC348 _NC349 N47 INVX0
X175 B[9] _NC350 _NC351 N49 INVX0
X176 B[7] _NC352 _NC353 N51 INVX0
X177 A[3] _NC354 _NC355 N4 INVX0
X178 B[0] _NC356 _NC357 N56 INVX0
X179 N90 _NC358 _NC359 N2 INVX0
X180 N89 _NC360 _NC361 N3 INVX0
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_cmp6_0

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_add_2 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] A[48] A[49] A[50] A[51] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] B[48] B[49] B[50] B[51] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] SUM[28] SUM[29] SUM[30] SUM[31] SUM[32] SUM[33] SUM[34] SUM[35] SUM[36] SUM[37] SUM[38] SUM[39] SUM[40] SUM[41] SUM[42] SUM[43] SUM[44] SUM[45] SUM[46] SUM[47] SUM[48] SUM[49] SUM[50] SUM[51] CO
X0 A[0] B[0] SUM[0] _NC0 _NC1 XOR2X1
X1 A[1] N12 SUM[1] _NC2 _NC3 XOR2X1
X2 A[3] Carry[0] SUM[3] _NC4 _NC5 XOR2X1
X3 A[5] Carry[2] SUM[5] _NC6 _NC7 XOR2X1
X4 A[7] Carry[4] SUM[7] _NC8 _NC9 XOR2X1
X5 A[9] Carry[6] SUM[9] _NC10 _NC11 XOR2X1
X6 A[11] Carry[8] SUM[11] _NC12 _NC13 XOR2X1
X7 A[13] Carry[10] SUM[13] _NC14 _NC15 XOR2X1
X8 A[15] Carry[12] SUM[15] _NC16 _NC17 XOR2X1
X9 A[17] Carry[14] SUM[17] _NC18 _NC19 XOR2X1
X10 A[19] Carry[16] SUM[19] _NC20 _NC21 XOR2X1
X11 A[21] Carry[18] SUM[21] _NC22 _NC23 XOR2X1
X12 A[23] Carry[20] SUM[23] _NC24 _NC25 XOR2X1
X13 A[25] Carry[22] SUM[25] _NC26 _NC27 XOR2X1
X14 A[27] Carry[24] SUM[27] _NC28 _NC29 XOR2X1
X15 A[29] Carry[26] SUM[29] _NC30 _NC31 XOR2X1
X16 A[31] Carry[28] SUM[31] _NC32 _NC33 XOR2X1
X17 A[33] Carry[30] SUM[33] _NC34 _NC35 XOR2X1
X18 A[35] Carry[32] SUM[35] _NC36 _NC37 XOR2X1
X19 A[37] Carry[34] SUM[37] _NC38 _NC39 XOR2X1
X20 A[39] Carry[36] SUM[39] _NC40 _NC41 XOR2X1
X21 A[41] Carry[38] SUM[41] _NC42 _NC43 XOR2X1
X22 A[43] Carry[40] SUM[43] _NC44 _NC45 XOR2X1
X23 A[45] Carry[42] SUM[45] _NC46 _NC47 XOR2X1
X24 A[47] Carry[44] SUM[47] _NC48 _NC49 XOR2X1
X25 A[49] Carry[46] SUM[49] _NC50 _NC51 XOR2X1
X26 A[51] Carry[48] SUM[51] _NC52 _NC53 XOR2X1
X27 A[49] Carry[46] N26 _NC54 _NC55 AND2X1
X28 A[43] Carry[40] N25 _NC56 _NC57 AND2X1
X29 A[41] Carry[38] N24 _NC58 _NC59 AND2X1
X30 A[39] Carry[36] N23 _NC60 _NC61 AND2X1
X31 A[37] Carry[34] N22 _NC62 _NC63 AND2X1
X32 A[35] Carry[32] N21 _NC64 _NC65 AND2X1
X33 A[33] Carry[30] N20 _NC66 _NC67 AND2X1
X34 A[31] Carry[28] N19 _NC68 _NC69 AND2X1
X35 A[23] Carry[20] N18 _NC70 _NC71 AND2X1
X36 A[21] Carry[18] N17 _NC72 _NC73 AND2X1
X37 A[17] Carry[14] N16 _NC74 _NC75 AND2X1
X38 A[15] Carry[12] N15 _NC76 _NC77 AND2X1
X39 A[9] Carry[6] N14 _NC78 _NC79 AND2X1
X40 A[1] N12 N13 _NC80 _NC81 AND2X1
X41 A[0] B[0] N12 _NC82 _NC83 AND2X1
X42 A[45] Carry[42] N11 _NC84 _NC85 AND2X1
X43 A[29] Carry[26] N10 _NC86 _NC87 AND2X1
X44 A[25] Carry[22] N9 _NC88 _NC89 AND2X1
X45 A[19] Carry[16] N8 _NC90 _NC91 AND2X1
X46 A[13] Carry[10] N7 _NC92 _NC93 AND2X1
X47 A[5] Carry[2] N6 _NC94 _NC95 AND2X1
X48 A[47] Carry[44] N5 _NC96 _NC97 AND2X1
X49 A[27] Carry[24] N4 _NC98 _NC99 AND2X1
X50 A[11] Carry[8] N3 _NC100 _NC101 AND2X1
X51 A[7] Carry[4] N2 _NC102 _NC103 AND2X1
X52 A[3] Carry[0] N1 _NC104 _NC105 AND2X1
X53 A[2] B[2] N13 Carry[0] SUM[2] _NC106 _NC107 FADDX1
X54 A[4] B[4] N1 Carry[2] SUM[4] _NC108 _NC109 FADDX1
X55 A[6] B[6] N6 Carry[4] SUM[6] _NC110 _NC111 FADDX1
X56 A[8] B[8] N2 Carry[6] SUM[8] _NC112 _NC113 FADDX1
X57 A[10] B[10] N14 Carry[8] SUM[10] _NC114 _NC115 FADDX1
X58 A[12] B[12] N3 Carry[10] SUM[12] _NC116 _NC117 FADDX1
X59 A[14] B[14] N7 Carry[12] SUM[14] _NC118 _NC119 FADDX1
X60 A[16] B[16] N15 Carry[14] SUM[16] _NC120 _NC121 FADDX1
X61 A[18] B[18] N16 Carry[16] SUM[18] _NC122 _NC123 FADDX1
X62 A[20] B[20] N8 Carry[18] SUM[20] _NC124 _NC125 FADDX1
X63 A[22] B[22] N17 Carry[20] SUM[22] _NC126 _NC127 FADDX1
X64 A[24] B[24] N18 Carry[22] SUM[24] _NC128 _NC129 FADDX1
X65 A[26] B[26] N9 Carry[24] SUM[26] _NC130 _NC131 FADDX1
X66 A[28] B[28] N4 Carry[26] SUM[28] _NC132 _NC133 FADDX1
X67 A[30] B[30] N10 Carry[28] SUM[30] _NC134 _NC135 FADDX1
X68 A[32] B[32] N19 Carry[30] SUM[32] _NC136 _NC137 FADDX1
X69 A[34] B[34] N20 Carry[32] SUM[34] _NC138 _NC139 FADDX1
X70 A[36] B[36] N21 Carry[34] SUM[36] _NC140 _NC141 FADDX1
X71 A[38] B[38] N22 Carry[36] SUM[38] _NC142 _NC143 FADDX1
X72 A[40] B[40] N23 Carry[38] SUM[40] _NC144 _NC145 FADDX1
X73 A[42] B[42] N24 Carry[40] SUM[42] _NC146 _NC147 FADDX1
X74 A[44] B[44] N25 Carry[42] SUM[44] _NC148 _NC149 FADDX1
X75 A[46] B[46] N11 Carry[44] SUM[46] _NC150 _NC151 FADDX1
X76 A[48] B[48] N5 Carry[46] SUM[48] _NC152 _NC153 FADDX1
X77 A[50] B[50] N26 Carry[48] SUM[50] _NC154 _NC155 FADDX1
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_add_2

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_2 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] DIFF[9] DIFF[10] DIFF[11] DIFF[12] DIFF[13] DIFF[14] DIFF[15] DIFF[16] DIFF[17] DIFF[18] DIFF[19] DIFF[20] DIFF[21] DIFF[22] DIFF[23] DIFF[24] DIFF[25] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 B[25] _NC2 _NC3 N2 INVX0
X2 B[24] _NC4 _NC5 N3 INVX0
X3 B[23] _NC6 _NC7 N4 INVX0
X4 B[22] _NC8 _NC9 N5 INVX0
X5 B[21] _NC10 _NC11 N6 INVX0
X6 B[20] _NC12 _NC13 N7 INVX0
X7 B[19] _NC14 _NC15 N8 INVX0
X8 B[18] _NC16 _NC17 N9 INVX0
X9 B[17] _NC18 _NC19 N10 INVX0
X10 B[16] _NC20 _NC21 N11 INVX0
X11 B[15] _NC22 _NC23 N12 INVX0
X12 B[14] _NC24 _NC25 N13 INVX0
X13 B[13] _NC26 _NC27 N14 INVX0
X14 B[12] _NC28 _NC29 N15 INVX0
X15 B[11] _NC30 _NC31 N16 INVX0
X16 B[10] _NC32 _NC33 N17 INVX0
X17 B[9] _NC34 _NC35 N18 INVX0
X18 B[8] _NC36 _NC37 N19 INVX0
X19 B[7] _NC38 _NC39 N20 INVX0
X20 B[6] _NC40 _NC41 N21 INVX0
X21 B[5] _NC42 _NC43 N22 INVX0
X22 B[4] _NC44 _NC45 N23 INVX0
X23 B[3] _NC46 _NC47 N24 INVX0
X24 B[2] _NC48 _NC49 N25 INVX0
X25 A[0] _NC50 _NC51 N1 INVX0
X26 N1 B[0] Carry[0] _NC52 _NC53 NAND2X1
X27 B[1] _NC54 _NC55 N26 INVX0
X28 A[25] N2 Carry[24] DIFF[25] _NC56 _NC57 XOR3X1
X29 A[1] N26 Carry[0] Carry[1] DIFF[1] _NC58 _NC59 FADDX1
X30 A[2] N25 Carry[1] Carry[2] DIFF[2] _NC60 _NC61 FADDX1
X31 A[3] N24 Carry[2] Carry[3] DIFF[3] _NC62 _NC63 FADDX1
X32 A[4] N23 Carry[3] Carry[4] DIFF[4] _NC64 _NC65 FADDX1
X33 A[5] N22 Carry[4] Carry[5] DIFF[5] _NC66 _NC67 FADDX1
X34 A[6] N21 Carry[5] Carry[6] DIFF[6] _NC68 _NC69 FADDX1
X35 A[7] N20 Carry[6] Carry[7] DIFF[7] _NC70 _NC71 FADDX1
X36 A[8] N19 Carry[7] Carry[8] DIFF[8] _NC72 _NC73 FADDX1
X37 A[9] N18 Carry[8] Carry[9] DIFF[9] _NC74 _NC75 FADDX1
X38 A[10] N17 Carry[9] Carry[10] DIFF[10] _NC76 _NC77 FADDX1
X39 A[11] N16 Carry[10] Carry[11] DIFF[11] _NC78 _NC79 FADDX1
X40 A[12] N15 Carry[11] Carry[12] DIFF[12] _NC80 _NC81 FADDX1
X41 A[13] N14 Carry[12] Carry[13] DIFF[13] _NC82 _NC83 FADDX1
X42 A[14] N13 Carry[13] Carry[14] DIFF[14] _NC84 _NC85 FADDX1
X43 A[15] N12 Carry[14] Carry[15] DIFF[15] _NC86 _NC87 FADDX1
X44 A[16] N11 Carry[15] Carry[16] DIFF[16] _NC88 _NC89 FADDX1
X45 A[17] N10 Carry[16] Carry[17] DIFF[17] _NC90 _NC91 FADDX1
X46 A[18] N9 Carry[17] Carry[18] DIFF[18] _NC92 _NC93 FADDX1
X47 A[19] N8 Carry[18] Carry[19] DIFF[19] _NC94 _NC95 FADDX1
X48 A[20] N7 Carry[19] Carry[20] DIFF[20] _NC96 _NC97 FADDX1
X49 A[21] N6 Carry[20] Carry[21] DIFF[21] _NC98 _NC99 FADDX1
X50 A[22] N5 Carry[21] Carry[22] DIFF[22] _NC100 _NC101 FADDX1
X51 A[23] N4 Carry[22] Carry[23] DIFF[23] _NC102 _NC103 FADDX1
X52 A[24] N3 Carry[23] Carry[24] DIFF[24] _NC104 _NC105 FADDX1
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_2

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_add_1 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] CO
X0 A[0] B[0] SUM[0] _NC0 _NC1 XOR2X1
X1 A[0] B[0] N1 _NC2 _NC3 AND2X1
X2 A[25] B[25] Carry[23] SUM[25] _NC4 _NC5 XOR3X1
X3 A[1] B[1] N1 Carry[0] SUM[1] _NC6 _NC7 FADDX1
X4 A[2] B[2] Carry[0] Carry[1] SUM[2] _NC8 _NC9 FADDX1
X5 A[3] B[3] Carry[1] Carry[2] SUM[3] _NC10 _NC11 FADDX1
X6 A[4] B[4] Carry[2] Carry[3] SUM[4] _NC12 _NC13 FADDX1
X7 A[5] B[5] Carry[3] Carry[4] SUM[5] _NC14 _NC15 FADDX1
X8 A[6] B[6] Carry[4] Carry[5] SUM[6] _NC16 _NC17 FADDX1
X9 A[7] B[7] Carry[5] Carry[6] SUM[7] _NC18 _NC19 FADDX1
X10 A[8] B[8] Carry[6] Carry[7] SUM[8] _NC20 _NC21 FADDX1
X11 A[9] B[9] Carry[7] Carry[8] SUM[9] _NC22 _NC23 FADDX1
X12 A[10] B[10] Carry[8] Carry[9] SUM[10] _NC24 _NC25 FADDX1
X13 A[11] B[11] Carry[9] Carry[10] SUM[11] _NC26 _NC27 FADDX1
X14 A[12] B[12] Carry[10] Carry[11] SUM[12] _NC28 _NC29 FADDX1
X15 A[13] B[13] Carry[11] Carry[12] SUM[13] _NC30 _NC31 FADDX1
X16 A[14] B[14] Carry[12] Carry[13] SUM[14] _NC32 _NC33 FADDX1
X17 A[15] B[15] Carry[13] Carry[14] SUM[15] _NC34 _NC35 FADDX1
X18 A[16] B[16] Carry[14] Carry[15] SUM[16] _NC36 _NC37 FADDX1
X19 A[17] B[17] Carry[15] Carry[16] SUM[17] _NC38 _NC39 FADDX1
X20 A[18] B[18] Carry[16] Carry[17] SUM[18] _NC40 _NC41 FADDX1
X21 A[19] B[19] Carry[17] Carry[18] SUM[19] _NC42 _NC43 FADDX1
X22 A[20] B[20] Carry[18] Carry[19] SUM[20] _NC44 _NC45 FADDX1
X23 A[21] B[21] Carry[19] Carry[20] SUM[21] _NC46 _NC47 FADDX1
X24 A[22] B[22] Carry[20] Carry[21] SUM[22] _NC48 _NC49 FADDX1
X25 A[23] B[23] Carry[21] Carry[22] SUM[23] _NC50 _NC51 FADDX1
X26 A[24] B[24] Carry[22] Carry[23] SUM[24] _NC52 _NC53 FADDX1
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_add_1

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_1 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] A[48] A[49] A[50] A[51] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] B[48] B[49] B[50] B[51] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] DIFF[9] DIFF[10] DIFF[11] DIFF[12] DIFF[13] DIFF[14] DIFF[15] DIFF[16] DIFF[17] DIFF[18] DIFF[19] DIFF[20] DIFF[21] DIFF[22] DIFF[23] DIFF[24] DIFF[25] DIFF[26] DIFF[27] DIFF[28] DIFF[29] DIFF[30] DIFF[31] DIFF[32] DIFF[33] DIFF[34] DIFF[35] DIFF[36] DIFF[37] DIFF[38] DIFF[39] DIFF[40] DIFF[41] DIFF[42] DIFF[43] DIFF[44] DIFF[45] DIFF[46] DIFF[47] DIFF[48] DIFF[49] DIFF[50] DIFF[51] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 A[0] _NC2 _NC3 N1 INVX0
X2 N1 B[0] Carry[0] _NC4 _NC5 NAND2X1
X3 B[1] _NC6 _NC7 N35 INVX0
X4 B[51] _NC8 _NC9 N52 INVX0
X5 B[49] _NC10 _NC11 N50 INVX0
X6 B[47] _NC12 _NC13 N48 INVX0
X7 B[45] _NC14 _NC15 N46 INVX0
X8 B[43] _NC16 _NC17 N44 INVX0
X9 B[41] _NC18 _NC19 N42 INVX0
X10 B[39] _NC20 _NC21 N41 INVX0
X11 B[37] _NC22 _NC23 N40 INVX0
X12 B[35] _NC24 _NC25 N39 INVX0
X13 B[33] _NC26 _NC27 N38 INVX0
X14 B[31] _NC28 _NC29 N27 INVX0
X15 B[29] _NC30 _NC31 N31 INVX0
X16 B[27] _NC32 _NC33 N23 INVX0
X17 B[25] _NC34 _NC35 N36 INVX0
X18 B[23] _NC36 _NC37 N28 INVX0
X19 B[21] _NC38 _NC39 N32 INVX0
X20 B[19] _NC40 _NC41 N24 INVX0
X21 B[17] _NC42 _NC43 N34 INVX0
X22 B[15] _NC44 _NC45 N26 INVX0
X23 B[13] _NC46 _NC47 N30 INVX0
X24 B[11] _NC48 _NC49 N22 INVX0
X25 B[9] _NC50 _NC51 N37 INVX0
X26 B[7] _NC52 _NC53 N29 INVX0
X27 B[5] _NC54 _NC55 N33 INVX0
X28 B[3] _NC56 _NC57 N25 INVX0
X29 B[50] _NC58 _NC59 N51 INVX0
X30 B[48] _NC60 _NC61 N49 INVX0
X31 B[46] _NC62 _NC63 N47 INVX0
X32 B[44] _NC64 _NC65 N45 INVX0
X33 B[42] _NC66 _NC67 N43 INVX0
X34 B[40] _NC68 _NC69 N21 INVX0
X35 B[38] _NC70 _NC71 N20 INVX0
X36 B[36] _NC72 _NC73 N19 INVX0
X37 B[34] _NC74 _NC75 N18 INVX0
X38 B[30] _NC76 _NC77 N14 INVX0
X39 B[28] _NC78 _NC79 N6 INVX0
X40 B[26] _NC80 _NC81 N10 INVX0
X41 B[24] _NC82 _NC83 N3 INVX0
X42 B[22] _NC84 _NC85 N15 INVX0
X43 B[20] _NC86 _NC87 N7 INVX0
X44 B[18] _NC88 _NC89 N11 INVX0
X45 B[16] _NC90 _NC91 N2 INVX0
X46 B[14] _NC92 _NC93 N13 INVX0
X47 B[12] _NC94 _NC95 N5 INVX0
X48 B[10] _NC96 _NC97 N9 INVX0
X49 B[8] _NC98 _NC99 N4 INVX0
X50 B[6] _NC100 _NC101 N16 INVX0
X51 B[2] _NC102 _NC103 N12 INVX0
X52 B[32] _NC104 _NC105 N17 INVX0
X53 B[4] _NC106 _NC107 N8 INVX0
X54 A[51] N52 Carry[50] DIFF[51] _NC108 _NC109 XOR3X1
X55 A[1] N35 Carry[0] Carry[1] DIFF[1] _NC110 _NC111 FADDX1
X56 A[2] N12 Carry[1] Carry[2] DIFF[2] _NC112 _NC113 FADDX1
X57 A[3] N25 Carry[2] Carry[3] DIFF[3] _NC114 _NC115 FADDX1
X58 A[4] N8 Carry[3] Carry[4] DIFF[4] _NC116 _NC117 FADDX1
X59 A[5] N33 Carry[4] Carry[5] DIFF[5] _NC118 _NC119 FADDX1
X60 A[6] N16 Carry[5] Carry[6] DIFF[6] _NC120 _NC121 FADDX1
X61 A[7] N29 Carry[6] Carry[7] DIFF[7] _NC122 _NC123 FADDX1
X62 A[8] N4 Carry[7] Carry[8] DIFF[8] _NC124 _NC125 FADDX1
X63 A[9] N37 Carry[8] Carry[9] DIFF[9] _NC126 _NC127 FADDX1
X64 A[10] N9 Carry[9] Carry[10] DIFF[10] _NC128 _NC129 FADDX1
X65 A[11] N22 Carry[10] Carry[11] DIFF[11] _NC130 _NC131 FADDX1
X66 A[12] N5 Carry[11] Carry[12] DIFF[12] _NC132 _NC133 FADDX1
X67 A[13] N30 Carry[12] Carry[13] DIFF[13] _NC134 _NC135 FADDX1
X68 A[14] N13 Carry[13] Carry[14] DIFF[14] _NC136 _NC137 FADDX1
X69 A[15] N26 Carry[14] Carry[15] DIFF[15] _NC138 _NC139 FADDX1
X70 A[16] N2 Carry[15] Carry[16] DIFF[16] _NC140 _NC141 FADDX1
X71 A[17] N34 Carry[16] Carry[17] DIFF[17] _NC142 _NC143 FADDX1
X72 A[18] N11 Carry[17] Carry[18] DIFF[18] _NC144 _NC145 FADDX1
X73 A[19] N24 Carry[18] Carry[19] DIFF[19] _NC146 _NC147 FADDX1
X74 A[20] N7 Carry[19] Carry[20] DIFF[20] _NC148 _NC149 FADDX1
X75 A[21] N32 Carry[20] Carry[21] DIFF[21] _NC150 _NC151 FADDX1
X76 A[22] N15 Carry[21] Carry[22] DIFF[22] _NC152 _NC153 FADDX1
X77 A[23] N28 Carry[22] Carry[23] DIFF[23] _NC154 _NC155 FADDX1
X78 A[24] N3 Carry[23] Carry[24] DIFF[24] _NC156 _NC157 FADDX1
X79 A[25] N36 Carry[24] Carry[25] DIFF[25] _NC158 _NC159 FADDX1
X80 A[26] N10 Carry[25] Carry[26] DIFF[26] _NC160 _NC161 FADDX1
X81 A[27] N23 Carry[26] Carry[27] DIFF[27] _NC162 _NC163 FADDX1
X82 A[28] N6 Carry[27] Carry[28] DIFF[28] _NC164 _NC165 FADDX1
X83 A[29] N31 Carry[28] Carry[29] DIFF[29] _NC166 _NC167 FADDX1
X84 A[30] N14 Carry[29] Carry[30] DIFF[30] _NC168 _NC169 FADDX1
X85 A[31] N27 Carry[30] Carry[31] DIFF[31] _NC170 _NC171 FADDX1
X86 A[32] N17 Carry[31] Carry[32] DIFF[32] _NC172 _NC173 FADDX1
X87 A[33] N38 Carry[32] Carry[33] DIFF[33] _NC174 _NC175 FADDX1
X88 A[34] N18 Carry[33] Carry[34] DIFF[34] _NC176 _NC177 FADDX1
X89 A[35] N39 Carry[34] Carry[35] DIFF[35] _NC178 _NC179 FADDX1
X90 A[36] N19 Carry[35] Carry[36] DIFF[36] _NC180 _NC181 FADDX1
X91 A[37] N40 Carry[36] Carry[37] DIFF[37] _NC182 _NC183 FADDX1
X92 A[38] N20 Carry[37] Carry[38] DIFF[38] _NC184 _NC185 FADDX1
X93 A[39] N41 Carry[38] Carry[39] DIFF[39] _NC186 _NC187 FADDX1
X94 A[40] N21 Carry[39] Carry[40] DIFF[40] _NC188 _NC189 FADDX1
X95 A[41] N42 Carry[40] Carry[41] DIFF[41] _NC190 _NC191 FADDX1
X96 A[42] N43 Carry[41] Carry[42] DIFF[42] _NC192 _NC193 FADDX1
X97 A[43] N44 Carry[42] Carry[43] DIFF[43] _NC194 _NC195 FADDX1
X98 A[44] N45 Carry[43] Carry[44] DIFF[44] _NC196 _NC197 FADDX1
X99 A[45] N46 Carry[44] Carry[45] DIFF[45] _NC198 _NC199 FADDX1
X100 A[46] N47 Carry[45] Carry[46] DIFF[46] _NC200 _NC201 FADDX1
X101 A[47] N48 Carry[46] Carry[47] DIFF[47] _NC202 _NC203 FADDX1
X102 A[48] N49 Carry[47] Carry[48] DIFF[48] _NC204 _NC205 FADDX1
X103 A[49] N50 Carry[48] Carry[49] DIFF[49] _NC206 _NC207 FADDX1
X104 A[50] N51 Carry[49] Carry[50] DIFF[50] _NC208 _NC209 FADDX1
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_1

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_add_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] A[48] A[49] A[50] A[51] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] B[48] B[49] B[50] B[51] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] SUM[28] SUM[29] SUM[30] SUM[31] SUM[32] SUM[33] SUM[34] SUM[35] SUM[36] SUM[37] SUM[38] SUM[39] SUM[40] SUM[41] SUM[42] SUM[43] SUM[44] SUM[45] SUM[46] SUM[47] SUM[48] SUM[49] SUM[50] SUM[51] CO
X0 A[0] B[0] SUM[0] _NC0 _NC1 XOR2X1
X1 A[0] B[0] N1 _NC2 _NC3 AND2X1
X2 A[51] B[51] Carry[49] SUM[51] _NC4 _NC5 XOR3X1
X3 A[1] B[1] N1 Carry[0] SUM[1] _NC6 _NC7 FADDX1
X4 A[2] B[2] Carry[0] Carry[1] SUM[2] _NC8 _NC9 FADDX1
X5 A[3] B[3] Carry[1] Carry[2] SUM[3] _NC10 _NC11 FADDX1
X6 A[4] B[4] Carry[2] Carry[3] SUM[4] _NC12 _NC13 FADDX1
X7 A[5] B[5] Carry[3] Carry[4] SUM[5] _NC14 _NC15 FADDX1
X8 A[6] B[6] Carry[4] Carry[5] SUM[6] _NC16 _NC17 FADDX1
X9 A[7] B[7] Carry[5] Carry[6] SUM[7] _NC18 _NC19 FADDX1
X10 A[8] B[8] Carry[6] Carry[7] SUM[8] _NC20 _NC21 FADDX1
X11 A[9] B[9] Carry[7] Carry[8] SUM[9] _NC22 _NC23 FADDX1
X12 A[10] B[10] Carry[8] Carry[9] SUM[10] _NC24 _NC25 FADDX1
X13 A[11] B[11] Carry[9] Carry[10] SUM[11] _NC26 _NC27 FADDX1
X14 A[12] B[12] Carry[10] Carry[11] SUM[12] _NC28 _NC29 FADDX1
X15 A[13] B[13] Carry[11] Carry[12] SUM[13] _NC30 _NC31 FADDX1
X16 A[14] B[14] Carry[12] Carry[13] SUM[14] _NC32 _NC33 FADDX1
X17 A[15] B[15] Carry[13] Carry[14] SUM[15] _NC34 _NC35 FADDX1
X18 A[16] B[16] Carry[14] Carry[15] SUM[16] _NC36 _NC37 FADDX1
X19 A[17] B[17] Carry[15] Carry[16] SUM[17] _NC38 _NC39 FADDX1
X20 A[18] B[18] Carry[16] Carry[17] SUM[18] _NC40 _NC41 FADDX1
X21 A[19] B[19] Carry[17] Carry[18] SUM[19] _NC42 _NC43 FADDX1
X22 A[20] B[20] Carry[18] Carry[19] SUM[20] _NC44 _NC45 FADDX1
X23 A[21] B[21] Carry[19] Carry[20] SUM[21] _NC46 _NC47 FADDX1
X24 A[22] B[22] Carry[20] Carry[21] SUM[22] _NC48 _NC49 FADDX1
X25 A[23] B[23] Carry[21] Carry[22] SUM[23] _NC50 _NC51 FADDX1
X26 A[24] B[24] Carry[22] Carry[23] SUM[24] _NC52 _NC53 FADDX1
X27 A[25] B[25] Carry[23] Carry[24] SUM[25] _NC54 _NC55 FADDX1
X28 A[26] B[26] Carry[24] Carry[25] SUM[26] _NC56 _NC57 FADDX1
X29 A[27] B[27] Carry[25] Carry[26] SUM[27] _NC58 _NC59 FADDX1
X30 A[28] B[28] Carry[26] Carry[27] SUM[28] _NC60 _NC61 FADDX1
X31 A[29] B[29] Carry[27] Carry[28] SUM[29] _NC62 _NC63 FADDX1
X32 A[30] B[30] Carry[28] Carry[29] SUM[30] _NC64 _NC65 FADDX1
X33 A[31] B[31] Carry[29] Carry[30] SUM[31] _NC66 _NC67 FADDX1
X34 A[32] B[32] Carry[30] Carry[31] SUM[32] _NC68 _NC69 FADDX1
X35 A[33] B[33] Carry[31] Carry[32] SUM[33] _NC70 _NC71 FADDX1
X36 A[34] B[34] Carry[32] Carry[33] SUM[34] _NC72 _NC73 FADDX1
X37 A[35] B[35] Carry[33] Carry[34] SUM[35] _NC74 _NC75 FADDX1
X38 A[36] B[36] Carry[34] Carry[35] SUM[36] _NC76 _NC77 FADDX1
X39 A[37] B[37] Carry[35] Carry[36] SUM[37] _NC78 _NC79 FADDX1
X40 A[38] B[38] Carry[36] Carry[37] SUM[38] _NC80 _NC81 FADDX1
X41 A[39] B[39] Carry[37] Carry[38] SUM[39] _NC82 _NC83 FADDX1
X42 A[40] B[40] Carry[38] Carry[39] SUM[40] _NC84 _NC85 FADDX1
X43 A[41] B[41] Carry[39] Carry[40] SUM[41] _NC86 _NC87 FADDX1
X44 A[42] B[42] Carry[40] Carry[41] SUM[42] _NC88 _NC89 FADDX1
X45 A[43] B[43] Carry[41] Carry[42] SUM[43] _NC90 _NC91 FADDX1
X46 A[44] B[44] Carry[42] Carry[43] SUM[44] _NC92 _NC93 FADDX1
X47 A[45] B[45] Carry[43] Carry[44] SUM[45] _NC94 _NC95 FADDX1
X48 A[46] B[46] Carry[44] Carry[45] SUM[46] _NC96 _NC97 FADDX1
X49 A[47] B[47] Carry[45] Carry[46] SUM[47] _NC98 _NC99 FADDX1
X50 A[48] B[48] Carry[46] Carry[47] SUM[48] _NC100 _NC101 FADDX1
X51 A[49] B[49] Carry[47] Carry[48] SUM[49] _NC102 _NC103 FADDX1
X52 A[50] B[50] Carry[48] Carry[49] SUM[50] _NC104 _NC105 FADDX1
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_add_0

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW_cmp_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] A[48] A[49] A[50] A[51] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] B[48] B[49] B[50] B[51] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
X0 N2206 A[27] N2346 _NC0 _NC1 NOR2X0
X1 B[26] N2168 N2346 N2340 _NC2 _NC3 AO21X1
X2 B[29] N2166 N2353 _NC4 _NC5 NAND2X0
X3 N2207 A[28] N2355 _NC6 _NC7 OR2X1
X4 N2208 A[31] N2351 _NC8 _NC9 NOR2X0
X5 B[30] N2165 N2351 N2349 _NC10 _NC11 AO21X1
X6 N2353 N2355 N2164 N2342 _NC12 _NC13 NAND3X0
X7 B[25] N2169 N2344 _NC14 _NC15 NAND2X0
X8 N2205 A[24] N2354 _NC16 _NC17 OR2X1
X9 N2167 N2163 N2344 N2354 N2278 _NC18 _NC19 NAND4X0
X10 N2353 N2207 A[28] N2352 _NC20 _NC21 NAND3X0
X11 B[29] N2166 N2352 N2347 _NC22 _NC23 OA21X1
X12 B[30] N2351 N2350 _NC24 _NC25 NOR2X0
X13 A[31] N2208 N2350 A[30] N2348 _NC26 _NC27 AOI22X1
X14 N2347 N2348 N2348 N2349 N2337 _NC28 _NC29 AO22X1
X15 B[26] N2346 N2345 _NC30 _NC31 NOR2X0
X16 A[27] N2206 N2345 A[26] N2339 _NC32 _NC33 AOI22X1
X17 N2344 N2205 A[24] N2343 _NC34 _NC35 NAND3X0
X18 B[25] N2169 N2343 N2341 _NC36 _NC37 OA21X1
X19 N2339 N2340 N2341 N2339 N2342 N2338 _NC38 _NC39 AO221X1
X20 N2337 N2338 N2320 _NC40 _NC41 NAND2X0
X21 N2203 A[21] N2327 _NC42 _NC43 NOR2X0
X22 B[20] N2327 N2335 _NC44 _NC45 NOR2X0
X23 N2204 A[23] N2334 _NC46 _NC47 NOR2X0
X24 B[22] N2334 N2336 _NC48 _NC49 NOR2X0
X25 A[23] N2204 N2336 A[22] N2333 _NC50 _NC51 AO22X1
X26 A[21] N2203 N2335 A[20] N2333 N2322 _NC52 _NC53 AO221X1
X27 B[22] N2171 N2334 N2326 _NC54 _NC55 AOI21X1
X28 N2333 N2326 N2323 _NC56 _NC57 OR2X1
X29 N2202 A[19] N2332 _NC58 _NC59 NOR2X0
X30 B[18] N2175 N2332 N2276 _NC60 _NC61 AO21X1
X31 B[18] N2332 N2331 _NC62 _NC63 NOR2X0
X32 A[19] N2202 N2331 A[18] N2328 _NC64 _NC65 AO22X1
X33 N2201 A[17] N2282 _NC66 _NC67 NOR2X0
X34 B[16] N2282 N2330 _NC68 _NC69 NOR2X0
X35 A[17] N2201 N2330 A[16] N2328 N2329 _NC70 _NC71 AO221X1
X36 N2174 N2328 N2329 N2324 _NC72 _NC73 OA21X1
X37 B[20] N2173 N2325 _NC74 _NC75 NAND2X0
X38 N2172 N2325 N2326 N2277 _NC76 _NC77 NAND3X0
X39 N2322 N2323 N2324 N2170 N2320 N2321 _NC78 _NC79 AO221X1
X40 N2162 N2320 N2321 N2273 _NC80 _NC81 OA21X1
X41 N2195 A[5] N2309 _NC82 _NC83 NOR2X0
X42 B[4] N2309 N2318 _NC84 _NC85 NOR2X0
X43 N2196 A[7] N2316 _NC86 _NC87 NOR2X0
X44 B[6] N2316 N2319 _NC88 _NC89 NOR2X0
X45 A[7] N2196 N2319 A[6] N2317 _NC90 _NC91 AO22X1
X46 A[5] N2195 N2318 A[4] N2317 N2288 _NC92 _NC93 AO221X1
X47 B[6] N2186 N2316 N2312 _NC94 _NC95 AO21X1
X48 N2185 N2312 N2289 _NC96 _NC97 NAND2X0
X49 N2190 B[1] N2313 _NC98 _NC99 AND2X1
X50 A[0] N2191 N2314 _NC100 _NC101 NOR2X0
X51 N2193 A[3] N2310 _NC102 _NC103 NOR2X0
X52 B[2] N2310 N2315 _NC104 _NC105 NOR2X0
X53 A[3] N2193 N2315 A[2] N2308 _NC106 _NC107 AO22X1
X54 N2313 N2314 B[1] N2190 N2188 N2311 _NC108 _NC109 OA221X1
X55 N2311 N2312 N2290 _NC110 _NC111 NOR2X0
X56 N2189 B[2] N2310 N2307 _NC112 _NC113 AOI21X1
X57 N2307 N2308 A[4] N2194 N2187 N2291 _NC114 _NC115 OA221X1
X58 B[13] N2181 N2296 _NC116 _NC117 NAND2X0
X59 N2296 N2199 A[12] N2306 _NC118 _NC119 NAND3X0
X60 B[13] N2181 N2306 N2302 _NC120 _NC121 OA21X1
X61 N2200 A[15] N2304 _NC122 _NC123 NOR2X0
X62 B[14] N2304 N2305 _NC124 _NC125 NOR2X0
X63 A[15] N2200 N2305 A[14] N2303 _NC126 _NC127 AOI22X1
X64 B[14] N2180 N2304 N2298 _NC128 _NC129 AO21X1
X65 N2302 N2303 N2303 N2298 N2292 _NC130 _NC131 AO22X1
X66 N2198 A[11] N2300 _NC132 _NC133 NOR2X0
X67 B[10] N2300 N2301 _NC134 _NC135 NOR2X0
X68 A[11] N2198 N2301 A[10] N2294 _NC136 _NC137 AOI22X1
X69 B[10] N2183 N2300 N2286 _NC138 _NC139 AO21X1
X70 B[9] N2184 N2283 _NC140 _NC141 NAND2X0
X71 N2283 N2197 A[8] N2299 _NC142 _NC143 NAND3X0
X72 B[9] N2184 N2299 N2295 _NC144 _NC145 OA21X1
X73 N2199 A[12] N2297 _NC146 _NC147 OR2X1
X74 N2296 N2297 N2179 N2285 _NC148 _NC149 NAND3X0
X75 N2294 N2286 N2295 N2294 N2285 N2293 _NC150 _NC151 AO221X1
X76 N2292 N2293 N2287 _NC152 _NC153 NAND2X0
X77 N2288 N2289 N2290 N2291 N2287 N2279 _NC154 _NC155 AO221X1
X78 N2197 A[8] N2284 _NC156 _NC157 OR2X1
X79 B[16] N2177 N2281 _NC158 _NC159 NAND2X0
X80 N2279 N2280 N2176 N2281 N2275 _NC160 _NC161 NAND4X0
X81 N2275 N2276 N2277 N2278 N2274 _NC162 _NC163 NOR4X0
X82 N2273 N2274 N2219 _NC164 _NC165 NOR2X0
X83 B[48] N2151 B[49] N2150 N2272 _NC166 _NC167 OAI22X1
X84 B[49] N2150 N2233 _NC168 _NC169 NAND2X0
X85 N2218 A[50] N2232 _NC170 _NC171 OR2X1
X86 N2272 N2233 N2232 N2271 _NC172 _NC173 AND3X1
X87 A[50] N2218 A[51] N2192 N2271 N2229 _NC174 _NC175 AO221X1
X88 N2192 A[51] N2230 _NC176 _NC177 OR2X1
X89 N2215 A[43] N2261 _NC178 _NC179 NOR2X0
X90 B[42] N2155 N2261 N2255 _NC180 _NC181 AO21X1
X91 B[45] N2154 N2268 _NC182 _NC183 NAND2X0
X92 N2216 A[44] N2270 _NC184 _NC185 OR2X1
X93 N2217 A[47] N2266 _NC186 _NC187 NOR2X0
X94 B[46] N2153 N2266 N2264 _NC188 _NC189 AO21X1
X95 N2268 N2270 N2152 N2257 _NC190 _NC191 NAND3X0
X96 B[41] N2157 N2259 _NC192 _NC193 NAND2X0
X97 N2214 A[40] N2269 _NC194 _NC195 NOR2X0
X98 N2255 N2257 N2156 N2269 N2222 _NC196 _NC197 NOR4X0
X99 N2268 N2216 A[44] N2267 _NC198 _NC199 NAND3X0
X100 B[45] N2154 N2267 N2262 _NC200 _NC201 OA21X1
X101 B[46] N2266 N2265 _NC202 _NC203 NOR2X0
X102 A[47] N2217 N2265 A[46] N2263 _NC204 _NC205 AOI22X1
X103 N2262 N2263 N2263 N2264 N2252 _NC206 _NC207 AO22X1
X104 B[42] N2261 N2260 _NC208 _NC209 NOR2X0
X105 A[43] N2215 N2260 A[42] N2254 _NC210 _NC211 AOI22X1
X106 N2259 N2214 A[40] N2258 _NC212 _NC213 NAND3X0
X107 B[41] N2157 N2258 N2256 _NC214 _NC215 OA21X1
X108 N2254 N2255 N2256 N2254 N2257 N2253 _NC216 _NC217 AO221X1
X109 N2252 N2253 N2235 _NC218 _NC219 NAND2X0
X110 N2212 A[37] N2242 _NC220 _NC221 NOR2X0
X111 B[36] N2242 N2250 _NC222 _NC223 NOR2X0
X112 N2213 A[39] N2249 _NC224 _NC225 NOR2X0
X113 B[38] N2249 N2251 _NC226 _NC227 NOR2X0
X114 A[39] N2213 N2251 A[38] N2248 _NC228 _NC229 AO22X1
X115 A[37] N2212 N2250 A[36] N2248 N2237 _NC230 _NC231 AO221X1
X116 B[38] N2158 N2249 N2241 _NC232 _NC233 AOI21X1
X117 N2248 N2241 N2238 _NC234 _NC235 OR2X1
X118 N2211 A[35] N2247 _NC236 _NC237 NOR2X0
X119 B[34] N2161 N2247 N2224 _NC238 _NC239 AOI21X1
X120 B[34] N2247 N2246 _NC240 _NC241 NOR2X0
X121 A[35] N2211 N2246 A[34] N2243 _NC242 _NC243 AO22X1
X122 N2210 A[33] N2228 _NC244 _NC245 NOR2X0
X123 B[32] N2228 N2245 _NC246 _NC247 NOR2X0
X124 A[33] N2210 N2245 A[32] N2243 N2244 _NC248 _NC249 AO221X1
X125 N2224 N2243 N2244 N2239 _NC250 _NC251 OA21X1
X126 B[36] N2160 N2240 _NC252 _NC253 NAND2X0
X127 N2159 N2240 N2241 N2223 _NC254 _NC255 AND3X1
X128 N2237 N2238 N2239 N2223 N2235 N2236 _NC256 _NC257 AO221X1
X129 N2222 N2235 N2236 N2231 _NC258 _NC259 OA21X1
X130 B[48] N2151 N2234 _NC260 _NC261 NAND2X0
X131 N2230 N2232 N2233 N2234 N2226 _NC262 _NC263 NAND4X0
X132 N2229 N2230 N2231 N2149 N2220 _NC264 _NC265 AOI22X1
X133 A[32] N2209 N2227 _NC266 _NC267 NOR2X0
X134 N2226 N2227 N2228 N2225 _NC268 _NC269 NOR3X0
X135 N2222 N2223 N2224 N2225 N2221 _NC270 _NC271 NAND4X0
X136 N2219 N2220 N2220 N2221 GE_LT_GT_LE _NC272 _NC273 AO22X1
X137 A[16] _NC274 _NC275 N2177 INVX0
X138 A[48] _NC276 _NC277 N2151 INVX0
X139 A[49] _NC278 _NC279 N2150 INVX0
X140 B[51] _NC280 _NC281 N2192 INVX0
X141 B[50] _NC282 _NC283 N2218 INVX0
X142 B[32] _NC284 _NC285 N2209 INVX0
X143 A[2] _NC286 _NC287 N2189 INVX0
X144 A[29] _NC288 _NC289 N2166 INVX0
X145 A[9] _NC290 _NC291 N2184 INVX0
X146 B[4] _NC292 _NC293 N2194 INVX0
X147 B[0] _NC294 _NC295 N2191 INVX0
X148 A[45] _NC296 _NC297 N2154 INVX0
X149 A[41] _NC298 _NC299 N2157 INVX0
X150 A[25] _NC300 _NC301 N2169 INVX0
X151 A[13] _NC302 _NC303 N2181 INVX0
X152 A[34] _NC304 _NC305 N2161 INVX0
X153 A[38] _NC306 _NC307 N2158 INVX0
X154 B[47] _NC308 _NC309 N2217 INVX0
X155 B[43] _NC310 _NC311 N2215 INVX0
X156 B[31] _NC312 _NC313 N2208 INVX0
X157 B[27] _NC314 _NC315 N2206 INVX0
X158 B[15] _NC316 _NC317 N2200 INVX0
X159 B[11] _NC318 _NC319 N2198 INVX0
X160 A[22] _NC320 _NC321 N2171 INVX0
X161 B[35] _NC322 _NC323 N2211 INVX0
X162 B[19] _NC324 _NC325 N2202 INVX0
X163 B[39] _NC326 _NC327 N2213 INVX0
X164 B[23] _NC328 _NC329 N2204 INVX0
X165 B[7] _NC330 _NC331 N2196 INVX0
X166 B[3] _NC332 _NC333 N2193 INVX0
X167 B[37] _NC334 _NC335 N2212 INVX0
X168 B[17] _NC336 _NC337 N2201 INVX0
X169 B[5] _NC338 _NC339 N2195 INVX0
X170 B[21] _NC340 _NC341 N2203 INVX0
X171 B[33] _NC342 _NC343 N2210 INVX0
X172 B[40] _NC344 _NC345 N2214 INVX0
X173 B[24] _NC346 _NC347 N2205 INVX0
X174 B[44] _NC348 _NC349 N2216 INVX0
X175 B[28] _NC350 _NC351 N2207 INVX0
X176 B[8] _NC352 _NC353 N2197 INVX0
X177 B[12] _NC354 _NC355 N2199 INVX0
X178 A[6] _NC356 _NC357 N2186 INVX0
X179 N2276 _NC358 _NC359 N2174 INVX0
X180 A[36] _NC360 _NC361 N2160 INVX0
X181 N2242 _NC362 _NC363 N2159 INVX0
X182 A[42] _NC364 _NC365 N2155 INVX0
X183 A[26] _NC366 _NC367 N2168 INVX0
X184 A[10] _NC368 _NC369 N2183 INVX0
X185 A[46] _NC370 _NC371 N2153 INVX0
X186 A[30] _NC372 _NC373 N2165 INVX0
X187 A[14] _NC374 _NC375 N2180 INVX0
X188 A[1] _NC376 _NC377 N2190 INVX0
X189 A[18] _NC378 _NC379 N2175 INVX0
X190 N2182 N2178 N2283 N2284 N2148 _NC380 _NC381 AND4X1
X191 N2287 N2148 N2280 _NC382 _NC383 OR2X1
X192 N2264 _NC384 _NC385 N2152 INVX0
X193 N2349 _NC386 _NC387 N2164 INVX0
X194 N2298 _NC388 _NC389 N2179 INVX0
X195 A[20] _NC390 _NC391 N2173 INVX0
X196 N2327 _NC392 _NC393 N2172 INVX0
X197 N2342 _NC394 _NC395 N2163 INVX0
X198 N2340 _NC396 _NC397 N2167 INVX0
X199 N2282 _NC398 _NC399 N2176 INVX0
X200 N2259 _NC400 _NC401 N2156 INVX0
X201 N2226 _NC402 _NC403 N2149 INVX0
X202 N2308 _NC404 _NC405 N2188 INVX0
X203 N2317 _NC406 _NC407 N2185 INVX0
X204 N2286 _NC408 _NC409 N2182 INVX0
X205 N2309 _NC410 _NC411 N2187 INVX0
X206 N2277 _NC412 _NC413 N2170 INVX0
X207 N2285 _NC414 _NC415 N2178 INVX0
X208 N2278 _NC416 _NC417 N2162 INVX0
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW_cmp_0

.SUBCKT sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] DIFF[9] DIFF[10] DIFF[11] DIFF[12] DIFF[13] DIFF[14] DIFF[15] DIFF[16] DIFF[17] DIFF[18] DIFF[19] DIFF[20] DIFF[21] DIFF[22] DIFF[23] DIFF[24] DIFF[25] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 N9 A[9] DIFF[9] _NC2 _NC3 XOR2X1
X2 N8 A[8] DIFF[8] _NC4 _NC5 XOR2X1
X3 N7 A[7] DIFF[7] _NC6 _NC7 XOR2X1
X4 N6 A[6] DIFF[6] _NC8 _NC9 XOR2X1
X5 N5 A[5] DIFF[5] _NC10 _NC11 XOR2X1
X6 N4 A[4] DIFF[4] _NC12 _NC13 XOR2X1
X7 N3 A[3] DIFF[3] _NC14 _NC15 XOR2X1
X8 N2 A[2] DIFF[2] _NC16 _NC17 XOR2X1
X9 N24 A[24] DIFF[24] _NC18 _NC19 XOR2X1
X10 N23 A[23] DIFF[23] _NC20 _NC21 XOR2X1
X11 N22 A[22] DIFF[22] _NC22 _NC23 XOR2X1
X12 N21 A[21] DIFF[21] _NC24 _NC25 XOR2X1
X13 N20 A[20] DIFF[20] _NC26 _NC27 XOR2X1
X14 N1 A[1] DIFF[1] _NC28 _NC29 XOR2X1
X15 N19 A[19] DIFF[19] _NC30 _NC31 XOR2X1
X16 N18 A[18] DIFF[18] _NC32 _NC33 XOR2X1
X17 N17 A[17] DIFF[17] _NC34 _NC35 XOR2X1
X18 N16 A[16] DIFF[16] _NC36 _NC37 XOR2X1
X19 N15 A[15] DIFF[15] _NC38 _NC39 XOR2X1
X20 N14 A[14] DIFF[14] _NC40 _NC41 XOR2X1
X21 N13 A[13] DIFF[13] _NC42 _NC43 XOR2X1
X22 N12 A[12] DIFF[12] _NC44 _NC45 XOR2X1
X23 N11 A[11] DIFF[11] _NC46 _NC47 XOR2X1
X24 N10 A[10] DIFF[10] _NC48 _NC49 XOR2X1
X25 A[24] _NC50 _NC51 N40 INVX0
X26 N40 N24 Carry[25] _NC52 _NC53 NAND2X1
X27 Carry[25] A[25] DIFF[25] _NC54 _NC55 XNOR2X1
X28 N39 N23 N24 _NC56 _NC57 AND2X1
X29 N38 N22 N23 _NC58 _NC59 AND2X1
X30 N37 N21 N22 _NC60 _NC61 AND2X1
X31 N36 N20 N21 _NC62 _NC63 AND2X1
X32 N34 N19 N20 _NC64 _NC65 AND2X1
X33 N33 N18 N19 _NC66 _NC67 AND2X1
X34 N32 N17 N18 _NC68 _NC69 AND2X1
X35 N31 N16 N17 _NC70 _NC71 AND2X1
X36 N30 N15 N16 _NC72 _NC73 AND2X1
X37 N29 N14 N15 _NC74 _NC75 AND2X1
X38 N28 N13 N14 _NC76 _NC77 AND2X1
X39 N27 N12 N13 _NC78 _NC79 AND2X1
X40 N26 N11 N12 _NC80 _NC81 AND2X1
X41 N25 N10 N11 _NC82 _NC83 AND2X1
X42 N48 N9 N10 _NC84 _NC85 AND2X1
X43 N47 N8 N9 _NC86 _NC87 AND2X1
X44 N46 N7 N8 _NC88 _NC89 AND2X1
X45 N45 N6 N7 _NC90 _NC91 AND2X1
X46 N44 N5 N6 _NC92 _NC93 AND2X1
X47 N43 N4 N5 _NC94 _NC95 AND2X1
X48 N42 N3 N4 _NC96 _NC97 AND2X1
X49 N41 N2 N3 _NC98 _NC99 AND2X1
X50 N35 N1 N2 _NC100 _NC101 AND2X1
X51 N49 B[0] N1 _NC102 _NC103 AND2X1
X52 A[23] _NC104 _NC105 N39 INVX0
X53 A[22] _NC106 _NC107 N38 INVX0
X54 A[21] _NC108 _NC109 N37 INVX0
X55 A[20] _NC110 _NC111 N36 INVX0
X56 A[19] _NC112 _NC113 N34 INVX0
X57 A[18] _NC114 _NC115 N33 INVX0
X58 A[17] _NC116 _NC117 N32 INVX0
X59 A[16] _NC118 _NC119 N31 INVX0
X60 A[15] _NC120 _NC121 N30 INVX0
X61 A[14] _NC122 _NC123 N29 INVX0
X62 A[13] _NC124 _NC125 N28 INVX0
X63 A[12] _NC126 _NC127 N27 INVX0
X64 A[11] _NC128 _NC129 N26 INVX0
X65 A[10] _NC130 _NC131 N25 INVX0
X66 A[9] _NC132 _NC133 N48 INVX0
X67 A[8] _NC134 _NC135 N47 INVX0
X68 A[7] _NC136 _NC137 N46 INVX0
X69 A[6] _NC138 _NC139 N45 INVX0
X70 A[5] _NC140 _NC141 N44 INVX0
X71 A[4] _NC142 _NC143 N43 INVX0
X72 A[3] _NC144 _NC145 N42 INVX0
X73 A[2] _NC146 _NC147 N41 INVX0
X74 A[1] _NC148 _NC149 N35 INVX0
X75 A[0] _NC150 _NC151 N49 INVX0
.ENDS sqrt_RD_WIDTH52_SQ_WIDTH26_DW01_sub_0

.SUBCKT pre_norm_sqrt Clk_i Opa_i[0] Opa_i[1] Opa_i[2] Opa_i[3] Opa_i[4] Opa_i[5] Opa_i[6] Opa_i[7] Opa_i[8] Opa_i[9] Opa_i[10] Opa_i[11] Opa_i[12] Opa_i[13] Opa_i[14] Opa_i[15] Opa_i[16] Opa_i[17] Opa_i[18] Opa_i[19] Opa_i[20] Opa_i[21] Opa_i[22] Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Opa_i[31] Fracta_52_o[0] Fracta_52_o[1] Fracta_52_o[2] Fracta_52_o[3] Fracta_52_o[4] Fracta_52_o[5] Fracta_52_o[6] Fracta_52_o[7] Fracta_52_o[8] Fracta_52_o[9] Fracta_52_o[10] Fracta_52_o[11] Fracta_52_o[12] Fracta_52_o[13] Fracta_52_o[14] Fracta_52_o[15] Fracta_52_o[16] Fracta_52_o[17] Fracta_52_o[18] Fracta_52_o[19] Fracta_52_o[20] Fracta_52_o[21] Fracta_52_o[22] Fracta_52_o[23] Fracta_52_o[24] Fracta_52_o[25] Fracta_52_o[26] Fracta_52_o[27] Fracta_52_o[28] Fracta_52_o[29] Fracta_52_o[30] Fracta_52_o[31] Fracta_52_o[32] Fracta_52_o[33] Fracta_52_o[34] Fracta_52_o[35] Fracta_52_o[36] Fracta_52_o[37] Fracta_52_o[38] Fracta_52_o[39] Fracta_52_o[40] Fracta_52_o[41] Fracta_52_o[42] Fracta_52_o[43] Fracta_52_o[44] Fracta_52_o[45] Fracta_52_o[46] Fracta_52_o[47] Fracta_52_o[48] Fracta_52_o[49] Fracta_52_o[50] Fracta_52_o[51] Exp_o[0] Exp_o[1] Exp_o[2] Exp_o[3] Exp_o[4] Exp_o[5] Exp_o[6] Exp_o[7]
X0 N3810 S_sqr_zeros_o[5] S_sqr_zeros_o[4] S_fracta1_52_o[9] _NC0 _NC1 NOR3X0
X1 N2280 N3800 N3810 N247 _NC2 _NC3 MUX21X1
X2 N214 N2060 N3780 S_fracta1_52_o[8] _NC4 _NC5 AND3X1
X3 N3770 N2210 N3780 N247 _NC6 _NC7 MUX21X1
X4 N3750 N2060 N214 S_fracta1_52_o[7] _NC8 _NC9 AND3X1
X5 N3740 N56 S_sqr_zeros_o[4] S_fracta1_52_o[6] _NC10 _NC11 NOR3X0
X6 N3730 N55 S_sqr_zeros_o[4] S_fracta1_52_o[5] _NC12 _NC13 NOR3X0
X7 S_sqr_zeros_o[4] S_sqr_zeros_o[5] N3720 S_fracta1_52_o[4] _NC14 _NC15 NOR3X0
X8 S_sqr_zeros_o[4] N56 N3710 S_fracta1_52_o[3] _NC16 _NC17 NOR3X0
X9 S_sqr_zeros_o[4] N55 N3700 S_fracta1_52_o[2] _NC18 _NC19 NOR3X0
X10 N369 N2060 S_fracta1_52_o[23] _NC20 _NC21 AND2X1
X11 N3750 N368 N369 N214 _NC22 _NC23 MUX21X1
X12 N232 N367 N368 N247 _NC24 _NC25 MUX21X1
X13 N366 N365 N367 N246 _NC26 _NC27 MUX21X1
X14 N3640 N3630 N365 N2450 _NC28 _NC29 MUX21X1
X15 Opa_i[22] N774 N3630 N57 _NC30 _NC31 MUX21X1
X16 N3740 N3600 N3610 N214 _NC32 _NC33 MUX21X1
X17 N3590 N2410 N3600 N247 _NC34 _NC35 MUX21X1
X18 N3570 N3560 N3580 N246 _NC36 _NC37 MUX21X1
X19 N3550 N3540 N3560 N2450 _NC38 _NC39 MUX21X1
X20 Opa_i[21] Opa_i[22] N3540 N57 _NC40 _NC41 MUX21X1
X21 N353 S_sqr_zeros_o[3] N3740 _NC42 _NC43 OR2X1
X22 N3730 N351 N352 N214 _NC44 _NC45 MUX21X1
X23 N350 N2390 N351 N247 _NC46 _NC47 MUX21X1
X24 N348 N3470 N349 N246 _NC48 _NC49 MUX21X1
X25 N3460 N3640 N3470 N2450 _NC50 _NC51 MUX21X1
X26 Opa_i[20] Opa_i[21] N3640 N57 _NC52 _NC53 MUX21X1
X27 N3450 S_sqr_zeros_o[3] N3730 _NC54 _NC55 OR2X1
X28 N3720 N3430 N3440 N214 _NC56 _NC57 MUX21X1
X29 N3420 N2360 N3430 N247 _NC58 _NC59 MUX21X1
X30 N3400 N3390 N3410 N246 _NC60 _NC61 MUX21X1
X31 N3380 N3550 N3390 N2450 _NC62 _NC63 MUX21X1
X32 Opa_i[19] Opa_i[20] N3550 N57 _NC64 _NC65 MUX21X1
X33 N3370 S_sqr_zeros_o[3] N3720 _NC66 _NC67 OR2X1
X34 N3360 S_sqr_zeros_o[5] S_sqr_zeros_o[4] S_fracta1_52_o[1] _NC68 _NC69 NOR3X0
X35 N3710 N334 N335 N214 _NC70 _NC71 MUX21X1
X36 N333 N332 N334 N247 _NC72 _NC73 MUX21X1
X37 N331 N2420 N332 N246 _NC74 _NC75 MUX21X1
X38 N3300 N3460 N366 N2450 _NC76 _NC77 MUX21X1
X39 Opa_i[18] Opa_i[19] N3460 N57 _NC78 _NC79 MUX21X1
X40 N3290 S_sqr_zeros_o[3] N3710 _NC80 _NC81 OR2X1
X41 N3700 N3270 N3280 N214 _NC82 _NC83 MUX21X1
X42 N3260 N3250 N3270 N247 _NC84 _NC85 MUX21X1
X43 N3240 N2400 N3250 N246 _NC86 _NC87 MUX21X1
X44 N3230 N3380 N3570 N2450 _NC88 _NC89 MUX21X1
X45 N83 Opa_i[18] N3380 N57 _NC90 _NC91 MUX21X1
X46 N3220 S_sqr_zeros_o[3] N3700 _NC92 _NC93 OR2X1
X47 N3360 N3200 N3210 N214 _NC94 _NC95 MUX21X1
X48 N3800 N3190 N3200 N247 _NC96 _NC97 MUX21X1
X49 N318 N2380 N3190 N246 _NC98 _NC99 MUX21X1
X50 N317 N3300 N348 N2450 _NC100 _NC101 MUX21X1
X51 Opa_i[16] N83 N3300 N57 _NC102 _NC103 MUX21X1
X52 N229 N231 N3800 N246 _NC104 _NC105 MUX21X1
X53 N314 N3130 N315 N214 _NC106 _NC107 MUX21X1
X54 N3760 N3120 N3130 N247 _NC108 _NC109 MUX21X1
X55 N3110 N2350 N3120 N246 _NC110 _NC111 MUX21X1
X56 N3100 N3230 N3400 N2450 _NC112 _NC113 MUX21X1
X57 N80 Opa_i[16] N3230 N57 _NC114 _NC115 MUX21X1
X58 N3090 N3080 N3760 N246 _NC116 _NC117 MUX21X1
X59 S_sqr_zeros_o[4] N56 N3070 S_fracta1_52_o[15] _NC118 _NC119 NOR3X0
X60 N2270 N3620 N3070 N247 _NC120 _NC121 MUX21X1
X61 N3060 N331 N3620 N246 _NC122 _NC123 MUX21X1
X62 N3050 N2370 N331 N2450 _NC124 _NC125 MUX21X1
X63 Opa_i[14] N80 N317 N57 _NC126 _NC127 MUX21X1
X64 N3030 N3020 N3040 N246 _NC128 _NC129 MUX21X1
X65 S_sqr_zeros_o[4] N55 N301 S_fracta1_52_o[14] _NC130 _NC131 NOR3X0
X66 N353 N3590 N301 N247 _NC132 _NC133 MUX21X1
X67 N300 N3240 N3590 N246 _NC134 _NC135 MUX21X1
X68 N299 N2340 N3240 N2450 _NC136 _NC137 MUX21X1
X69 N77 Opa_i[14] N3100 N57 _NC138 _NC139 MUX21X1
X70 N298 N297 N353 N246 _NC140 _NC141 MUX21X1
X71 N2960 S_sqr_zeros_o[5] S_sqr_zeros_o[4] S_fracta1_52_o[13] _NC142 _NC143 NOR3X0
X72 N3450 N350 N2960 N247 _NC144 _NC145 MUX21X1
X73 N231 N318 N350 N246 _NC146 _NC147 MUX21X1
X74 N2950 N3050 N318 N2450 _NC148 _NC149 MUX21X1
X75 N2730 N78 N3050 N57 _NC150 _NC151 MUX21X1
X76 N2930 N2920 N2940 N2450 _NC152 _NC153 MUX21X1
X77 N316 N229 N3450 N246 _NC154 _NC155 MUX21X1
X78 N2900 N2890 N2910 N2450 _NC156 _NC157 MUX21X1
X79 N2870 N56 S_sqr_zeros_o[4] S_fracta1_52_o[12] _NC158 _NC159 NOR3X0
X80 N3370 N3420 N2870 N247 _NC160 _NC161 MUX21X1
X81 N3080 N3110 N3420 N246 _NC162 _NC163 MUX21X1
X82 N2260 N299 N3110 N2450 _NC164 _NC165 MUX21X1
X83 N76 N2730 N299 N58 _NC166 _NC167 MUX21X1
X84 N2240 N2250 N3080 N2450 _NC168 _NC169 MUX21X1
X85 N2860 N3090 N3370 N246 _NC170 _NC171 MUX21X1
X86 N2220 N2230 N3090 N2450 _NC172 _NC173 MUX21X1
X87 N2850 N55 S_sqr_zeros_o[4] S_fracta1_52_o[11] _NC174 _NC175 NOR3X0
X88 N3290 N333 N2850 N247 _NC176 _NC177 MUX21X1
X89 N230 N3060 N333 N246 _NC178 _NC179 MUX21X1
X90 N233 N2950 N3060 N2450 _NC180 _NC181 MUX21X1
X91 N74 N76 N2950 N58 _NC182 _NC183 MUX21X1
X92 Opa_i[8] N72 N2920 N58 _NC184 _NC185 MUX21X1
X93 N2890 N2930 N3020 N2450 _NC186 _NC187 MUX21X1
X94 Opa_i[6] N69 N2930 N58 _NC188 _NC189 MUX21X1
X95 N64 N66 N2890 N58 _NC190 _NC191 MUX21X1
X96 N2880 N2900 N3030 N2450 _NC192 _NC193 MUX21X1
X97 N61 Opa_i[3] N2900 N58 _NC194 _NC195 MUX21X1
X98 Opa_i[0] N59 N2880 N58 _NC196 _NC197 MUX21X1
X99 N284 N56 S_sqr_zeros_o[4] S_fracta1_52_o[10] _NC198 _NC199 NOR3X0
X100 N3220 N3260 N284 N247 _NC200 _NC201 MUX21X1
X101 N297 N300 N3260 N246 _NC202 _NC203 MUX21X1
X102 N2250 N2260 N300 N2450 _NC204 _NC205 MUX21X1
X103 N72 Opa_i[10] N283 N58 _NC206 _NC207 MUX21X1
X104 N69 Opa_i[8] N282 N58 _NC208 _NC209 MUX21X1
X105 N2230 N2240 N297 N2450 _NC210 _NC211 MUX21X1
X106 N66 Opa_i[6] N281 N58 _NC212 _NC213 MUX21X1
X107 Opa_i[3] N64 N280 N58 _NC214 _NC215 MUX21X1
X108 N298 S_sqr_zeros_o[2] N3220 _NC216 _NC217 OR2X1
X109 N2790 N2220 N298 N2450 _NC218 _NC219 MUX21X1
X110 N59 N61 N2780 N58 _NC220 _NC221 MUX21X1
X111 N314 N55 S_sqr_zeros_o[4] S_fracta1_52_o[0] _NC222 _NC223 NOR3X0
X112 N2790 S_sqr_zeros_o[1] N2860 _NC224 _NC225 OR2X1
X113 N153 N197 N159 _NC226 _NC227 AND2X1
X114 Add_90_I24_L07002_C89_carry[3] N449 N460 _NC228 _NC229 XOR2X1
X115 N444 _NC230 _NC231 N455 INVX0
X116 Add_90_I23_L07002_C89_carry[3] N432 N443 _NC232 _NC233 XOR2X1
X117 N427 _NC234 _NC235 N438 INVX0
X118 Add_90_I22_L07002_C89_carry[3] N415 N426 _NC236 _NC237 XOR2X1
X119 N410 _NC238 _NC239 N421 INVX0
X120 Add_90_I21_L07002_C89_carry[3] N398 N409 _NC240 _NC241 XOR2X1
X121 N393 _NC242 _NC243 N404 INVX0
X122 Add_90_I20_L07002_C89_carry[3] N381 N392 _NC244 _NC245 XOR2X1
X123 N376 _NC246 _NC247 N387 INVX0
X124 Add_90_I19_L07002_C89_carry[3] N364 N375 _NC248 _NC249 XOR2X1
X125 N359 _NC250 _NC251 N370 INVX0
X126 Add_90_I18_L07002_C89_carry[3] N347 N358 _NC252 _NC253 XOR2X1
X127 Add_90_I17_L07002_C89_carry[3] N330 N341 _NC254 _NC255 XOR2X1
X128 N325 _NC256 _NC257 N336 INVX0
X129 Add_90_I16_L07002_C89_carry[3] N313 N324 _NC258 _NC259 XOR2X1
X130 N308 _NC260 _NC261 N319 INVX0
X131 Add_90_I15_L07002_C89_carry[3] N296 N307 _NC262 _NC263 XOR2X1
X132 N291 _NC264 _NC265 N302 INVX0
X133 Add_90_I14_L07002_C89_carry[3] N279 N290 _NC266 _NC267 XOR2X1
X134 N274 _NC268 _NC269 N285 INVX0
X135 Add_90_I13_L07002_C89_carry[3] N262 N273 _NC270 _NC271 XOR2X1
X136 N257 _NC272 _NC273 N268 INVX0
X137 Add_90_I12_L07002_C89_carry[3] N245 N256 _NC274 _NC275 XOR2X1
X138 N240 _NC276 _NC277 N251 INVX0
X139 Add_90_I11_L07002_C89_carry[3] N228 N239 _NC278 _NC279 XOR2X1
X140 N223 _NC280 _NC281 N234 INVX0
X141 Add_90_I10_L07002_C89_carry[3] N211 N222 _NC282 _NC283 XOR2X1
X142 N206 _NC284 _NC285 N217 INVX0
X143 Add_90_I9_L07002_C89_carry[3] N194 N205 _NC286 _NC287 XOR2X1
X144 N189 _NC288 _NC289 N200 INVX0
X145 N172 _NC290 _NC291 N183 INVX0
X146 N155 _NC292 _NC293 N166 INVX0
X147 N139 _NC294 _NC295 N149 INVX0
X148 N125 _NC296 _NC297 N134 INVX0
X149 N198 Opa_i[24] N760 _NC298 _NC299 XNOR2X1
X150 Opa_i[24] N198 Add_1_root_sub_0_root_sub_92_carry[2] _NC300 _NC301 OR2X1
X151 Add_1_root_sub_0_root_sub_92_carry[2] Opa_i[25] N761 _NC302 _NC303 XNOR2X1
X152 Opa_i[25] Add_1_root_sub_0_root_sub_92_carry[2] Add_1_root_sub_0_root_sub_92_carry[3] _NC304 _NC305 OR2X1
X153 Add_1_root_sub_0_root_sub_92_carry[3] Opa_i[26] N762 _NC306 _NC307 XNOR2X1
X154 Opa_i[26] Add_1_root_sub_0_root_sub_92_carry[3] Add_1_root_sub_0_root_sub_92_carry[4] _NC308 _NC309 OR2X1
X155 Add_1_root_sub_0_root_sub_92_carry[4] Opa_i[27] N763 _NC310 _NC311 XNOR2X1
X156 Opa_i[27] Add_1_root_sub_0_root_sub_92_carry[4] Add_1_root_sub_0_root_sub_92_carry[5] _NC312 _NC313 OR2X1
X157 Add_1_root_sub_0_root_sub_92_carry[5] Opa_i[28] N764 _NC314 _NC315 XNOR2X1
X158 Opa_i[28] Add_1_root_sub_0_root_sub_92_carry[5] Add_1_root_sub_0_root_sub_92_carry[6] _NC316 _NC317 OR2X1
X159 Add_1_root_sub_0_root_sub_92_carry[6] Opa_i[29] N765 _NC318 _NC319 XNOR2X1
X160 Opa_i[29] Add_1_root_sub_0_root_sub_92_carry[6] Add_1_root_sub_0_root_sub_92_carry[7] _NC320 _NC321 OR2X1
X161 Opa_i[30] Add_1_root_sub_0_root_sub_92_carry[7] N766 _NC322 _NC323 XOR2X1
X162 Add_1_root_sub_0_root_sub_92_carry[7] Opa_i[30] N767 _NC324 _NC325 AND2X1
X163 N2000 _NC326 _NC327 N199 INVX0
X164 N2000 _NC328 _NC329 N198 INVX0
X165 Opa_i[18] _NC330 _NC331 N197 INVX0
X166 N196 _NC332 _NC333 N83 INVX0
X167 Opa_i[16] _NC334 _NC335 N82 INVX0
X168 N81 _NC336 _NC337 N80 INVX0
X169 Opa_i[14] _NC338 _NC339 N79 INVX0
X170 N78 _NC340 _NC341 N77 INVX0
X171 N76 _NC342 _NC343 N75 INVX0
X172 Opa_i[10] _NC344 _NC345 N74 INVX0
X173 N73 _NC346 _NC347 N72 INVX0
X174 Opa_i[8] _NC348 _NC349 N71 INVX0
X175 N70 _NC350 _NC351 N69 INVX0
X176 Opa_i[6] _NC352 _NC353 N68 INVX0
X177 N67 _NC354 _NC355 N66 INVX0
X178 N65 _NC356 _NC357 N64 INVX0
X179 Opa_i[3] _NC358 _NC359 N63 INVX0
X180 N62 _NC360 _NC361 N61 INVX0
X181 N60 _NC362 _NC363 N59 INVX0
X182 N84 N85 N86 N87 N56 _NC364 _NC365 NAND4X0
X183 Opa_i[21] _NC366 _NC367 N2710 INVX0
X184 Opa_i[19] _NC368 _NC369 N2720 INVX0
X185 Opa_i[0] N57 N2790 _NC370 _NC371 NAND2X1
X186 Opa_i[0] _NC372 _NC373 N2740 INVX0
X187 N774 Opa_i[22] N1510 _NC374 _NC375 NOR2X0
X188 N1940 N195 N774 _NC376 _NC377 NAND2X1
X189 Opa_i[1] _NC378 _NC379 N60 INVX0
X190 Opa_i[5] _NC380 _NC381 N67 INVX0
X191 Opa_i[2] _NC382 _NC383 N62 INVX0
X192 Opa_i[7] _NC384 _NC385 N70 INVX0
X193 Opa_i[4] _NC386 _NC387 N65 INVX0
X194 N1900 _NC388 _NC389 N2690 INVX0
X195 Opa_i[9] _NC390 _NC391 N73 INVX0
X196 Opa_i[11] _NC392 _NC393 N76 INVX0
X197 Opa_i[15] _NC394 _NC395 N81 INVX0
X198 Opa_i[17] _NC396 _NC397 N196 INVX0
X199 Opa_i[12] _NC398 _NC399 N2730 INVX0
X200 Opa_i[23] _NC400 _NC401 N2050 INVX0
X201 N282 _NC402 _NC403 N2250 INVX0
X202 N283 _NC404 _NC405 N2260 INVX0
X203 N280 _NC406 _NC407 N2230 INVX0
X204 N281 _NC408 _NC409 N2240 INVX0
X205 N1370 N2720 N138 _NC410 _NC411 NAND2X1
X206 N1510 N2710 N1890 _NC412 _NC413 NAND2X1
X207 N774 _NC414 _NC415 N2440 INVX0
X208 Opa_i[13] _NC416 _NC417 N78 INVX0
X209 N1890 Opa_i[20] N1370 _NC418 _NC419 NOR2X0
X210 N1870 _NC420 _NC421 N249 INVX0
X211 N3580 _NC422 _NC423 N2410 INVX0
X212 N55 N3610 S_fracta1_52_o[22] _NC424 _NC425 NOR2X0
X213 N1930 Opa_i[20] N1910 _NC426 _NC427 NOR2X0
X214 Add_90_I8_L07002_C89_carry[3] N2750 N188 _NC428 _NC429 XNOR2X1
X215 N2880 N2450 N316 _NC430 _NC431 NAND2X1
X216 N2050 _NC432 _NC433 N2040 NBUFFX2
X217 N2050 _NC434 _NC435 N2030 NBUFFX2
X218 N2050 _NC436 _NC437 N2020 NBUFFX2
X219 N2050 _NC438 _NC439 N2010 NBUFFX2
X220 N93 N259 N1400 _NC440 _NC441 NAND2X1
X221 N93 N257 N1660 _NC442 _NC443 NAND2X1
X222 N93 N258 N1530 _NC444 _NC445 NAND2X1
X223 N93 N262 N85 _NC446 _NC447 NAND2X1
X224 N330 _NC448 _NC449 N2090 INVX0
X225 N296 _NC450 _NC451 N2110 INVX0
X226 N295 _NC452 _NC453 N2190 INVX0
X227 N294 _NC454 _NC455 N2550 INVX0
X228 N293 _NC456 _NC457 N2610 INVX0
X229 N292 _NC458 _NC459 N267 INVX0
X230 N2050 _NC460 _NC461 N2000 NBUFFX2
X231 N364 _NC462 _NC463 N2070 INVX0
X232 N363 _NC464 _NC465 N215 INVX0
X233 N362 _NC466 _NC467 N2510 INVX0
X234 N361 _NC468 _NC469 N2570 INVX0
X235 N360 _NC470 _NC471 N263 INVX0
X236 N329 _NC472 _NC473 N2170 INVX0
X237 N328 _NC474 _NC475 N2530 INVX0
X238 N327 _NC476 _NC477 N2590 INVX0
X239 N326 _NC478 _NC479 N265 INVX0
X240 S_sqr_zeros_o[0] _NC480 _NC481 N2430 INVX0
X241 N1830 N1840 N182 _NC482 _NC483 NOR2X0
X242 N138 _NC484 _NC485 N250 INVX0
X243 N1850 N63 N1860 _NC486 _NC487 NAND2X1
X244 N179 N71 N180 _NC488 _NC489 NAND2X1
X245 N1700 N82 N1710 _NC490 _NC491 NAND2X1
X246 N1720 N79 N1730 _NC492 _NC493 NAND2X1
X247 N1740 N2730 N96 _NC494 _NC495 NAND2X1
X248 N100 N74 N178 _NC496 _NC497 NAND2X1
X249 N250 N197 N115 _NC498 _NC499 NAND2X1
X250 N181 N68 N105 _NC500 _NC501 NAND2X1
X251 N2860 S_sqr_zeros_o[2] N3770 _NC502 _NC503 NOR2X0
X252 N366 _NC504 _NC505 N2420 INVX0
X253 N2940 _NC506 _NC507 N231 INVX0
X254 N2910 _NC508 _NC509 N229 INVX0
X255 N123 N124 N122 _NC510 _NC511 NOR2X0
X256 N1340 N1350 N133 _NC512 _NC513 NOR2X0
X257 N148 N1490 N147 _NC514 _NC515 NOR2X0
X258 N161 N162 N160 _NC516 _NC517 NOR2X0
X259 N106 N107 N104 _NC518 _NC519 NOR2X0
X260 N3040 _NC520 _NC521 N2270 INVX0
X261 N3100 _NC522 _NC523 N2340 INVX0
X262 N317 _NC524 _NC525 N2370 INVX0
X263 N2920 _NC526 _NC527 N233 INVX0
X264 N171 N196 N2750 _NC528 _NC529 NAND2X1
X265 N316 S_sqr_zeros_o[2] N3790 _NC530 _NC531 NOR2X0
X266 N1250 N1260 N250 S_sqr_zeros_o[3] _NC532 _NC533 OA21X1
X267 N3410 _NC534 _NC535 N2360 INVX0
X268 S_sqr_zeros_o[5] N3440 S_fracta1_52_o[20] _NC536 _NC537 NOR2X0
X269 N3030 N246 N3290 _NC538 _NC539 NAND2X1
X270 N349 _NC540 _NC541 N2390 INVX0
X271 N56 N352 S_fracta1_52_o[21] _NC542 _NC543 NOR2X0
X272 N113 N114 N250 S_sqr_zeros_o[4] _NC544 _NC545 OA21X1
X273 S_sqr_zeros_o[1] _NC546 _NC547 N2450 INVX0
X274 N96 _NC548 _NC549 N248 INVX0
X275 N115 N1700 N89 _NC550 _NC551 NOR2X0
X276 N1710 N1720 N88 _NC552 _NC553 NOR2X0
X277 N100 N178 N101 _NC554 _NC555 NAND2X1
X278 N1730 N1740 N92 _NC556 _NC557 NOR2X0
X279 N313 _NC558 _NC559 N2100 INVX0
X280 N312 _NC560 _NC561 N2180 INVX0
X281 N311 _NC562 _NC563 N2540 INVX0
X282 N310 _NC564 _NC565 N2600 INVX0
X283 N309 _NC566 _NC567 N266 INVX0
X284 N279 _NC568 _NC569 N212 INVX0
X285 N278 _NC570 _NC571 N2200 INVX0
X286 N277 _NC572 _NC573 N2560 INVX0
X287 N276 _NC574 _NC575 N2620 INVX0
X288 N275 _NC576 _NC577 N2680 INVX0
X289 N342 _NC578 _NC579 N2700 INVX0
X290 N181 N105 N103 _NC580 _NC581 NAND2X1
X291 N179 N180 N98 _NC582 _NC583 NAND2X1
X292 N347 _NC584 _NC585 N2080 INVX0
X293 N346 _NC586 _NC587 N216 INVX0
X294 N345 _NC588 _NC589 N2520 INVX0
X295 N344 _NC590 _NC591 N2580 INVX0
X296 N343 _NC592 _NC593 N264 INVX0
X297 N2780 _NC594 _NC595 N2220 INVX0
X298 N1860 N1880 N111 _NC596 _NC597 NOR2X0
X299 N1860 N61 N1880 _NC598 _NC599 NOR2X0
X300 N1730 N77 N1740 _NC600 _NC601 NOR2X0
X301 N115 N83 N1700 _NC602 _NC603 NOR2X0
X302 N1710 N80 N1720 _NC604 _NC605 NOR2X0
X303 N110 N64 N1850 _NC606 _NC607 NOR2X0
X304 N180 N69 N181 _NC608 _NC609 NOR2X0
X305 N178 N72 N179 _NC610 _NC611 NOR2X0
X306 N96 N75 N100 _NC612 _NC613 NOR2X0
X307 N2430 _NC614 _NC615 N58 NBUFFX2
X308 N2430 _NC616 _NC617 N57 NBUFFX2
X309 N3760 _NC618 _NC619 N2210 INVX0
X310 N84 N85 N86 N87 N55 _NC620 _NC621 NAND4X0
X311 N3570 _NC622 _NC623 N2400 INVX0
X312 N348 _NC624 _NC625 N2380 INVX0
X313 N3400 _NC626 _NC627 N2350 INVX0
X314 N2750 _NC628 _NC629 N213 INVX0
X315 N2270 S_sqr_zeros_o[3] N3750 _NC630 _NC631 NOR2X0
X316 N55 N335 S_fracta1_52_o[19] _NC632 _NC633 NOR2X0
X317 N55 N315 S_fracta1_52_o[16] _NC634 _NC635 NOR2X0
X318 N3020 _NC636 _NC637 N230 INVX0
X319 N119 N120 N117 _NC638 _NC639 NAND2X1
X320 N130 N131 N128 _NC640 _NC641 NAND2X1
X321 N3790 N247 N3360 _NC642 _NC643 NAND2X1
X322 N3770 N247 N314 _NC644 _NC645 NAND2X1
X323 N56 N3280 S_fracta1_52_o[18] _NC646 _NC647 NOR2X0
X324 N3790 _NC648 _NC649 N2280 INVX0
X325 S_sqr_zeros_o[4] _NC650 _NC651 N214 INVX0
X326 S_sqr_zeros_o[3] _NC652 _NC653 N247 INVX0
X327 S_sqr_zeros_o[2] _NC654 _NC655 N246 INVX0
X328 N110 N1850 N112 _NC656 _NC657 NOR2X0
X329 S_sqr_zeros_o[5] _NC658 _NC659 N2060 INVX0
X330 N3620 _NC660 _NC661 N232 INVX0
X331 S_sqr_zeros_o[5] N3210 S_fracta1_52_o[17] _NC662 _NC663 NOR2X0
X332 Vdd _NC664 _NC665 Fracta_52_o[26] INVX0
X333 Vdd _NC666 _NC667 Fracta_52_o[25] INVX0
X334 Vdd _NC668 _NC669 Fracta_52_o[24] INVX0
X335 Vdd _NC670 _NC671 Fracta_52_o[23] INVX0
X336 Vdd _NC672 _NC673 Fracta_52_o[22] INVX0
X337 Vdd _NC674 _NC675 Fracta_52_o[21] INVX0
X338 Vdd _NC676 _NC677 Fracta_52_o[20] INVX0
X339 Vdd _NC678 _NC679 Fracta_52_o[19] INVX0
X340 Vdd _NC680 _NC681 Fracta_52_o[18] INVX0
X341 Vdd _NC682 _NC683 Fracta_52_o[17] INVX0
X342 Vdd _NC684 _NC685 Fracta_52_o[16] INVX0
X343 Vdd _NC686 _NC687 Fracta_52_o[15] INVX0
X344 Vdd _NC688 _NC689 Fracta_52_o[14] INVX0
X345 Vdd _NC690 _NC691 Fracta_52_o[13] INVX0
X346 Vdd _NC692 _NC693 Fracta_52_o[12] INVX0
X347 Vdd _NC694 _NC695 Fracta_52_o[11] INVX0
X348 Vdd _NC696 _NC697 Fracta_52_o[10] INVX0
X349 Vdd _NC698 _NC699 Fracta_52_o[9] INVX0
X350 Vdd _NC700 _NC701 Fracta_52_o[8] INVX0
X351 Vdd _NC702 _NC703 Fracta_52_o[7] INVX0
X352 Vdd _NC704 _NC705 Fracta_52_o[6] INVX0
X353 Vdd _NC706 _NC707 Fracta_52_o[5] INVX0
X354 Vdd _NC708 _NC709 Fracta_52_o[4] INVX0
X355 Vdd _NC710 _NC711 Fracta_52_o[3] INVX0
X356 Vdd _NC712 _NC713 Fracta_52_o[2] INVX0
X357 Vdd _NC714 _NC715 Fracta_52_o[1] INVX0
X358 Vdd _NC716 _NC717 Fracta_52_o[0] INVX0
X359 N127 Add_90_I5_L07002_C89_carry[2] N137 _NC718 _NC719 _NC720 HADDX1
X360 N126 N125 Add_90_I5_L07002_C89_carry[2] _NC721 _NC722 _NC723 HADDX1
X361 N142 Add_90_I6_L07002_C89_carry[3] N153 _NC724 _NC725 _NC726 HADDX1
X362 N141 Add_90_I6_L07002_C89_carry[2] Add_90_I6_L07002_C89_carry[3] _NC727 _NC728 _NC729 HADDX1
X363 N140 N139 Add_90_I6_L07002_C89_carry[2] _NC730 _NC731 _NC732 HADDX1
X364 N159 Add_90_I7_L07002_C89_carry[2] N171 _NC733 _NC734 _NC735 HADDX1
X365 N158 Add_90_I7_L07002_C89_carry[1] Add_90_I7_L07002_C89_carry[2] _NC736 _NC737 _NC738 HADDX1
X366 N157 Add_90_I7_L07002_C89_carry[0] Add_90_I7_L07002_C89_carry[1] _NC739 _NC740 _NC741 HADDX1
X367 N156 N155 Add_90_I7_L07002_C89_carry[0] _NC742 _NC743 _NC744 HADDX1
X368 N176 Add_90_I8_L07002_C89_carry[2] Add_90_I8_L07002_C89_carry[3] _NC745 _NC746 _NC747 HADDX1
X369 N175 Add_90_I8_L07002_C89_carry[1] Add_90_I8_L07002_C89_carry[2] _NC748 _NC749 _NC750 HADDX1
X370 N174 Add_90_I8_L07002_C89_carry[0] Add_90_I8_L07002_C89_carry[1] _NC751 _NC752 _NC753 HADDX1
X371 N173 N172 Add_90_I8_L07002_C89_carry[0] _NC754 _NC755 _NC756 HADDX1
X372 N193 Add_90_I9_L07002_C89_carry[2] Add_90_I9_L07002_C89_carry[3] _NC757 _NC758 _NC759 HADDX1
X373 N192 Add_90_I9_L07002_C89_carry[1] Add_90_I9_L07002_C89_carry[2] _NC760 _NC761 _NC762 HADDX1
X374 N191 Add_90_I9_L07002_C89_carry[0] Add_90_I9_L07002_C89_carry[1] _NC763 _NC764 _NC765 HADDX1
X375 N190 N189 Add_90_I9_L07002_C89_carry[0] _NC766 _NC767 _NC768 HADDX1
X376 N210 Add_90_I10_L07002_C89_carry[2] Add_90_I10_L07002_C89_carry[3] _NC769 _NC770 _NC771 HADDX1
X377 N209 Add_90_I10_L07002_C89_carry[1] Add_90_I10_L07002_C89_carry[2] _NC772 _NC773 _NC774 HADDX1
X378 N208 Add_90_I10_L07002_C89_carry[0] Add_90_I10_L07002_C89_carry[1] _NC775 _NC776 _NC777 HADDX1
X379 N207 N206 Add_90_I10_L07002_C89_carry[0] _NC778 _NC779 _NC780 HADDX1
X380 N227 Add_90_I11_L07002_C89_carry[2] Add_90_I11_L07002_C89_carry[3] _NC781 _NC782 _NC783 HADDX1
X381 N226 Add_90_I11_L07002_C89_carry[1] Add_90_I11_L07002_C89_carry[2] _NC784 _NC785 _NC786 HADDX1
X382 N225 Add_90_I11_L07002_C89_carry[0] Add_90_I11_L07002_C89_carry[1] _NC787 _NC788 _NC789 HADDX1
X383 N224 N223 Add_90_I11_L07002_C89_carry[0] _NC790 _NC791 _NC792 HADDX1
X384 N244 Add_90_I12_L07002_C89_carry[2] Add_90_I12_L07002_C89_carry[3] _NC793 _NC794 _NC795 HADDX1
X385 N243 Add_90_I12_L07002_C89_carry[1] Add_90_I12_L07002_C89_carry[2] _NC796 _NC797 _NC798 HADDX1
X386 N242 Add_90_I12_L07002_C89_carry[0] Add_90_I12_L07002_C89_carry[1] _NC799 _NC800 _NC801 HADDX1
X387 N241 N240 Add_90_I12_L07002_C89_carry[0] _NC802 _NC803 _NC804 HADDX1
X388 N261 Add_90_I13_L07002_C89_carry[2] Add_90_I13_L07002_C89_carry[3] _NC805 _NC806 _NC807 HADDX1
X389 N260 Add_90_I13_L07002_C89_carry[1] Add_90_I13_L07002_C89_carry[2] _NC808 _NC809 _NC810 HADDX1
X390 N259 Add_90_I13_L07002_C89_carry[0] Add_90_I13_L07002_C89_carry[1] _NC811 _NC812 _NC813 HADDX1
X391 N258 N257 Add_90_I13_L07002_C89_carry[0] _NC814 _NC815 _NC816 HADDX1
X392 N278 Add_90_I14_L07002_C89_carry[2] Add_90_I14_L07002_C89_carry[3] _NC817 _NC818 _NC819 HADDX1
X393 N277 Add_90_I14_L07002_C89_carry[1] Add_90_I14_L07002_C89_carry[2] _NC820 _NC821 _NC822 HADDX1
X394 N276 Add_90_I14_L07002_C89_carry[0] Add_90_I14_L07002_C89_carry[1] _NC823 _NC824 _NC825 HADDX1
X395 N275 N274 Add_90_I14_L07002_C89_carry[0] _NC826 _NC827 _NC828 HADDX1
X396 N295 Add_90_I15_L07002_C89_carry[2] Add_90_I15_L07002_C89_carry[3] _NC829 _NC830 _NC831 HADDX1
X397 N294 Add_90_I15_L07002_C89_carry[1] Add_90_I15_L07002_C89_carry[2] _NC832 _NC833 _NC834 HADDX1
X398 N293 Add_90_I15_L07002_C89_carry[0] Add_90_I15_L07002_C89_carry[1] _NC835 _NC836 _NC837 HADDX1
X399 N292 N291 Add_90_I15_L07002_C89_carry[0] _NC838 _NC839 _NC840 HADDX1
X400 N312 Add_90_I16_L07002_C89_carry[2] Add_90_I16_L07002_C89_carry[3] _NC841 _NC842 _NC843 HADDX1
X401 N311 Add_90_I16_L07002_C89_carry[1] Add_90_I16_L07002_C89_carry[2] _NC844 _NC845 _NC846 HADDX1
X402 N310 Add_90_I16_L07002_C89_carry[0] Add_90_I16_L07002_C89_carry[1] _NC847 _NC848 _NC849 HADDX1
X403 N309 N308 Add_90_I16_L07002_C89_carry[0] _NC850 _NC851 _NC852 HADDX1
X404 N329 Add_90_I17_L07002_C89_carry[2] Add_90_I17_L07002_C89_carry[3] _NC853 _NC854 _NC855 HADDX1
X405 N328 Add_90_I17_L07002_C89_carry[1] Add_90_I17_L07002_C89_carry[2] _NC856 _NC857 _NC858 HADDX1
X406 N327 Add_90_I17_L07002_C89_carry[0] Add_90_I17_L07002_C89_carry[1] _NC859 _NC860 _NC861 HADDX1
X407 N326 N325 Add_90_I17_L07002_C89_carry[0] _NC862 _NC863 _NC864 HADDX1
X408 N346 Add_90_I18_L07002_C89_carry[2] Add_90_I18_L07002_C89_carry[3] _NC865 _NC866 _NC867 HADDX1
X409 N345 Add_90_I18_L07002_C89_carry[1] Add_90_I18_L07002_C89_carry[2] _NC868 _NC869 _NC870 HADDX1
X410 N344 Add_90_I18_L07002_C89_carry[0] Add_90_I18_L07002_C89_carry[1] _NC871 _NC872 _NC873 HADDX1
X411 N343 N342 Add_90_I18_L07002_C89_carry[0] _NC874 _NC875 _NC876 HADDX1
X412 N363 Add_90_I19_L07002_C89_carry[2] Add_90_I19_L07002_C89_carry[3] _NC877 _NC878 _NC879 HADDX1
X413 N362 Add_90_I19_L07002_C89_carry[1] Add_90_I19_L07002_C89_carry[2] _NC880 _NC881 _NC882 HADDX1
X414 N361 Add_90_I19_L07002_C89_carry[0] Add_90_I19_L07002_C89_carry[1] _NC883 _NC884 _NC885 HADDX1
X415 N360 N359 Add_90_I19_L07002_C89_carry[0] _NC886 _NC887 _NC888 HADDX1
X416 N380 Add_90_I20_L07002_C89_carry[2] Add_90_I20_L07002_C89_carry[3] _NC889 _NC890 _NC891 HADDX1
X417 N379 Add_90_I20_L07002_C89_carry[1] Add_90_I20_L07002_C89_carry[2] _NC892 _NC893 _NC894 HADDX1
X418 N378 Add_90_I20_L07002_C89_carry[0] Add_90_I20_L07002_C89_carry[1] _NC895 _NC896 _NC897 HADDX1
X419 N377 N376 Add_90_I20_L07002_C89_carry[0] _NC898 _NC899 _NC900 HADDX1
X420 N397 Add_90_I21_L07002_C89_carry[2] Add_90_I21_L07002_C89_carry[3] _NC901 _NC902 _NC903 HADDX1
X421 N396 Add_90_I21_L07002_C89_carry[1] Add_90_I21_L07002_C89_carry[2] _NC904 _NC905 _NC906 HADDX1
X422 N395 Add_90_I21_L07002_C89_carry[0] Add_90_I21_L07002_C89_carry[1] _NC907 _NC908 _NC909 HADDX1
X423 N394 N393 Add_90_I21_L07002_C89_carry[0] _NC910 _NC911 _NC912 HADDX1
X424 N414 Add_90_I22_L07002_C89_carry[2] Add_90_I22_L07002_C89_carry[3] _NC913 _NC914 _NC915 HADDX1
X425 N413 Add_90_I22_L07002_C89_carry[1] Add_90_I22_L07002_C89_carry[2] _NC916 _NC917 _NC918 HADDX1
X426 N412 Add_90_I22_L07002_C89_carry[0] Add_90_I22_L07002_C89_carry[1] _NC919 _NC920 _NC921 HADDX1
X427 N411 N410 Add_90_I22_L07002_C89_carry[0] _NC922 _NC923 _NC924 HADDX1
X428 N431 Add_90_I23_L07002_C89_carry[2] Add_90_I23_L07002_C89_carry[3] _NC925 _NC926 _NC927 HADDX1
X429 N430 Add_90_I23_L07002_C89_carry[1] Add_90_I23_L07002_C89_carry[2] _NC928 _NC929 _NC930 HADDX1
X430 N429 Add_90_I23_L07002_C89_carry[0] Add_90_I23_L07002_C89_carry[1] _NC931 _NC932 _NC933 HADDX1
X431 N428 N427 Add_90_I23_L07002_C89_carry[0] _NC934 _NC935 _NC936 HADDX1
X432 N448 Add_90_I24_L07002_C89_carry[2] Add_90_I24_L07002_C89_carry[3] _NC937 _NC938 _NC939 HADDX1
X433 N447 Add_90_I24_L07002_C89_carry[1] Add_90_I24_L07002_C89_carry[2] _NC940 _NC941 _NC942 HADDX1
X434 N446 Add_90_I24_L07002_C89_carry[0] Add_90_I24_L07002_C89_carry[1] _NC943 _NC944 _NC945 HADDX1
X435 N445 N444 Add_90_I24_L07002_C89_carry[0] _NC946 _NC947 _NC948 HADDX1
X436 N2000 N760 N761 N762 N763 N764 N765 N766 N767 S_sqr_zeros_o[0] S_sqr_zeros_o[1] S_sqr_zeros_o[2] S_sqr_zeros_o[3] S_sqr_zeros_o[4] N56 Vss Vss Vss Vss SYNOPSYS_UNCONNECTED__0 S_exp_tem[0] S_exp_tem[1] S_exp_tem[2] S_exp_tem[3] S_exp_tem[4] S_exp_tem[5] S_exp_tem[6] S_exp_tem[7] _NC949 pre_norm_sqrt_DW01_sub_0
X437 Opa_i[26] Opa_i[25] Opa_i[24] N198 N1940 _NC950 _NC951 NOR4X0
X438 Opa_i[30] Opa_i[29] Opa_i[28] Opa_i[27] N195 _NC952 _NC953 NOR4X0
X439 N774 Opa_i[22] N1900 _NC954 _NC955 XOR2X1
X440 N1900 Opa_i[21] N1930 _NC956 _NC957 XOR2X1
X441 N1930 Opa_i[20] N125 _NC958 _NC959 XOR2X1
X442 N1900 N2710 N1510 N1920 _NC960 _NC961 AO21X1
X443 N1920 N1910 N126 _NC962 _NC963 XOR2X1
X444 N1910 N1920 N127 _NC964 _NC965 AND2X1
X445 N134 N2720 N125 Opa_i[19] N139 _NC966 _NC967 AO22X1
X446 N135 N2720 Opa_i[19] N126 N140 _NC968 _NC969 AO22X1
X447 N136 N2720 Opa_i[19] N127 N141 _NC970 _NC971 AO22X1
X448 N137 N2720 N142 _NC972 _NC973 AND2X1
X449 N149 N197 Opa_i[18] N139 N155 _NC974 _NC975 AO22X1
X450 N150 N197 Opa_i[18] N140 N156 _NC976 _NC977 AO22X1
X451 N151 N197 Opa_i[18] N141 N157 _NC978 _NC979 AO22X1
X452 N152 N197 N142 Opa_i[18] N158 _NC980 _NC981 AO22X1
X453 N166 N196 N83 N155 N172 _NC982 _NC983 AO22X1
X454 N167 N196 N83 N156 N173 _NC984 _NC985 AO22X1
X455 N168 N196 N83 N157 N174 _NC986 _NC987 AO22X1
X456 N169 N196 N83 N158 N175 _NC988 _NC989 AO22X1
X457 N170 N196 N83 N159 N176 _NC990 _NC991 AO22X1
X458 N183 N82 Opa_i[16] N172 N189 _NC992 _NC993 AO22X1
X459 N184 N82 Opa_i[16] N173 N190 _NC994 _NC995 AO22X1
X460 N185 N82 Opa_i[16] N174 N191 _NC996 _NC997 AO22X1
X461 N186 N82 Opa_i[16] N175 N192 _NC998 _NC999 AO22X1
X462 N187 N82 Opa_i[16] N176 N193 _NC1000 _NC1001 AO22X1
X463 N188 N82 Opa_i[16] N213 N194 _NC1002 _NC1003 AO22X1
X464 N200 N81 N80 N189 N206 _NC1004 _NC1005 AO22X1
X465 N201 N81 N80 N190 N207 _NC1006 _NC1007 AO22X1
X466 N202 N81 N80 N191 N208 _NC1008 _NC1009 AO22X1
X467 N203 N81 N80 N192 N209 _NC1010 _NC1011 AO22X1
X468 N204 N81 N80 N193 N210 _NC1012 _NC1013 AO22X1
X469 N205 N81 N80 N194 N211 _NC1014 _NC1015 AO22X1
X470 N217 N79 Opa_i[14] N206 N223 _NC1016 _NC1017 AO22X1
X471 N218 N79 Opa_i[14] N207 N224 _NC1018 _NC1019 AO22X1
X472 N219 N79 Opa_i[14] N208 N225 _NC1020 _NC1021 AO22X1
X473 N220 N79 Opa_i[14] N209 N226 _NC1022 _NC1023 AO22X1
X474 N221 N79 Opa_i[14] N210 N227 _NC1024 _NC1025 AO22X1
X475 N222 N79 Opa_i[14] N211 N228 _NC1026 _NC1027 AO22X1
X476 N234 N78 N77 N223 N240 _NC1028 _NC1029 AO22X1
X477 N235 N78 N77 N224 N241 _NC1030 _NC1031 AO22X1
X478 N236 N78 N77 N225 N242 _NC1032 _NC1033 AO22X1
X479 N237 N78 N77 N226 N243 _NC1034 _NC1035 AO22X1
X480 N238 N78 N77 N227 N244 _NC1036 _NC1037 AO22X1
X481 N239 N78 N77 N228 N245 _NC1038 _NC1039 AO22X1
X482 N251 N2730 Opa_i[12] N240 N257 _NC1040 _NC1041 AO22X1
X483 N252 N2730 Opa_i[12] N241 N258 _NC1042 _NC1043 AO22X1
X484 N253 N2730 Opa_i[12] N242 N259 _NC1044 _NC1045 AO22X1
X485 N254 N2730 Opa_i[12] N243 N260 _NC1046 _NC1047 AO22X1
X486 N255 N2730 Opa_i[12] N244 N261 _NC1048 _NC1049 AO22X1
X487 N256 N2730 Opa_i[12] N245 N262 _NC1050 _NC1051 AO22X1
X488 N268 N76 N75 N257 N274 _NC1052 _NC1053 AO22X1
X489 N269 N76 N75 N258 N275 _NC1054 _NC1055 AO22X1
X490 N270 N76 N75 N259 N276 _NC1056 _NC1057 AO22X1
X491 N271 N76 N75 N260 N277 _NC1058 _NC1059 AO22X1
X492 N272 N76 N75 N261 N278 _NC1060 _NC1061 AO22X1
X493 N273 N76 N75 N262 N279 _NC1062 _NC1063 AO22X1
X494 N285 N74 Opa_i[10] N274 N291 _NC1064 _NC1065 AO22X1
X495 N286 N74 Opa_i[10] N275 N292 _NC1066 _NC1067 AO22X1
X496 N287 N74 Opa_i[10] N276 N293 _NC1068 _NC1069 AO22X1
X497 N288 N74 Opa_i[10] N277 N294 _NC1070 _NC1071 AO22X1
X498 N289 N74 Opa_i[10] N278 N295 _NC1072 _NC1073 AO22X1
X499 N290 N74 Opa_i[10] N279 N296 _NC1074 _NC1075 AO22X1
X500 N302 N73 N72 N291 N308 _NC1076 _NC1077 AO22X1
X501 N303 N73 N72 N292 N309 _NC1078 _NC1079 AO22X1
X502 N304 N73 N72 N293 N310 _NC1080 _NC1081 AO22X1
X503 N305 N73 N72 N294 N311 _NC1082 _NC1083 AO22X1
X504 N306 N73 N72 N295 N312 _NC1084 _NC1085 AO22X1
X505 N307 N73 N72 N296 N313 _NC1086 _NC1087 AO22X1
X506 N319 N71 Opa_i[8] N308 N325 _NC1088 _NC1089 AO22X1
X507 N320 N71 Opa_i[8] N309 N326 _NC1090 _NC1091 AO22X1
X508 N321 N71 Opa_i[8] N310 N327 _NC1092 _NC1093 AO22X1
X509 N322 N71 Opa_i[8] N311 N328 _NC1094 _NC1095 AO22X1
X510 N323 N71 Opa_i[8] N312 N329 _NC1096 _NC1097 AO22X1
X511 N324 N71 Opa_i[8] N313 N330 _NC1098 _NC1099 AO22X1
X512 N336 N70 N69 N325 N342 _NC1100 _NC1101 AO22X1
X513 N337 N70 N69 N326 N343 _NC1102 _NC1103 AO22X1
X514 N338 N70 N69 N327 N344 _NC1104 _NC1105 AO22X1
X515 N339 N70 N69 N328 N345 _NC1106 _NC1107 AO22X1
X516 N340 N70 N69 N329 N346 _NC1108 _NC1109 AO22X1
X517 N341 N70 N69 N330 N347 _NC1110 _NC1111 AO22X1
X518 N2700 N68 Opa_i[6] N342 N359 _NC1112 _NC1113 AO22X1
X519 N354 N68 Opa_i[6] N343 N360 _NC1114 _NC1115 AO22X1
X520 N355 N68 Opa_i[6] N344 N361 _NC1116 _NC1117 AO22X1
X521 N356 N68 Opa_i[6] N345 N362 _NC1118 _NC1119 AO22X1
X522 N357 N68 Opa_i[6] N346 N363 _NC1120 _NC1121 AO22X1
X523 N358 N68 Opa_i[6] N347 N364 _NC1122 _NC1123 AO22X1
X524 N370 N67 N66 N359 N376 _NC1124 _NC1125 AO22X1
X525 N371 N67 N66 N360 N377 _NC1126 _NC1127 AO22X1
X526 N372 N67 N66 N361 N378 _NC1128 _NC1129 AO22X1
X527 N373 N67 N66 N362 N379 _NC1130 _NC1131 AO22X1
X528 N374 N67 N66 N363 N380 _NC1132 _NC1133 AO22X1
X529 N375 N67 N66 N364 N381 _NC1134 _NC1135 AO22X1
X530 N387 N65 N64 N376 N393 _NC1136 _NC1137 AO22X1
X531 N388 N65 N64 N377 N394 _NC1138 _NC1139 AO22X1
X532 N389 N65 N64 N378 N395 _NC1140 _NC1141 AO22X1
X533 N390 N65 N64 N379 N396 _NC1142 _NC1143 AO22X1
X534 N391 N65 N64 N380 N397 _NC1144 _NC1145 AO22X1
X535 N392 N65 N64 N381 N398 _NC1146 _NC1147 AO22X1
X536 N404 N63 Opa_i[3] N393 N410 _NC1148 _NC1149 AO22X1
X537 N405 N63 Opa_i[3] N394 N411 _NC1150 _NC1151 AO22X1
X538 N406 N63 Opa_i[3] N395 N412 _NC1152 _NC1153 AO22X1
X539 N407 N63 Opa_i[3] N396 N413 _NC1154 _NC1155 AO22X1
X540 N408 N63 Opa_i[3] N397 N414 _NC1156 _NC1157 AO22X1
X541 N409 N63 Opa_i[3] N398 N415 _NC1158 _NC1159 AO22X1
X542 N421 N62 N61 N410 N427 _NC1160 _NC1161 AO22X1
X543 N422 N62 N61 N411 N428 _NC1162 _NC1163 AO22X1
X544 N423 N62 N61 N412 N429 _NC1164 _NC1165 AO22X1
X545 N424 N62 N61 N413 N430 _NC1166 _NC1167 AO22X1
X546 N425 N62 N61 N414 N431 _NC1168 _NC1169 AO22X1
X547 N426 N62 N61 N415 N432 _NC1170 _NC1171 AO22X1
X548 N438 N60 N59 N427 N444 _NC1172 _NC1173 AO22X1
X549 N439 N60 N59 N428 N445 _NC1174 _NC1175 AO22X1
X550 N440 N60 N59 N429 N446 _NC1176 _NC1177 AO22X1
X551 N441 N60 N59 N430 N447 _NC1178 _NC1179 AO22X1
X552 N442 N60 N59 N431 N448 _NC1180 _NC1181 AO22X1
X553 N443 N60 N59 N432 N449 _NC1182 _NC1183 AO22X1
X554 N105 N66 N110 _NC1184 _NC1185 OR2X1
X555 N60 N2740 N1880 N1870 _NC1186 _NC1187 NAND3X0
X556 S_exp_tem[0] N1870 N799 _NC1188 _NC1189 AND2X1
X557 S_exp_tem[1] N1870 N800 _NC1190 _NC1191 AND2X1
X558 S_exp_tem[2] N1870 N801 _NC1192 _NC1193 AND2X1
X559 S_exp_tem[3] N1870 N802 _NC1194 _NC1195 AND2X1
X560 S_exp_tem[4] N1870 N803 _NC1196 _NC1197 AND2X1
X561 S_exp_tem[5] N1870 N804 _NC1198 _NC1199 AND2X1
X562 S_exp_tem[6] N1870 N805 _NC1200 _NC1201 AND2X1
X563 S_exp_tem[7] N1870 N806 _NC1202 _NC1203 AND2X1
X564 N198 S_fracta1_52_o[0] Fracta_52_o[27] _NC1204 _NC1205 AND2X1
X565 S_fracta1_52_o[1] N198 S_fracta1_52_o[0] N2020 Fracta_52_o[28] _NC1206 _NC1207 AO22X1
X566 S_fracta1_52_o[2] N198 S_fracta1_52_o[1] N2000 Fracta_52_o[29] _NC1208 _NC1209 AO22X1
X567 S_fracta1_52_o[3] N198 S_fracta1_52_o[2] N2000 Fracta_52_o[30] _NC1210 _NC1211 AO22X1
X568 S_fracta1_52_o[4] N198 S_fracta1_52_o[3] N2000 Fracta_52_o[31] _NC1212 _NC1213 AO22X1
X569 S_fracta1_52_o[5] N198 S_fracta1_52_o[4] N2010 Fracta_52_o[32] _NC1214 _NC1215 AO22X1
X570 S_fracta1_52_o[6] N198 S_fracta1_52_o[5] N2010 Fracta_52_o[33] _NC1216 _NC1217 AO22X1
X571 S_fracta1_52_o[7] N198 S_fracta1_52_o[6] N2010 Fracta_52_o[34] _NC1218 _NC1219 AO22X1
X572 S_fracta1_52_o[8] N198 S_fracta1_52_o[7] N2010 Fracta_52_o[35] _NC1220 _NC1221 AO22X1
X573 S_fracta1_52_o[9] N198 S_fracta1_52_o[8] N2010 Fracta_52_o[36] _NC1222 _NC1223 AO22X1
X574 S_fracta1_52_o[10] N198 S_fracta1_52_o[9] N2010 Fracta_52_o[37] _NC1224 _NC1225 AO22X1
X575 S_fracta1_52_o[11] N198 S_fracta1_52_o[10] N2020 Fracta_52_o[38] _NC1226 _NC1227 AO22X1
X576 S_fracta1_52_o[12] N199 S_fracta1_52_o[11] N2020 Fracta_52_o[39] _NC1228 _NC1229 AO22X1
X577 S_fracta1_52_o[13] N199 S_fracta1_52_o[12] N2020 Fracta_52_o[40] _NC1230 _NC1231 AO22X1
X578 S_fracta1_52_o[14] N199 S_fracta1_52_o[13] N2020 Fracta_52_o[41] _NC1232 _NC1233 AO22X1
X579 S_fracta1_52_o[15] N199 S_fracta1_52_o[14] N2020 Fracta_52_o[42] _NC1234 _NC1235 AO22X1
X580 S_fracta1_52_o[16] N199 S_fracta1_52_o[15] N2030 Fracta_52_o[43] _NC1236 _NC1237 AO22X1
X581 S_fracta1_52_o[17] N199 S_fracta1_52_o[16] N2030 Fracta_52_o[44] _NC1238 _NC1239 AO22X1
X582 S_fracta1_52_o[18] N199 S_fracta1_52_o[17] N2030 Fracta_52_o[45] _NC1240 _NC1241 AO22X1
X583 S_fracta1_52_o[19] N199 S_fracta1_52_o[18] N2030 Fracta_52_o[46] _NC1242 _NC1243 AO22X1
X584 S_fracta1_52_o[20] N199 S_fracta1_52_o[19] N2030 Fracta_52_o[47] _NC1244 _NC1245 AO22X1
X585 S_fracta1_52_o[21] N198 S_fracta1_52_o[20] N2030 Fracta_52_o[48] _NC1246 _NC1247 AO22X1
X586 N198 S_fracta1_52_o[22] S_fracta1_52_o[21] N2040 Fracta_52_o[49] _NC1248 _NC1249 AO22X1
X587 N198 S_fracta1_52_o[23] S_fracta1_52_o[22] N2040 Fracta_52_o[50] _NC1250 _NC1251 AO22X1
X588 N2040 S_fracta1_52_o[23] Fracta_52_o[51] _NC1252 _NC1253 AND2X1
X589 N1890 N1370 N2690 N163 _NC1254 _NC1255 OAI21X1
X590 N178 N179 N102 _NC1256 _NC1257 OR2X1
X591 N376 N110 N111 N427 N112 N393 N1830 _NC1258 _NC1259 AO222X1
X592 N1880 N1870 N108 _NC1260 _NC1261 AND2X1
X593 N1850 N1860 N109 _NC1262 _NC1263 AND2X1
X594 N108 N444 N455 N249 N109 N410 N1840 _NC1264 _NC1265 AO222X1
X595 N319 N102 N370 N103 N182 N105 N1750 _NC1266 _NC1267 OA222X1
X596 N180 N181 N97 _NC1268 _NC1269 OR2X1
X597 N100 N285 N302 N101 N177 _NC1270 _NC1271 OA22X1
X598 N2700 N97 N336 N98 N177 N1760 _NC1272 _NC1273 OA221X1
X599 N1750 N1760 N96 N165 _NC1274 _NC1275 AO21X1
X600 N1740 N96 N93 _NC1276 _NC1277 AND2X1
X601 N1720 N1730 N91 _NC1278 _NC1279 AND2X1
X602 N223 N91 N240 N92 N1670 _NC1280 _NC1281 AOI22X1
X603 N1700 N1710 N90 _NC1282 _NC1283 AND2X1
X604 N172 N89 N189 N90 N1690 _NC1284 _NC1285 AO22X1
X605 N115 N155 N206 N88 N1690 N1680 _NC1286 _NC1287 AOI221X1
X606 N165 N1660 N1670 N1680 N164 _NC1288 _NC1289 NAND4X0
X607 N163 N2440 N250 N164 S_sqr_zeros_o[0] _NC1290 _NC1291 AO22X1
X608 N377 N110 N111 N428 N112 N394 N161 _NC1292 _NC1293 AO222X1
X609 N108 N445 N456 N249 N109 N411 N162 _NC1294 _NC1295 AO222X1
X610 N266 N102 N263 N103 N160 N105 N1570 _NC1296 _NC1297 OA222X1
X611 N100 N2680 N267 N101 N1590 _NC1298 _NC1299 OA22X1
X612 N264 N97 N265 N98 N1590 N1580 _NC1300 _NC1301 OA221X1
X613 N1570 N1580 N96 N1520 _NC1302 _NC1303 AO21X1
X614 N224 N91 N241 N92 N154 _NC1304 _NC1305 AOI22X1
X615 N173 N89 N190 N90 N1560 _NC1306 _NC1307 AO22X1
X616 N115 N156 N207 N88 N1560 N1550 _NC1308 _NC1309 AOI221X1
X617 N1520 N1530 N154 N1550 N1500 _NC1310 _NC1311 NAND4X0
X618 N250 N1500 N1510 N126 S_sqr_zeros_o[1] _NC1312 _NC1313 AO22X1
X619 N378 N110 N111 N429 N112 N395 N148 _NC1314 _NC1315 AO222X1
X620 N108 N446 N457 N249 N109 N412 N1490 _NC1316 _NC1317 AO222X1
X621 N2600 N102 N2570 N103 N147 N105 N144 _NC1318 _NC1319 OA222X1
X622 N100 N2620 N2610 N101 N146 _NC1320 _NC1321 OA22X1
X623 N2580 N97 N2590 N98 N146 N145 _NC1322 _NC1323 OA221X1
X624 N144 N145 N96 N1390 _NC1324 _NC1325 AO21X1
X625 N225 N91 N242 N92 N1410 _NC1326 _NC1327 AOI22X1
X626 N174 N89 N191 N90 N143 _NC1328 _NC1329 AO22X1
X627 N115 N157 N208 N88 N143 N1420 _NC1330 _NC1331 AOI221X1
X628 N1390 N1400 N1410 N1420 N1360 _NC1332 _NC1333 NAND4X0
X629 N250 N1360 N1370 N138 S_sqr_zeros_o[2] _NC1334 _NC1335 AO22X1
X630 N379 N110 N111 N430 N112 N396 N1340 _NC1336 _NC1337 AO222X1
X631 N108 N447 N458 N249 N109 N413 N1350 _NC1338 _NC1339 AO222X1
X632 N2540 N102 N2510 N103 N133 N105 N130 _NC1340 _NC1341 OA222X1
X633 N100 N2560 N2550 N101 N132 _NC1342 _NC1343 OA22X1
X634 N2520 N97 N2530 N98 N132 N131 _NC1344 _NC1345 OA221X1
X635 N92 N243 N91 N226 N129 _NC1346 _NC1347 AO22X1
X636 N93 N260 N248 N128 N129 N1250 _NC1348 _NC1349 AO221X1
X637 N90 N192 N89 N175 N1270 _NC1350 _NC1351 AO22X1
X638 N88 N209 N158 N115 N1270 N1260 _NC1352 _NC1353 AO221X1
X639 N380 N110 N111 N431 N112 N397 N123 _NC1354 _NC1355 AO222X1
X640 N108 N448 N459 N249 N109 N414 N124 _NC1356 _NC1357 AO222X1
X641 N2180 N102 N215 N103 N122 N105 N119 _NC1358 _NC1359 OA222X1
X642 N100 N2200 N2190 N101 N121 _NC1360 _NC1361 OA22X1
X643 N216 N97 N2170 N98 N121 N120 _NC1362 _NC1363 OA221X1
X644 N92 N244 N91 N227 N118 _NC1364 _NC1365 AO22X1
X645 N93 N261 N248 N117 N118 N113 _NC1366 _NC1367 AO221X1
X646 N90 N193 N89 N176 N116 _NC1368 _NC1369 AO22X1
X647 N88 N210 N159 N115 N116 N114 _NC1370 _NC1371 AO221X1
X648 N381 N110 N111 N432 N112 N398 N106 _NC1372 _NC1373 AO222X1
X649 N108 N449 N460 N249 N109 N415 N107 _NC1374 _NC1375 AO222X1
X650 N2100 N102 N2070 N103 N104 N105 N94 _NC1376 _NC1377 OA222X1
X651 N100 N212 N2110 N101 N99 _NC1378 _NC1379 OA22X1
X652 N2080 N97 N2090 N98 N99 N95 _NC1380 _NC1381 OA221X1
X653 N94 N95 N96 N84 _NC1382 _NC1383 AO21X1
X654 N228 N91 N245 N92 N86 _NC1384 _NC1385 AOI22X1
X655 N211 N88 N213 N89 N194 N90 N87 _NC1386 _NC1387 AOI222X1
X656 N84 N85 N86 N87 S_sqr_zeros_o[5] _NC1388 _NC1389 NAND4X0
X657 Clk_i N799 Exp_o[0] _NC1390 _NC1391 _NC1392 DFFX1
X658 Clk_i N800 Exp_o[1] _NC1393 _NC1394 _NC1395 DFFX1
X659 Clk_i N801 Exp_o[2] _NC1396 _NC1397 _NC1398 DFFX1
X660 Clk_i N802 Exp_o[3] _NC1399 _NC1400 _NC1401 DFFX1
X661 Clk_i N803 Exp_o[4] _NC1402 _NC1403 _NC1404 DFFX1
X662 Clk_i N804 Exp_o[5] _NC1405 _NC1406 _NC1407 DFFX1
X663 Clk_i N805 Exp_o[6] _NC1408 _NC1409 _NC1410 DFFX1
X664 Clk_i N806 Exp_o[7] _NC1411 _NC1412 _NC1413 DFFX1
.ENDS pre_norm_sqrt

.SUBCKT pre_norm_sqrt_DW01_sub_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] CO
X0 B[0] N5 Carry[0] _NC0 _NC1 NAND2X0
X1 A[0] _NC2 _NC3 N5 INVX0
X2 N1 A[7] DIFF[7] _NC4 _NC5 XOR2X1
X3 N3 A[6] DIFF[6] _NC6 _NC7 XOR2X1
X4 B[5] _NC8 _NC9 N6 INVX0
X5 B[4] _NC10 _NC11 N7 INVX0
X6 B[3] _NC12 _NC13 N10 INVX0
X7 B[2] _NC14 _NC15 N9 INVX0
X8 B[1] _NC16 _NC17 N8 INVX0
X9 Carry[7] A[8] DIFF[8] _NC18 _NC19 XNOR2X1
X10 Carry[5] _NC20 _NC21 N3 INVX0
X11 N2 N3 N1 _NC22 _NC23 AND2X1
X12 A[7] _NC24 _NC25 N4 INVX0
X13 N4 N1 Carry[7] _NC26 _NC27 NAND2X1
X14 A[6] _NC28 _NC29 N2 INVX0
X15 A[1] N8 Carry[0] Carry[1] DIFF[1] _NC30 _NC31 FADDX1
X16 A[2] N9 Carry[1] Carry[2] DIFF[2] _NC32 _NC33 FADDX1
X17 A[3] N10 Carry[2] Carry[3] DIFF[3] _NC34 _NC35 FADDX1
X18 A[4] N7 Carry[3] Carry[4] DIFF[4] _NC36 _NC37 FADDX1
X19 A[5] N6 Carry[4] Carry[5] DIFF[5] _NC38 _NC39 FADDX1
.ENDS pre_norm_sqrt_DW01_sub_0

.SUBCKT post_norm_div Clk_i Opa_i[0] Opa_i[1] Opa_i[2] Opa_i[3] Opa_i[4] Opa_i[5] Opa_i[6] Opa_i[7] Opa_i[8] Opa_i[9] Opa_i[10] Opa_i[11] Opa_i[12] Opa_i[13] Opa_i[14] Opa_i[15] Opa_i[16] Opa_i[17] Opa_i[18] Opa_i[19] Opa_i[20] Opa_i[21] Opa_i[22] Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Opa_i[31] Opb_i[0] Opb_i[1] Opb_i[2] Opb_i[3] Opb_i[4] Opb_i[5] Opb_i[6] Opb_i[7] Opb_i[8] Opb_i[9] Opb_i[10] Opb_i[11] Opb_i[12] Opb_i[13] Opb_i[14] Opb_i[15] Opb_i[16] Opb_i[17] Opb_i[18] Opb_i[19] Opb_i[20] Opb_i[21] Opb_i[22] Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Opb_i[31] Qutnt_i[0] Qutnt_i[1] Qutnt_i[2] Qutnt_i[3] Qutnt_i[4] Qutnt_i[5] Qutnt_i[6] Qutnt_i[7] Qutnt_i[8] Qutnt_i[9] Qutnt_i[10] Qutnt_i[11] Qutnt_i[12] Qutnt_i[13] Qutnt_i[14] Qutnt_i[15] Qutnt_i[16] Qutnt_i[17] Qutnt_i[18] Qutnt_i[19] Qutnt_i[20] Qutnt_i[21] Qutnt_i[22] Qutnt_i[23] Qutnt_i[24] Qutnt_i[25] Qutnt_i[26] Rmndr_i[0] Rmndr_i[1] Rmndr_i[2] Rmndr_i[3] Rmndr_i[4] Rmndr_i[5] Rmndr_i[6] Rmndr_i[7] Rmndr_i[8] Rmndr_i[9] Rmndr_i[10] Rmndr_i[11] Rmndr_i[12] Rmndr_i[13] Rmndr_i[14] Rmndr_i[15] Rmndr_i[16] Rmndr_i[17] Rmndr_i[18] Rmndr_i[19] Rmndr_i[20] Rmndr_i[21] Rmndr_i[22] Rmndr_i[23] Rmndr_i[24] Rmndr_i[25] Rmndr_i[26] Exp_10_i[0] Exp_10_i[1] Exp_10_i[2] Exp_10_i[3] Exp_10_i[4] Exp_10_i[5] Exp_10_i[6] Exp_10_i[7] Exp_10_i[8] Exp_10_i[9] Sign_i Rmode_i[0] Rmode_i[1] Output_o[0] Output_o[1] Output_o[2] Output_o[3] Output_o[4] Output_o[5] Output_o[6] Output_o[7] Output_o[8] Output_o[9] Output_o[10] Output_o[11] Output_o[12] Output_o[13] Output_o[14] Output_o[15] Output_o[16] Output_o[17] Output_o[18] Output_o[19] Output_o[20] Output_o[21] Output_o[22] Output_o[23] Output_o[24] Output_o[25] Output_o[26] Output_o[27] Output_o[28] Output_o[29] Output_o[30] Output_o[31] Ine_o
X0 S_qutnt_i[9] S_qutnt_i[8] N220 N27 _NC0 _NC1 MUX21X1
X1 S_qutnt_i[8] S_qutnt_i[7] N219 N27 _NC2 _NC3 MUX21X1
X2 S_qutnt_i[7] S_qutnt_i[6] N218 N27 _NC4 _NC5 MUX21X1
X3 S_qutnt_i[6] S_qutnt_i[5] N217 N27 _NC6 _NC7 MUX21X1
X4 S_qutnt_i[5] S_qutnt_i[4] N216 N27 _NC8 _NC9 MUX21X1
X5 S_qutnt_i[4] S_qutnt_i[3] N215 N27 _NC10 _NC11 MUX21X1
X6 S_qutnt_i[3] S_qutnt_i[2] N214 N27 _NC12 _NC13 MUX21X1
X7 S_qutnt_i[2] S_qutnt_i[1] N213 N27 _NC14 _NC15 MUX21X1
X8 S_qutnt_i[26] S_qutnt_i[25] N237 N27 _NC16 _NC17 MUX21X1
X9 S_qutnt_i[25] S_qutnt_i[24] N236 N26 _NC18 _NC19 MUX21X1
X10 S_qutnt_i[24] S_qutnt_i[23] N235 N26 _NC20 _NC21 MUX21X1
X11 S_qutnt_i[23] S_qutnt_i[22] N234 N26 _NC22 _NC23 MUX21X1
X12 S_qutnt_i[22] S_qutnt_i[21] N233 N26 _NC24 _NC25 MUX21X1
X13 S_qutnt_i[21] S_qutnt_i[20] N232 N26 _NC26 _NC27 MUX21X1
X14 S_qutnt_i[20] S_qutnt_i[19] N231 N26 _NC28 _NC29 MUX21X1
X15 S_qutnt_i[1] S_qutnt_i[0] N212 N26 _NC30 _NC31 MUX21X1
X16 S_qutnt_i[19] S_qutnt_i[18] N230 N26 _NC32 _NC33 MUX21X1
X17 S_qutnt_i[18] S_qutnt_i[17] N229 N26 _NC34 _NC35 MUX21X1
X18 S_qutnt_i[17] S_qutnt_i[16] N228 N26 _NC36 _NC37 MUX21X1
X19 S_qutnt_i[16] S_qutnt_i[15] N227 N26 _NC38 _NC39 MUX21X1
X20 S_qutnt_i[15] S_qutnt_i[14] N226 N26 _NC40 _NC41 MUX21X1
X21 S_qutnt_i[14] S_qutnt_i[13] N225 N26 _NC42 _NC43 MUX21X1
X22 S_qutnt_i[13] S_qutnt_i[12] N224 N26 _NC44 _NC45 MUX21X1
X23 S_qutnt_i[12] S_qutnt_i[11] N223 N26 _NC46 _NC47 MUX21X1
X24 S_qutnt_i[11] S_qutnt_i[10] N222 N26 _NC48 _NC49 MUX21X1
X25 S_qutnt_i[10] S_qutnt_i[9] N221 N26 _NC50 _NC51 MUX21X1
X26 N451 N450 N452 N28 _NC52 _NC53 MUX21X1
X27 N4490 N4480 N451 N3 _NC54 _NC55 MUX21X1
X28 N4460 N4450 N4470 N28 _NC56 _NC57 MUX21X1
X29 N4440 N4430 N4460 N3 _NC58 _NC59 MUX21X1
X30 N4410 N4400 N4420 N28 _NC60 _NC61 MUX21X1
X31 N85 N4390 N4410 N3 _NC62 _NC63 MUX21X1
X32 N4380 N437 N4390 N2 _NC64 _NC65 MUX21X1
X33 N435 N434 N436 N28 _NC66 _NC67 MUX21X1
X34 N433 N4320 N435 N3 _NC68 _NC69 MUX21X1
X35 N4310 N4300 N4320 N2 _NC70 _NC71 MUX21X1
X36 N4280 N4270 N4290 N28 _NC72 _NC73 MUX21X1
X37 N4260 N4250 N4280 N3 _NC74 _NC75 MUX21X1
X38 N4240 N3210 N4250 N2 _NC76 _NC77 MUX21X1
X39 N4210 N420 N4220 N28 _NC78 _NC79 MUX21X1
X40 N419 N418 N4210 N3 _NC80 _NC81 MUX21X1
X41 N417 N3250 N418 N2 _NC82 _NC83 MUX21X1
X42 N4140 N4130 N4150 N28 _NC84 _NC85 MUX21X1
X43 N4120 N4110 N4140 N3 _NC86 _NC87 MUX21X1
X44 N437 N3270 N4110 N2 _NC88 _NC89 MUX21X1
X45 N4090 N4080 N4100 N18 _NC90 _NC91 MUX21X1
X46 N4070 N3220 N437 N18 _NC92 _NC93 MUX21X1
X47 N4040 N403 N4050 N28 _NC94 _NC95 MUX21X1
X48 N402 N401 N4040 N3 _NC96 _NC97 MUX21X1
X49 N4300 N3280 N401 N2 _NC98 _NC99 MUX21X1
X50 N399 N3980 N400 N18 _NC100 _NC101 MUX21X1
X51 N3970 N3260 N4300 N18 _NC102 _NC103 MUX21X1
X52 N3950 N30 N29 N210 _NC104 _NC105 NOR3X0
X53 N450 N31 N29 N209 _NC106 _NC107 NOR3X0
X54 N29 N31 N4450 N208 _NC108 _NC109 NOR3X0
X55 N3930 S_shr1[3] N4450 _NC110 _NC111 OR2X1
X56 N29 N31 N4400 N207 _NC112 _NC113 NOR3X0
X57 N3920 S_shr1[3] N4400 _NC114 _NC115 OR2X1
X58 N29 N31 N434 N206 _NC116 _NC117 NOR3X0
X59 N3910 S_shr1[3] N434 _NC118 _NC119 OR2X1
X60 N4270 N31 N29 N205 _NC120 _NC121 NOR3X0
X61 N3900 S_shr1[3] N4270 _NC122 _NC123 OR2X1
X62 N420 N31 N29 N204 _NC124 _NC125 NOR3X0
X63 N3890 S_shr1[3] N420 _NC126 _NC127 OR2X1
X64 N3870 N386 N3880 N28 _NC128 _NC129 MUX21X1
X65 N4480 N3200 N3870 N3 _NC130 _NC131 MUX21X1
X66 N4230 N384 N385 N2 _NC132 _NC133 MUX21X1
X67 N4080 N383 N384 N18 _NC134 _NC135 MUX21X1
X68 S_qutnt_i[2] S_qutnt_i[1] N383 N20 _NC136 _NC137 MUX21X1
X69 S_qutnt_i[4] S_qutnt_i[3] N4080 N20 _NC138 _NC139 MUX21X1
X70 N4060 N4090 N4230 N18 _NC140 _NC141 MUX21X1
X71 S_qutnt_i[6] S_qutnt_i[5] N4090 N20 _NC142 _NC143 MUX21X1
X72 S_qutnt_i[8] S_qutnt_i[7] N4060 N20 _NC144 _NC145 MUX21X1
X73 N316 N4240 N4480 N2 _NC146 _NC147 MUX21X1
X74 N382 N4070 N4240 N18 _NC148 _NC149 MUX21X1
X75 N100 N101 N4070 N20 _NC150 _NC151 MUX21X1
X76 N4130 N31 N29 N203 _NC152 _NC153 NOR3X0
X77 N29 N31 N403 N202 _NC154 _NC155 NOR3X0
X78 N78 N3800 N403 N3 _NC156 _NC157 MUX21X1
X79 N386 N31 N29 N201 _NC158 _NC159 NOR3X0
X80 N81 N4490 N386 N3 _NC160 _NC161 MUX21X1
X81 N83 N92 N4490 N2 _NC162 _NC163 MUX21X1
X82 N3770 N31 N29 N200 _NC164 _NC165 NOR3X0
X83 N3760 N31 N29 N199 _NC166 _NC167 NOR3X0
X84 N3920 N85 N3760 N3 _NC168 _NC169 MUX21X1
X85 N3740 N3730 N3750 N2 _NC170 _NC171 MUX21X1
X86 N3710 N31 N29 N198 _NC172 _NC173 NOR3X0
X87 N3910 N433 N3710 N3 _NC174 _NC175 MUX21X1
X88 N3700 N369 N433 N2 _NC176 _NC177 MUX21X1
X89 N368 N367 N3910 N2 _NC178 _NC179 MUX21X1
X90 N29 N31 N366 N197 _NC180 _NC181 NOR3X0
X91 N3900 N4260 N366 N3 _NC182 _NC183 MUX21X1
X92 N92 N316 N4260 N2 _NC184 _NC185 MUX21X1
X93 N3640 N3630 N365 N18 _NC186 _NC187 MUX21X1
X94 N3610 N3600 N3620 N18 _NC188 _NC189 MUX21X1
X95 N3780 N83 N3900 N2 _NC190 _NC191 MUX21X1
X96 N3580 N3570 N3590 N18 _NC192 _NC193 MUX21X1
X97 N29 N31 N3550 N196 _NC194 _NC195 NOR3X0
X98 N3890 N419 N3550 N3 _NC196 _NC197 MUX21X1
X99 N3540 N3530 N419 N2 _NC198 _NC199 MUX21X1
X100 N352 N351 N3890 N2 _NC200 _NC201 MUX21X1
X101 N29 N30 N350 N195 _NC202 _NC203 NOR3X0
X102 N80 N4120 N350 N3 _NC204 _NC205 MUX21X1
X103 N120 N4380 N4120 N2 _NC206 _NC207 MUX21X1
X104 N318 N382 N4380 N18 _NC208 _NC209 MUX21X1
X105 N98 N99 N382 N20 _NC210 _NC211 MUX21X1
X106 S_qutnt_i[14] S_qutnt_i[13] N3630 N20 _NC212 _NC213 MUX21X1
X107 N3600 N3640 N3730 N18 _NC214 _NC215 MUX21X1
X108 S_qutnt_i[16] S_qutnt_i[15] N3640 N20 _NC216 _NC217 MUX21X1
X109 S_qutnt_i[18] S_qutnt_i[17] N3600 N20 _NC218 _NC219 MUX21X1
X110 N3720 N3740 N3810 N2 _NC220 _NC221 MUX21X1
X111 N3570 N3610 N3740 N18 _NC222 _NC223 MUX21X1
X112 S_qutnt_i[20] S_qutnt_i[19] N3610 N20 _NC224 _NC225 MUX21X1
X113 S_qutnt_i[22] S_qutnt_i[21] N3570 N20 _NC226 _NC227 MUX21X1
X114 N3560 N3580 N3720 N18 _NC228 _NC229 MUX21X1
X115 S_qutnt_i[24] S_qutnt_i[23] N3580 N20 _NC230 _NC231 MUX21X1
X116 S_qutnt_i[26] S_qutnt_i[25] N3560 N20 _NC232 _NC233 MUX21X1
X117 N348 N3950 N349 N28 _NC234 _NC235 MUX21X1
X118 N347 S_shr1[1] N368 _NC236 _NC237 OR2X1
X119 N3800 N402 N348 N3 _NC238 _NC239 MUX21X1
X120 N369 N4310 N402 N2 _NC240 _NC241 MUX21X1
X121 N3190 N3460 N4310 N18 _NC242 _NC243 MUX21X1
X122 N315 N317 N369 N18 _NC244 _NC245 MUX21X1
X123 N367 N3700 N3800 N2 _NC246 _NC247 MUX21X1
X124 N87 N111 N3700 N19 _NC248 _NC249 MUX21X1
X125 N82 N84 N367 N19 _NC250 _NC251 MUX21X1
X126 N3440 N3770 N3450 N28 _NC252 _NC253 MUX21X1
X127 N3930 N4440 N3770 N3 _NC254 _NC255 MUX21X1
X128 N351 N3540 N4440 N2 _NC256 _NC257 MUX21X1
X129 N111 N315 N3540 N19 _NC258 _NC259 MUX21X1
X130 S_qutnt_i[17] S_qutnt_i[16] N3430 N20 _NC260 _NC261 MUX21X1
X131 S_qutnt_i[19] S_qutnt_i[18] N3420 N20 _NC262 _NC263 MUX21X1
X132 N84 N87 N351 N19 _NC264 _NC265 MUX21X1
X133 S_qutnt_i[21] S_qutnt_i[20] N3410 N20 _NC266 _NC267 MUX21X1
X134 S_qutnt_i[23] S_qutnt_i[22] N3400 N21 _NC268 _NC269 MUX21X1
X135 N352 S_shr1[2] N3930 _NC270 _NC271 OR2X1
X136 N347 N82 N352 N19 _NC272 _NC273 MUX21X1
X137 S_qutnt_i[25] S_qutnt_i[24] N3390 N21 _NC274 _NC275 MUX21X1
X138 N324 N4430 N3440 S_shr1[3] _NC276 _NC277 MUX21X1
X139 N3530 N417 N4430 N2 _NC278 _NC279 MUX21X1
X140 N3460 N3970 N417 N19 _NC280 _NC281 MUX21X1
X141 N101 N103 N3970 N21 _NC282 _NC283 MUX21X1
X142 N99 N100 N3460 N21 _NC284 _NC285 MUX21X1
X143 N317 N3190 N3530 N19 _NC286 _NC287 MUX21X1
X144 S_qutnt_i[13] S_qutnt_i[12] N3380 N21 _NC288 _NC289 MUX21X1
X145 S_qutnt_i[15] S_qutnt_i[14] N3370 N21 _NC290 _NC291 MUX21X1
X146 N335 N416 N3360 S_shr1[2] _NC292 _NC293 MUX21X1
X147 N3960 N399 N416 N19 _NC294 _NC295 MUX21X1
X148 S_qutnt_i[5] S_qutnt_i[4] N399 N21 _NC296 _NC297 MUX21X1
X149 S_qutnt_i[7] S_qutnt_i[6] N3960 N21 _NC298 _NC299 MUX21X1
X150 N3980 N334 N335 N19 _NC300 _NC301 MUX21X1
X151 S_qutnt_i[1] S_qutnt_i[0] N334 N21 _NC302 _NC303 MUX21X1
X152 S_qutnt_i[3] S_qutnt_i[2] N3980 N21 _NC304 _NC305 MUX21X1
X153 N323 N106 N329 _NC306 _NC307 AND2X1
X154 N51 N50 N49 N48 N1025 _NC308 _NC309 AO22X1
X155 N1023 N7 N50 N48 _NC310 _NC311 OA21X1
X156 N47 N40 N39 N49 _NC312 _NC313 OA21X1
X157 N1020 N10 N38 N1019 N40 N39 _NC314 _NC315 AO221X1
X158 S_r_zeros[0] N37 N38 _NC316 _NC317 NOR2X0
X159 N1020 N10 N37 _NC318 _NC319 NOR2X0
X160 N1022 N9 N36 N1021 N40 _NC320 _NC321 AO22X1
X161 S_r_zeros[2] N35 N36 _NC322 _NC323 NOR2X0
X162 N52 S_r_zeros[2] N35 N47 _NC324 _NC325 AOI21X1
X163 N9 N1022 N35 _NC326 _NC327 NOR2X0
X164 N8 N1024 N50 _NC328 _NC329 OR2X1
X165 N1024 N8 N1023 N7 N51 _NC330 _NC331 AO22X1
X166 Add_105_I27_L07002_C191_carry[3] N670 N681 _NC332 _NC333 XOR2X1
X167 N665 _NC334 _NC335 N676 INVX0
X168 Add_105_I26_L07002_C191_carry[3] N653 N664 _NC336 _NC337 XOR2X1
X169 N648 _NC338 _NC339 N659 INVX0
X170 Add_105_I25_L07002_C191_carry[3] N636 N647 _NC340 _NC341 XOR2X1
X171 N631 _NC342 _NC343 N642 INVX0
X172 Add_105_I24_L07002_C191_carry[3] N619 N630 _NC344 _NC345 XOR2X1
X173 N614 _NC346 _NC347 N625 INVX0
X174 Add_105_I23_L07002_C191_carry[3] N602 N613 _NC348 _NC349 XOR2X1
X175 N597 _NC350 _NC351 N608 INVX0
X176 Add_105_I22_L07002_C191_carry[3] N585 N596 _NC352 _NC353 XOR2X1
X177 Add_105_I21_L07002_C191_carry[3] N568 N579 _NC354 _NC355 XOR2X1
X178 N563 _NC356 _NC357 N574 INVX0
X179 Add_105_I20_L07002_C191_carry[3] N551 N562 _NC358 _NC359 XOR2X1
X180 N546 _NC360 _NC361 N557 INVX0
X181 Add_105_I19_L07002_C191_carry[3] N534 N545 _NC362 _NC363 XOR2X1
X182 N529 _NC364 _NC365 N540 INVX0
X183 Add_105_I18_L07002_C191_carry[3] N517 N528 _NC366 _NC367 XOR2X1
X184 N512 _NC368 _NC369 N523 INVX0
X185 Add_105_I17_L07002_C191_carry[3] N500 N511 _NC370 _NC371 XOR2X1
X186 N495 _NC372 _NC373 N506 INVX0
X187 Add_105_I16_L07002_C191_carry[3] N483 N494 _NC374 _NC375 XOR2X1
X188 N478 _NC376 _NC377 N489 INVX0
X189 Add_105_I15_L07002_C191_carry[3] N466 N477 _NC378 _NC379 XOR2X1
X190 N461 _NC380 _NC381 N472 INVX0
X191 Add_105_I14_L07002_C191_carry[3] N449 N460 _NC382 _NC383 XOR2X1
X192 N444 _NC384 _NC385 N455 INVX0
X193 Add_105_I13_L07002_C191_carry[3] N432 N443 _NC386 _NC387 XOR2X1
X194 N427 _NC388 _NC389 N438 INVX0
X195 Add_105_I12_L07002_C191_carry[3] N415 N426 _NC390 _NC391 XOR2X1
X196 N410 _NC392 _NC393 N421 INVX0
X197 Add_105_I11_L07002_C191_carry[3] N398 N409 _NC394 _NC395 XOR2X1
X198 N393 _NC396 _NC397 N404 INVX0
X199 Add_105_I10_L07002_C191_carry[3] N381 N392 _NC398 _NC399 XOR2X1
X200 N376 _NC400 _NC401 N387 INVX0
X201 Add_105_I9_L07002_C191_carry[3] N364 N375 _NC402 _NC403 XOR2X1
X202 N359 _NC404 _NC405 N370 INVX0
X203 N342 _NC406 _NC407 N353 INVX0
X204 N325 _NC408 _NC409 N336 INVX0
X205 N309 _NC410 _NC411 N319 INVX0
X206 N295 _NC412 _NC413 N304 INVX0
X207 S_exp_10_i[0] S_qutnt_i[26] Sub_141_carry[0] _NC414 _NC415 OR2X1
X208 Sub_141_carry[0] S_exp_10_i[1] S_exp_10b[0] _NC416 _NC417 XNOR2X1
X209 S_exp_10_i[1] Sub_141_carry[0] Sub_141_carry[1] _NC418 _NC419 OR2X1
X210 Sub_141_carry[1] S_exp_10_i[2] S_exp_10b[1] _NC420 _NC421 XNOR2X1
X211 S_exp_10_i[2] Sub_141_carry[1] Sub_141_carry[2] _NC422 _NC423 OR2X1
X212 Sub_141_carry[2] S_exp_10_i[3] S_exp_10b[2] _NC424 _NC425 XNOR2X1
X213 S_exp_10_i[3] Sub_141_carry[2] Sub_141_carry[3] _NC426 _NC427 OR2X1
X214 Sub_141_carry[3] S_exp_10_i[4] S_exp_10b[3] _NC428 _NC429 XNOR2X1
X215 S_exp_10_i[4] Sub_141_carry[3] Sub_141_carry[4] _NC430 _NC431 OR2X1
X216 Sub_141_carry[4] S_exp_10_i[5] S_exp_10b[4] _NC432 _NC433 XNOR2X1
X217 S_exp_10_i[5] Sub_141_carry[4] Sub_141_carry[5] _NC434 _NC435 OR2X1
X218 Sub_141_carry[5] S_exp_10_i[6] S_exp_10b[5] _NC436 _NC437 XNOR2X1
X219 S_exp_10_i[6] Sub_141_carry[5] Sub_141_carry[6] _NC438 _NC439 OR2X1
X220 Sub_141_carry[6] S_exp_10_i[7] S_exp_10b[6] _NC440 _NC441 XNOR2X1
X221 S_exp_10_i[7] Sub_141_carry[6] Sub_141_carry[7] _NC442 _NC443 OR2X1
X222 Sub_141_carry[7] S_exp_10_i[8] S_exp_10b[7] _NC444 _NC445 XNOR2X1
X223 S_exp_10_i[8] Sub_141_carry[7] Sub_141_carry[8] _NC446 _NC447 OR2X1
X224 S_exp_10_i[9] Sub_141_carry[8] S_exp_10b[8] _NC448 _NC449 XNOR2X1
X225 S_qutnt_i[26] N1 N145 _NC450 _NC451 XNOR2X1
X226 N1 S_qutnt_i[26] Sub_1_root_sub_150_2_carry[0] _NC452 _NC453 OR2X1
X227 N32 Sub_1_root_sub_150_2_carry[0] N146 _NC454 _NC455 XOR2X1
X228 Sub_1_root_sub_150_2_carry[0] N32 Sub_1_root_sub_150_2_carry[1] _NC456 _NC457 AND2X1
X229 N58 Sub_1_root_sub_150_2_carry[1] N147 _NC458 _NC459 XOR2X1
X230 Sub_1_root_sub_150_2_carry[1] N58 Sub_1_root_sub_150_2_carry[2] _NC460 _NC461 AND2X1
X231 N57 Sub_1_root_sub_150_2_carry[2] N148 _NC462 _NC463 XOR2X1
X232 Sub_1_root_sub_150_2_carry[2] N57 Sub_1_root_sub_150_2_carry[3] _NC464 _NC465 AND2X1
X233 N33 Sub_1_root_sub_150_2_carry[3] N149 _NC466 _NC467 XOR2X1
X234 Sub_1_root_sub_150_2_carry[3] N33 Sub_1_root_sub_150_2_carry[4] _NC468 _NC469 AND2X1
X235 N34 Sub_1_root_sub_150_2_carry[4] N150 _NC470 _NC471 XOR2X1
X236 S_fraco1[26] S_expo1[0] S_expo2[0] _NC472 _NC473 XNOR2X1
X237 S_expo1[0] S_fraco1[26] Sub_188_aco_carry[0] _NC474 _NC475 OR2X1
X238 Sub_188_aco_carry[0] S_expo1[1] S_expo2[1] _NC476 _NC477 XNOR2X1
X239 S_expo1[1] Sub_188_aco_carry[0] Sub_188_aco_carry[1] _NC478 _NC479 OR2X1
X240 Sub_188_aco_carry[1] S_expo1[2] S_expo2[2] _NC480 _NC481 XNOR2X1
X241 S_expo1[2] Sub_188_aco_carry[1] Sub_188_aco_carry[2] _NC482 _NC483 OR2X1
X242 Sub_188_aco_carry[2] S_expo1[3] S_expo2[3] _NC484 _NC485 XNOR2X1
X243 S_expo1[3] Sub_188_aco_carry[2] Sub_188_aco_carry[3] _NC486 _NC487 OR2X1
X244 Sub_188_aco_carry[3] S_expo1[4] S_expo2[4] _NC488 _NC489 XNOR2X1
X245 S_expo1[4] Sub_188_aco_carry[3] Sub_188_aco_carry[4] _NC490 _NC491 OR2X1
X246 Sub_188_aco_carry[4] S_expo1[5] S_expo2[5] _NC492 _NC493 XNOR2X1
X247 S_expo1[5] Sub_188_aco_carry[4] Sub_188_aco_carry[5] _NC494 _NC495 OR2X1
X248 Sub_188_aco_carry[5] S_expo1[6] S_expo2[6] _NC496 _NC497 XNOR2X1
X249 S_expo1[6] Sub_188_aco_carry[5] Sub_188_aco_carry[6] _NC498 _NC499 OR2X1
X250 Sub_188_aco_carry[6] S_expo1[7] S_expo2[7] _NC500 _NC501 XNOR2X1
X251 S_expo1[7] Sub_188_aco_carry[6] Sub_188_aco_carry[7] _NC502 _NC503 OR2X1
X252 S_expo1[8] Sub_188_aco_carry[7] S_expo2[8] _NC504 _NC505 XNOR2X1
X253 S_shr1[0] N17 N1019 _NC506 _NC507 XOR2X1
X254 N331 S_shr1[0] Add_194_carry[0] _NC508 _NC509 AND2X1
X255 S_shr1[1] Add_194_carry[0] N1020 _NC510 _NC511 XOR2X1
X256 Add_194_carry[0] S_shr1[1] Add_194_carry[1] _NC512 _NC513 AND2X1
X257 S_shr1[2] Add_194_carry[1] N1021 _NC514 _NC515 XOR2X1
X258 Add_194_carry[1] S_shr1[2] Add_194_carry[2] _NC516 _NC517 AND2X1
X259 S_shr1[3] Add_194_carry[2] N1022 _NC518 _NC519 XOR2X1
X260 Add_194_carry[2] S_shr1[3] Add_194_carry[3] _NC520 _NC521 AND2X1
X261 N28 Add_194_carry[3] N1023 _NC522 _NC523 XOR2X1
X262 Add_194_carry[3] S_shr1[4] Add_194_carry[4] _NC524 _NC525 AND2X1
X263 N30 Add_194_carry[4] N1024 _NC526 _NC527 XOR2X1
X264 N25 _NC528 _NC529 N23 INVX0
X265 S_shr1[4] _NC530 _NC531 N28 NBUFFX4
X266 S_shl1[0] _NC532 _NC533 N26 NBUFFX4
X267 N6 _NC534 _NC535 N20 NBUFFX4
X268 N5 _NC536 _NC537 N18 NBUFFX4
X269 N331 _NC538 _NC539 N17 NBUFFX2
X270 S_shl1[0] _NC540 _NC541 N27 NBUFFX2
X271 S_shr1[5] _NC542 _NC543 N31 NBUFFX2
X272 S_shr1[4] _NC544 _NC545 N29 NBUFFX2
X273 N2460 N117 S_output_o[31] _NC546 _NC547 NAND2X1
X274 N3450 N30 N184 _NC548 _NC549 NOR2X0
X275 N26 N113 N211 _NC550 _NC551 NOR2X0
X276 N3370 _NC552 _NC553 N317 INVX0
X277 N3390 _NC554 _NC555 N82 INVX0
X278 N3400 _NC556 _NC557 N84 INVX0
X279 N3430 _NC558 _NC559 N315 INVX0
X280 N3420 _NC560 _NC561 N111 INVX0
X281 N3380 _NC562 _NC563 N3190 INVX0
X282 N3410 _NC564 _NC565 N87 INVX0
X283 N3360 _NC566 _NC567 N324 INVX0
X284 N30 N4290 N189 _NC568 _NC569 NOR2X0
X285 N30 N4220 N188 _NC570 _NC571 NOR2X0
X286 N30 N4470 N192 _NC572 _NC573 NOR2X0
X287 N30 N436 N190 _NC574 _NC575 NOR2X0
X288 N30 N3880 N185 _NC576 _NC577 NOR2X0
X289 N30 N4050 N186 _NC578 _NC579 NOR2X0
X290 N30 N349 N194 _NC580 _NC581 NOR2X0
X291 N30 N452 N193 _NC582 _NC583 NOR2X0
X292 N30 N4420 N191 _NC584 _NC585 NOR2X0
X293 N30 N4150 N187 _NC586 _NC587 NOR2X0
X294 S_qutnt_i[26] N20 N347 _NC588 _NC589 NAND2X1
X295 N283 N284 N2520 _NC590 _NC591 NOR2X0
X296 N368 S_shr1[2] N3790 _NC592 _NC593 NOR2X0
X297 N3780 S_shr1[2] N3940 _NC594 _NC595 NOR2X0
X298 N281 N282 N2500 _NC596 _NC597 NOR2X0
X299 N2460 N2480 S_output_o[22] _NC598 _NC599 NAND2X1
X300 N286 N287 N285 _NC600 _NC601 NOR2X0
X301 S_shr1[5] _NC602 _NC603 N30 NBUFFX2
X302 S_rmode_i[1] N119 N3050 _NC604 _NC605 NAND2X1
X303 N2420 S_qutnt_i[15] N152 _NC606 _NC607 NOR2X0
X304 N2260 S_qutnt_i[9] N155 _NC608 _NC609 NOR2X0
X305 N2370 S_qutnt_i[21] N1480 _NC610 _NC611 NOR2X0
X306 N332 N301 N302 N12 _NC612 _NC613 OAI21X1
X307 N265 S_exp_10b[8] N2640 _NC614 _NC615 NOR2X0
X308 N1860 N108 N1850 _NC616 _NC617 NAND2X1
X309 N2440 N79 N2410 _NC618 _NC619 NAND2X1
X310 N1990 N112 N2000 _NC620 _NC621 NAND2X1
X311 N2000 S_qutnt_i[3] N1860 _NC622 _NC623 NOR2X0
X312 N2380 S_qutnt_i[24] N2390 _NC624 _NC625 NOR2X0
X313 N2200 N104 N2210 _NC626 _NC627 NAND2X1
X314 N2280 N97 N2290 _NC628 _NC629 NAND2X1
X315 N2260 N99 N2270 _NC630 _NC631 NAND2X1
X316 N2370 N62 N2380 _NC632 _NC633 NAND2X1
X317 N3290 N106 N2220 _NC634 _NC635 NAND2X1
X318 N2420 N93 N2430 _NC636 _NC637 NAND2X1
X319 N102 N71 N1450 _NC638 _NC639 NAND2X1
X320 N2220 S_qutnt_i[6] N2200 _NC640 _NC641 NOR2X0
X321 N2270 S_qutnt_i[12] N2280 _NC642 _NC643 NOR2X0
X322 S_qutnt_i[10] S_qutnt_i[9] N2260 _NC644 _NC645 NOR2X0
X323 N2430 S_qutnt_i[18] N2440 _NC646 _NC647 NOR2X0
X324 S_qutnt_i[21] S_qutnt_i[22] N2370 _NC648 _NC649 NOR2X0
X325 N2210 S_qutnt_i[8] N127 _NC650 _NC651 NOR2X0
X326 N2290 S_qutnt_i[14] N137 _NC652 _NC653 NOR2X0
X327 S_qutnt_i[15] S_qutnt_i[16] N2420 _NC654 _NC655 NOR2X0
X328 N2350 N2360 N2340 _NC656 _NC657 NOR2X0
X329 N341 N105 N333 _NC658 _NC659 NAND2X1
X330 Add_105_I8_L07002_C191_carry[3] N333 N358 _NC660 _NC661 XNOR2X1
X331 N2600 S_qutnt_i[3] N2580 _NC662 _NC663 NOR2X0
X332 N2130 N2140 N2120 _NC664 _NC665 NOR2X0
X333 S_qutnt_i[0] S_qutnt_i[1] N1990 _NC666 _NC667 NOR2X0
X334 N3730 _NC668 _NC669 N120 INVX0
X335 N3630 _NC670 _NC671 N318 INVX0
X336 N4060 _NC672 _NC673 N3220 INVX0
X337 N3960 _NC674 _NC675 N3260 INVX0
X338 N2000 _NC676 _NC677 N330 INVX0
X339 N3620 _NC678 _NC679 N92 INVX0
X340 N3590 _NC680 _NC681 N83 INVX0
X341 N365 _NC682 _NC683 N316 INVX0
X342 N3750 _NC684 _NC685 N85 INVX0
X343 S_exp_10b[4] _NC686 _NC687 N34 INVX0
X344 S_exp_10b[3] _NC688 _NC689 N33 INVX0
X345 S_exp_10b[0] _NC690 _NC691 N32 INVX0
X346 N4230 _NC692 _NC693 N3210 INVX0
X347 N416 _NC694 _NC695 N3250 INVX0
X348 N4100 _NC696 _NC697 N3270 INVX0
X349 N400 _NC698 _NC699 N3280 INVX0
X350 N385 _NC700 _NC701 N3200 INVX0
X351 N3790 _NC702 _NC703 N78 INVX0
X352 N3940 _NC704 _NC705 N81 INVX0
X353 N3560 N18 N3780 _NC706 _NC707 NAND2X1
X354 S_exp_10b[2] _NC708 _NC709 N57 INVX0
X355 S_exp_10b[1] _NC710 _NC711 N58 INVX0
X356 N3790 N3 N3950 _NC712 _NC713 NAND2X1
X357 N3940 N3 N450 _NC714 _NC715 NAND2X1
X358 N3810 N3 N4130 _NC716 _NC717 NAND2X1
X359 N3720 N2 N3920 _NC718 _NC719 NAND2X1
X360 N5 _NC720 _NC721 N19 NBUFFX2
X361 N2550 N2540 N2470 _NC722 _NC723 NOR2X0
X362 N6 _NC724 _NC725 N21 NBUFFX2
X363 N2610 _NC726 _NC727 N24 INVX0
X364 N2610 _NC728 _NC729 N25 INVX0
X365 N2570 _NC730 _NC731 N76 INVX0
X366 S_exp_10b[7] _NC732 _NC733 N54 INVX0
X367 N279 _NC734 _NC735 N332 INVX0
X368 N159 N325 N2170 _NC736 _NC737 NAND2X1
X369 N2640 N1 N162 _NC738 _NC739 NAND2X1
X370 N2440 N2410 N154 _NC740 _NC741 NAND2X1
X371 N2420 N2430 N142 _NC742 _NC743 NAND2X1
X372 S_exp_10b[6] _NC744 _NC745 N55 INVX0
X373 S_exp_10b[5] _NC746 _NC747 N56 INVX0
X374 N2270 N2280 N156 _NC748 _NC749 NOR2X0
X375 Sub_1_root_sub_150_2_carry[4] N34 N11 _NC750 _NC751 NAND2X1
X376 S_exp_10b[5] N11 N151 _NC752 _NC753 XOR2X1
X377 N2220 N2200 N131 _NC754 _NC755 NOR2X0
X378 N2640 _NC756 _NC757 N53 INVX0
X379 N12 _NC758 _NC759 N22 INVX0
X380 N1850 _NC760 _NC761 N3290 INVX0
X381 N127 _NC762 _NC763 N3230 INVX0
X382 N102 N1450 N143 _NC764 _NC765 NAND2X1
X383 N2410 _NC766 _NC767 N102 INVX0
X384 N2400 _NC768 _NC769 N77 INVX0
X385 N2210 N127 N126 _NC770 _NC771 NOR2X0
X386 N2290 N137 N136 _NC772 _NC773 NOR2X0
X387 N2380 N2390 N1500 _NC774 _NC775 NOR2X0
X388 N1021 _NC776 _NC777 N52 INVX0
X389 N580 _NC778 _NC779 N91 INVX0
X390 N1089 N12 N300 _NC780 _NC781 NAND2X1
X391 N530 _NC782 _NC783 N299 INVX0
X392 N581 _NC784 _NC785 N90 INVX0
X393 N568 _NC786 _NC787 N65 INVX0
X394 N567 _NC788 _NC789 N70 INVX0
X395 N565 _NC790 _NC791 N109 INVX0
X396 N566 _NC792 _NC793 N107 INVX0
X397 N564 _NC794 _NC795 N110 INVX0
X398 N551 _NC796 _NC797 N66 INVX0
X399 N550 _NC798 _NC799 N72 INVX0
X400 N548 _NC800 _NC801 N115 INVX0
X401 N549 _NC802 _NC803 N114 INVX0
X402 N547 _NC804 _NC805 N116 INVX0
X403 N333 _NC806 _NC807 N68 INVX0
X404 N330 N1980 N1990 N2000 N10 _NC808 _NC809 AOI22X1
X405 N127 N171 N159 N328 N1720 N9 _NC810 _NC811 AOI221X1
X406 N183 N1840 S_r_zeros[2] _NC812 _NC813 NAND2X1
X407 N2030 _NC814 _NC815 Add_105_I5_L07002_C191_A[1] INVX0
X408 N126 N381 N127 N128 N129 N8 _NC816 _NC817 AOI221X1
X409 N169 N170 N168 _NC818 _NC819 NOR2X0
X410 N584 _NC820 _NC821 N69 INVX0
X411 N533 _NC822 _NC823 N73 INVX0
X412 N1950 N1960 N1940 _NC824 _NC825 NOR2X0
X413 N582 _NC826 _NC827 N89 INVX0
X414 N531 _NC828 _NC829 N125 INVX0
X415 N181 N182 N180 _NC830 _NC831 NOR2X0
X416 N583 _NC832 _NC833 N88 INVX0
X417 N532 _NC834 _NC835 N121 INVX0
X418 N1460 N1470 N144 _NC836 _NC837 NOR2X0
X419 N585 _NC838 _NC839 N59 INVX0
X420 N534 _NC840 _NC841 N67 INVX0
X421 N268 N74 N1386 _NC842 _NC843 NOR2X0
X422 N127 N158 N159 N329 N160 N7 _NC844 _NC845 AOI221X1
X423 N3810 _NC846 _NC847 N80 INVX0
X424 N2470 _NC848 _NC849 N74 INVX0
X425 N2490 _NC850 _NC851 N75 INVX0
X426 N300 _NC852 _NC853 N331 INVX0
X427 N22 N13 N298 _NC854 _NC855 NOR2X0
X428 N74 N75 N2450 _NC856 _NC857 NOR2X0
X429 N74 N75 N16 _NC858 _NC859 NOR2X0
X430 N17 _NC860 _NC861 N13 NBUFFX2
X431 N17 _NC862 _NC863 N15 NBUFFX2
X432 N17 _NC864 _NC865 N14 NBUFFX2
X433 N159 N326 N2010 _NC866 _NC867 NAND2X1
X434 S_qutnt_i[26] S_exp_10_i[0] N1 _NC868 _NC869 XOR2X1
X435 S_sign_i N3050 N3060 N301 _NC870 _NC871 OA21X1
X436 Clk_i Qutnt_i[6] S_qutnt_i[6] N105 _NC872 _NC873 DFFX1
X437 Clk_i Qutnt_i[9] S_qutnt_i[9] N101 _NC874 _NC875 DFFX1
X438 Clk_i Qutnt_i[8] S_qutnt_i[8] N103 _NC876 _NC877 DFFX1
X439 Clk_i Qutnt_i[10] S_qutnt_i[10] N100 _NC878 _NC879 DFFX1
X440 Clk_i Qutnt_i[7] S_qutnt_i[7] N104 _NC880 _NC881 DFFX1
X441 Clk_i Qutnt_i[12] S_qutnt_i[12] N98 _NC882 _NC883 DFFX1
X442 Clk_i Qutnt_i[13] S_qutnt_i[13] N97 _NC884 _NC885 DFFX1
X443 Clk_i Qutnt_i[11] S_qutnt_i[11] N99 _NC886 _NC887 DFFX1
X444 Clk_i Qutnt_i[15] S_qutnt_i[15] N95 _NC888 _NC889 DFFX1
X445 Clk_i Qutnt_i[14] S_qutnt_i[14] N96 _NC890 _NC891 DFFX1
X446 Clk_i Qutnt_i[16] S_qutnt_i[16] N94 _NC892 _NC893 DFFX1
X447 Clk_i Qutnt_i[17] S_qutnt_i[17] N93 _NC894 _NC895 DFFX1
X448 Clk_i Qutnt_i[18] S_qutnt_i[18] N86 _NC896 _NC897 DFFX1
X449 Clk_i Qutnt_i[19] S_qutnt_i[19] N79 _NC898 _NC899 DFFX1
X450 Clk_i Qutnt_i[20] S_qutnt_i[20] N71 _NC900 _NC901 DFFX1
X451 Clk_i Qutnt_i[21] S_qutnt_i[21] N64 _NC902 _NC903 DFFX1
X452 Clk_i Qutnt_i[22] S_qutnt_i[22] N63 _NC904 _NC905 DFFX1
X453 Clk_i Qutnt_i[24] S_qutnt_i[24] N61 _NC906 _NC907 DFFX1
X454 Clk_i Qutnt_i[23] S_qutnt_i[23] N62 _NC908 _NC909 DFFX1
X455 Clk_i Qutnt_i[25] S_qutnt_i[25] N60 _NC910 _NC911 DFFX1
X456 Clk_i N175 S_shr1[3] N3 _NC912 _NC913 DFFX1
X457 N297 Add_105_I5_L07002_C191_carry[2] N307 _NC914 _NC915 _NC916 HADDX1
X458 Add_105_I5_L07002_C191_A[1] N295 Add_105_I5_L07002_C191_carry[2] _NC917 _NC918 _NC919 HADDX1
X459 N312 Add_105_I6_L07002_C191_carry[3] N323 _NC920 _NC921 _NC922 HADDX1
X460 N311 Add_105_I6_L07002_C191_carry[2] Add_105_I6_L07002_C191_carry[3] _NC923 _NC924 _NC925 HADDX1
X461 N310 N309 Add_105_I6_L07002_C191_carry[2] _NC926 _NC927 _NC928 HADDX1
X462 N329 Add_105_I7_L07002_C191_carry[2] N341 _NC929 _NC930 _NC931 HADDX1
X463 N328 Add_105_I7_L07002_C191_carry[1] Add_105_I7_L07002_C191_carry[2] _NC932 _NC933 _NC934 HADDX1
X464 N327 Add_105_I7_L07002_C191_carry[0] Add_105_I7_L07002_C191_carry[1] _NC935 _NC936 _NC937 HADDX1
X465 N326 N325 Add_105_I7_L07002_C191_carry[0] _NC938 _NC939 _NC940 HADDX1
X466 N346 Add_105_I8_L07002_C191_carry[2] Add_105_I8_L07002_C191_carry[3] _NC941 _NC942 _NC943 HADDX1
X467 N345 Add_105_I8_L07002_C191_carry[1] Add_105_I8_L07002_C191_carry[2] _NC944 _NC945 _NC946 HADDX1
X468 N344 Add_105_I8_L07002_C191_carry[0] Add_105_I8_L07002_C191_carry[1] _NC947 _NC948 _NC949 HADDX1
X469 N343 N342 Add_105_I8_L07002_C191_carry[0] _NC950 _NC951 _NC952 HADDX1
X470 N363 Add_105_I9_L07002_C191_carry[2] Add_105_I9_L07002_C191_carry[3] _NC953 _NC954 _NC955 HADDX1
X471 N362 Add_105_I9_L07002_C191_carry[1] Add_105_I9_L07002_C191_carry[2] _NC956 _NC957 _NC958 HADDX1
X472 N361 Add_105_I9_L07002_C191_carry[0] Add_105_I9_L07002_C191_carry[1] _NC959 _NC960 _NC961 HADDX1
X473 N360 N359 Add_105_I9_L07002_C191_carry[0] _NC962 _NC963 _NC964 HADDX1
X474 N380 Add_105_I10_L07002_C191_carry[2] Add_105_I10_L07002_C191_carry[3] _NC965 _NC966 _NC967 HADDX1
X475 N379 Add_105_I10_L07002_C191_carry[1] Add_105_I10_L07002_C191_carry[2] _NC968 _NC969 _NC970 HADDX1
X476 N378 Add_105_I10_L07002_C191_carry[0] Add_105_I10_L07002_C191_carry[1] _NC971 _NC972 _NC973 HADDX1
X477 N377 N376 Add_105_I10_L07002_C191_carry[0] _NC974 _NC975 _NC976 HADDX1
X478 N397 Add_105_I11_L07002_C191_carry[2] Add_105_I11_L07002_C191_carry[3] _NC977 _NC978 _NC979 HADDX1
X479 N396 Add_105_I11_L07002_C191_carry[1] Add_105_I11_L07002_C191_carry[2] _NC980 _NC981 _NC982 HADDX1
X480 N395 Add_105_I11_L07002_C191_carry[0] Add_105_I11_L07002_C191_carry[1] _NC983 _NC984 _NC985 HADDX1
X481 N394 N393 Add_105_I11_L07002_C191_carry[0] _NC986 _NC987 _NC988 HADDX1
X482 N414 Add_105_I12_L07002_C191_carry[2] Add_105_I12_L07002_C191_carry[3] _NC989 _NC990 _NC991 HADDX1
X483 N413 Add_105_I12_L07002_C191_carry[1] Add_105_I12_L07002_C191_carry[2] _NC992 _NC993 _NC994 HADDX1
X484 N412 Add_105_I12_L07002_C191_carry[0] Add_105_I12_L07002_C191_carry[1] _NC995 _NC996 _NC997 HADDX1
X485 N411 N410 Add_105_I12_L07002_C191_carry[0] _NC998 _NC999 _NC1000 HADDX1
X486 N431 Add_105_I13_L07002_C191_carry[2] Add_105_I13_L07002_C191_carry[3] _NC1001 _NC1002 _NC1003 HADDX1
X487 N430 Add_105_I13_L07002_C191_carry[1] Add_105_I13_L07002_C191_carry[2] _NC1004 _NC1005 _NC1006 HADDX1
X488 N429 Add_105_I13_L07002_C191_carry[0] Add_105_I13_L07002_C191_carry[1] _NC1007 _NC1008 _NC1009 HADDX1
X489 N428 N427 Add_105_I13_L07002_C191_carry[0] _NC1010 _NC1011 _NC1012 HADDX1
X490 N448 Add_105_I14_L07002_C191_carry[2] Add_105_I14_L07002_C191_carry[3] _NC1013 _NC1014 _NC1015 HADDX1
X491 N447 Add_105_I14_L07002_C191_carry[1] Add_105_I14_L07002_C191_carry[2] _NC1016 _NC1017 _NC1018 HADDX1
X492 N446 Add_105_I14_L07002_C191_carry[0] Add_105_I14_L07002_C191_carry[1] _NC1019 _NC1020 _NC1021 HADDX1
X493 N445 N444 Add_105_I14_L07002_C191_carry[0] _NC1022 _NC1023 _NC1024 HADDX1
X494 N465 Add_105_I15_L07002_C191_carry[2] Add_105_I15_L07002_C191_carry[3] _NC1025 _NC1026 _NC1027 HADDX1
X495 N464 Add_105_I15_L07002_C191_carry[1] Add_105_I15_L07002_C191_carry[2] _NC1028 _NC1029 _NC1030 HADDX1
X496 N463 Add_105_I15_L07002_C191_carry[0] Add_105_I15_L07002_C191_carry[1] _NC1031 _NC1032 _NC1033 HADDX1
X497 N462 N461 Add_105_I15_L07002_C191_carry[0] _NC1034 _NC1035 _NC1036 HADDX1
X498 N482 Add_105_I16_L07002_C191_carry[2] Add_105_I16_L07002_C191_carry[3] _NC1037 _NC1038 _NC1039 HADDX1
X499 N481 Add_105_I16_L07002_C191_carry[1] Add_105_I16_L07002_C191_carry[2] _NC1040 _NC1041 _NC1042 HADDX1
X500 N480 Add_105_I16_L07002_C191_carry[0] Add_105_I16_L07002_C191_carry[1] _NC1043 _NC1044 _NC1045 HADDX1
X501 N479 N478 Add_105_I16_L07002_C191_carry[0] _NC1046 _NC1047 _NC1048 HADDX1
X502 N499 Add_105_I17_L07002_C191_carry[2] Add_105_I17_L07002_C191_carry[3] _NC1049 _NC1050 _NC1051 HADDX1
X503 N498 Add_105_I17_L07002_C191_carry[1] Add_105_I17_L07002_C191_carry[2] _NC1052 _NC1053 _NC1054 HADDX1
X504 N497 Add_105_I17_L07002_C191_carry[0] Add_105_I17_L07002_C191_carry[1] _NC1055 _NC1056 _NC1057 HADDX1
X505 N496 N495 Add_105_I17_L07002_C191_carry[0] _NC1058 _NC1059 _NC1060 HADDX1
X506 N516 Add_105_I18_L07002_C191_carry[2] Add_105_I18_L07002_C191_carry[3] _NC1061 _NC1062 _NC1063 HADDX1
X507 N515 Add_105_I18_L07002_C191_carry[1] Add_105_I18_L07002_C191_carry[2] _NC1064 _NC1065 _NC1066 HADDX1
X508 N514 Add_105_I18_L07002_C191_carry[0] Add_105_I18_L07002_C191_carry[1] _NC1067 _NC1068 _NC1069 HADDX1
X509 N513 N512 Add_105_I18_L07002_C191_carry[0] _NC1070 _NC1071 _NC1072 HADDX1
X510 N533 Add_105_I19_L07002_C191_carry[2] Add_105_I19_L07002_C191_carry[3] _NC1073 _NC1074 _NC1075 HADDX1
X511 N532 Add_105_I19_L07002_C191_carry[1] Add_105_I19_L07002_C191_carry[2] _NC1076 _NC1077 _NC1078 HADDX1
X512 N531 Add_105_I19_L07002_C191_carry[0] Add_105_I19_L07002_C191_carry[1] _NC1079 _NC1080 _NC1081 HADDX1
X513 N530 N529 Add_105_I19_L07002_C191_carry[0] _NC1082 _NC1083 _NC1084 HADDX1
X514 N550 Add_105_I20_L07002_C191_carry[2] Add_105_I20_L07002_C191_carry[3] _NC1085 _NC1086 _NC1087 HADDX1
X515 N549 Add_105_I20_L07002_C191_carry[1] Add_105_I20_L07002_C191_carry[2] _NC1088 _NC1089 _NC1090 HADDX1
X516 N548 Add_105_I20_L07002_C191_carry[0] Add_105_I20_L07002_C191_carry[1] _NC1091 _NC1092 _NC1093 HADDX1
X517 N547 N546 Add_105_I20_L07002_C191_carry[0] _NC1094 _NC1095 _NC1096 HADDX1
X518 N567 Add_105_I21_L07002_C191_carry[2] Add_105_I21_L07002_C191_carry[3] _NC1097 _NC1098 _NC1099 HADDX1
X519 N566 Add_105_I21_L07002_C191_carry[1] Add_105_I21_L07002_C191_carry[2] _NC1100 _NC1101 _NC1102 HADDX1
X520 N565 Add_105_I21_L07002_C191_carry[0] Add_105_I21_L07002_C191_carry[1] _NC1103 _NC1104 _NC1105 HADDX1
X521 N564 N563 Add_105_I21_L07002_C191_carry[0] _NC1106 _NC1107 _NC1108 HADDX1
X522 N584 Add_105_I22_L07002_C191_carry[2] Add_105_I22_L07002_C191_carry[3] _NC1109 _NC1110 _NC1111 HADDX1
X523 N583 Add_105_I22_L07002_C191_carry[1] Add_105_I22_L07002_C191_carry[2] _NC1112 _NC1113 _NC1114 HADDX1
X524 N582 Add_105_I22_L07002_C191_carry[0] Add_105_I22_L07002_C191_carry[1] _NC1115 _NC1116 _NC1117 HADDX1
X525 N581 N580 Add_105_I22_L07002_C191_carry[0] _NC1118 _NC1119 _NC1120 HADDX1
X526 N601 Add_105_I23_L07002_C191_carry[2] Add_105_I23_L07002_C191_carry[3] _NC1121 _NC1122 _NC1123 HADDX1
X527 N600 Add_105_I23_L07002_C191_carry[1] Add_105_I23_L07002_C191_carry[2] _NC1124 _NC1125 _NC1126 HADDX1
X528 N599 Add_105_I23_L07002_C191_carry[0] Add_105_I23_L07002_C191_carry[1] _NC1127 _NC1128 _NC1129 HADDX1
X529 N598 N597 Add_105_I23_L07002_C191_carry[0] _NC1130 _NC1131 _NC1132 HADDX1
X530 N618 Add_105_I24_L07002_C191_carry[2] Add_105_I24_L07002_C191_carry[3] _NC1133 _NC1134 _NC1135 HADDX1
X531 N617 Add_105_I24_L07002_C191_carry[1] Add_105_I24_L07002_C191_carry[2] _NC1136 _NC1137 _NC1138 HADDX1
X532 N616 Add_105_I24_L07002_C191_carry[0] Add_105_I24_L07002_C191_carry[1] _NC1139 _NC1140 _NC1141 HADDX1
X533 N615 N614 Add_105_I24_L07002_C191_carry[0] _NC1142 _NC1143 _NC1144 HADDX1
X534 N635 Add_105_I25_L07002_C191_carry[2] Add_105_I25_L07002_C191_carry[3] _NC1145 _NC1146 _NC1147 HADDX1
X535 N634 Add_105_I25_L07002_C191_carry[1] Add_105_I25_L07002_C191_carry[2] _NC1148 _NC1149 _NC1150 HADDX1
X536 N633 Add_105_I25_L07002_C191_carry[0] Add_105_I25_L07002_C191_carry[1] _NC1151 _NC1152 _NC1153 HADDX1
X537 N632 N631 Add_105_I25_L07002_C191_carry[0] _NC1154 _NC1155 _NC1156 HADDX1
X538 N652 Add_105_I26_L07002_C191_carry[2] Add_105_I26_L07002_C191_carry[3] _NC1157 _NC1158 _NC1159 HADDX1
X539 N651 Add_105_I26_L07002_C191_carry[1] Add_105_I26_L07002_C191_carry[2] _NC1160 _NC1161 _NC1162 HADDX1
X540 N650 Add_105_I26_L07002_C191_carry[0] Add_105_I26_L07002_C191_carry[1] _NC1163 _NC1164 _NC1165 HADDX1
X541 N649 N648 Add_105_I26_L07002_C191_carry[0] _NC1166 _NC1167 _NC1168 HADDX1
X542 N669 Add_105_I27_L07002_C191_carry[2] Add_105_I27_L07002_C191_carry[3] _NC1169 _NC1170 _NC1171 HADDX1
X543 N668 Add_105_I27_L07002_C191_carry[1] Add_105_I27_L07002_C191_carry[2] _NC1172 _NC1173 _NC1174 HADDX1
X544 N667 Add_105_I27_L07002_C191_carry[0] Add_105_I27_L07002_C191_carry[1] _NC1175 _NC1176 _NC1177 HADDX1
X545 N666 N665 Add_105_I27_L07002_C191_carry[0] _NC1178 _NC1179 _NC1180 HADDX1
X546 S_fraco1[3] S_fraco1[4] S_fraco1[5] S_fraco1[6] S_fraco1[7] S_fraco1[8] S_fraco1[9] S_fraco1[10] S_fraco1[11] S_fraco1[12] S_fraco1[13] S_fraco1[14] S_fraco1[15] S_fraco1[16] S_fraco1[17] S_fraco1[18] S_fraco1[19] S_fraco1[20] S_fraco1[21] S_fraco1[22] S_fraco1[23] S_fraco1[24] S_fraco1[25] S_fraco1[26] Vss N1065 N1066 N1067 N1068 N1069 N1070 N1071 N1072 N1073 N1074 N1075 N1076 N1077 N1078 N1079 N1080 N1081 N1082 N1083 N1084 N1085 N1086 N1087 N1088 N1089 post_norm_div_DW01_inc_1
X547 S_expo2[0] S_expo2[1] S_expo2[2] S_expo2[3] S_expo2[4] S_expo2[5] S_expo2[6] S_expo2[7] S_expo2[8] N1091 N1092 N1093 N1094 N1095 N1096 N1097 N1098 N1099 post_norm_div_DW01_inc_0
X548 S_rmndr_i[12] S_rmndr_i[11] S_rmndr_i[14] S_rmndr_i[13] N314 _NC1181 _NC1182 OR4X1
X549 N314 S_fraco1[0] S_rmndr_i[10] S_rmndr_i[0] N3070 _NC1183 _NC1184 NOR4X0
X550 S_rmndr_i[19] S_rmndr_i[18] S_rmndr_i[20] S_rmndr_i[1] N313 _NC1185 _NC1186 OR4X1
X551 N313 S_rmndr_i[15] S_rmndr_i[17] S_rmndr_i[16] N308 _NC1187 _NC1188 NOR4X0
X552 S_rmndr_i[25] S_rmndr_i[24] S_rmndr_i[2] S_rmndr_i[26] N3120 _NC1189 _NC1190 OR4X1
X553 N3120 S_rmndr_i[21] S_rmndr_i[23] S_rmndr_i[22] N3090 _NC1191 _NC1192 NOR4X0
X554 S_rmndr_i[7] S_rmndr_i[6] S_rmndr_i[9] S_rmndr_i[8] N3110 _NC1193 _NC1194 OR4X1
X555 N3110 S_rmndr_i[3] S_rmndr_i[5] S_rmndr_i[4] N3100 _NC1195 _NC1196 NOR4X0
X556 N3070 N308 N3090 N3100 N3040 _NC1197 _NC1198 AND4X1
X557 N124 N123 N3040 N279 _NC1199 _NC1200 NAND3X0
X558 S_rmode_i[1] N3050 S_sign_i N3060 _NC1201 _NC1202 NAND3X0
X559 N124 N122 N3040 N303 _NC1203 _NC1204 NAND3X0
X560 S_fraco1[2] N303 N119 N118 N302 _NC1205 _NC1206 NAND4X0
X561 N1091 N15 S_expo2[0] N300 N1100 _NC1207 _NC1208 AO22X1
X562 N1092 N14 S_expo2[1] N300 N1101 _NC1209 _NC1210 AO22X1
X563 N1093 N15 S_expo2[2] N300 N1102 _NC1211 _NC1212 AO22X1
X564 N1094 N14 S_expo2[3] N300 N1103 _NC1213 _NC1214 AO22X1
X565 N1095 N15 S_expo2[4] N300 N1104 _NC1215 _NC1216 AO22X1
X566 N1096 N14 S_expo2[5] N300 N1105 _NC1217 _NC1218 AO22X1
X567 N1097 N15 S_expo2[6] N300 N1106 _NC1219 _NC1220 AO22X1
X568 N1098 N14 S_expo2[7] N300 N1107 _NC1221 _NC1222 AO22X1
X569 N1099 N14 S_expo2[8] N300 N1108 _NC1223 _NC1224 AO22X1
X570 N1065 N298 S_fraco1[3] N22 N1066 N14 N1109 _NC1225 _NC1226 AO222X1
X571 N1066 N298 S_fraco1[4] N22 N1067 N15 N1110 _NC1227 _NC1228 AO222X1
X572 N1067 N298 S_fraco1[5] N22 N1068 N14 N1111 _NC1229 _NC1230 AO222X1
X573 N1068 N298 S_fraco1[6] N22 N1069 N15 N1112 _NC1231 _NC1232 AO222X1
X574 N1069 N298 S_fraco1[7] N22 N1070 N14 N1113 _NC1233 _NC1234 AO222X1
X575 N1070 N298 S_fraco1[8] N22 N1071 N15 N1114 _NC1235 _NC1236 AO222X1
X576 N1071 N298 S_fraco1[9] N22 N1072 N14 N1115 _NC1237 _NC1238 AO222X1
X577 N1072 N298 S_fraco1[10] N22 N1073 N15 N1116 _NC1239 _NC1240 AO222X1
X578 N1073 N298 S_fraco1[11] N22 N1074 N14 N1117 _NC1241 _NC1242 AO222X1
X579 N1074 N298 S_fraco1[12] N22 N1075 N15 N1118 _NC1243 _NC1244 AO222X1
X580 N1075 N298 S_fraco1[13] N22 N1076 N15 N1119 _NC1245 _NC1246 AO222X1
X581 N1076 N298 S_fraco1[14] N22 N1077 N14 N1120 _NC1247 _NC1248 AO222X1
X582 N1077 N298 S_fraco1[15] N22 N1078 N15 N1121 _NC1249 _NC1250 AO222X1
X583 N1078 N298 S_fraco1[16] N22 N1079 N14 N1122 _NC1251 _NC1252 AO222X1
X584 N1079 N298 S_fraco1[17] N22 N1080 N15 N1123 _NC1253 _NC1254 AO222X1
X585 N1080 N298 S_fraco1[18] N22 N1081 N14 N1124 _NC1255 _NC1256 AO222X1
X586 N1081 N298 S_fraco1[19] N22 N1082 N15 N1125 _NC1257 _NC1258 AO222X1
X587 N1082 N298 S_fraco1[20] N22 N1083 N14 N1126 _NC1259 _NC1260 AO222X1
X588 N1083 N298 S_fraco1[21] N22 N1084 N15 N1127 _NC1261 _NC1262 AO222X1
X589 N1084 N298 S_fraco1[22] N22 N1085 N14 N1128 _NC1263 _NC1264 AO222X1
X590 N1085 N298 S_fraco1[23] N22 N1086 N15 N1129 _NC1265 _NC1266 AO222X1
X591 N1086 N298 S_fraco1[24] N22 N13 N1087 N1130 _NC1267 _NC1268 AO222X1
X592 N1087 N298 S_fraco1[25] N22 N1088 N14 N1131 _NC1269 _NC1270 AO222X1
X593 S_opb_i[30] S_opb_i[29] S_opb_i[28] N288 _NC1271 _NC1272 OR3X1
X594 S_opb_i[10] S_opb_i[0] N2970 _NC1273 _NC1274 OR2X1
X595 N2970 S_opb_i[11] S_opb_i[13] S_opb_i[12] N290 _NC1275 _NC1276 NOR4X0
X596 S_opb_i[19] S_opb_i[18] S_opb_i[17] N296 _NC1277 _NC1278 OR3X1
X597 N296 S_opb_i[14] S_opb_i[16] S_opb_i[15] N291 _NC1279 _NC1280 NOR4X0
X598 S_opb_i[3] S_opb_i[2] S_opb_i[22] N2950 _NC1281 _NC1282 OR3X1
X599 N2950 S_opb_i[1] S_opb_i[21] S_opb_i[20] N292 _NC1283 _NC1284 NOR4X0
X600 S_opb_i[9] S_opb_i[8] S_opb_i[7] N294 _NC1285 _NC1286 OR3X1
X601 N294 S_opb_i[4] S_opb_i[6] S_opb_i[5] N293 _NC1287 _NC1288 NOR4X0
X602 N290 N291 N292 N293 N2510 _NC1289 _NC1290 NAND4X0
X603 S_opb_i[23] N2510 S_opb_i[25] S_opb_i[24] N289 _NC1291 _NC1292 OR4X1
X604 S_opb_i[27] S_opb_i[26] N288 N289 N2550 _NC1293 _NC1294 NOR4X0
X605 S_expo3[3] S_expo3[2] S_expo3[1] S_expo3[0] N286 _NC1295 _NC1296 NAND4X0
X606 S_expo3[7] S_expo3[6] S_expo3[5] S_expo3[4] N287 _NC1297 _NC1298 NAND4X0
X607 S_expo3[8] N2550 N285 N2570 _NC1299 _NC1300 NOR3X0
X608 S_expa[3] S_expa[2] S_expa[1] S_expa[0] N283 _NC1301 _NC1302 NAND4X0
X609 S_expa[7] S_expa[6] S_expa[5] S_expa[4] N284 _NC1303 _NC1304 NAND4X0
X610 S_expb[3] S_expb[2] S_expb[1] S_expb[0] N281 _NC1305 _NC1306 NAND4X0
X611 S_expb[7] S_expb[6] S_expb[5] S_expb[4] N282 _NC1307 _NC1308 NAND4X0
X612 N2570 N2520 N2500 N280 _NC1309 _NC1310 NOR3X0
X613 N279 N1025 N280 N268 _NC1311 _NC1312 NOR3X0
X614 S_opa_i[30] S_opa_i[29] S_opa_i[28] N269 _NC1313 _NC1314 OR3X1
X615 S_opa_i[10] S_opa_i[0] N278 _NC1315 _NC1316 OR2X1
X616 N278 S_opa_i[11] S_opa_i[13] S_opa_i[12] N271 _NC1317 _NC1318 NOR4X0
X617 S_opa_i[19] S_opa_i[18] S_opa_i[17] N277 _NC1319 _NC1320 OR3X1
X618 N277 S_opa_i[14] S_opa_i[16] S_opa_i[15] N272 _NC1321 _NC1322 NOR4X0
X619 S_opa_i[3] S_opa_i[2] S_opa_i[22] N276 _NC1323 _NC1324 OR3X1
X620 N276 S_opa_i[1] S_opa_i[21] S_opa_i[20] N273 _NC1325 _NC1326 NOR4X0
X621 S_opa_i[9] S_opa_i[8] S_opa_i[7] N275 _NC1327 _NC1328 OR3X1
X622 N275 S_opa_i[4] S_opa_i[6] S_opa_i[5] N274 _NC1329 _NC1330 NOR4X0
X623 N271 N272 N273 N274 N2560 _NC1331 _NC1332 NAND4X0
X624 S_opa_i[23] N2560 S_opa_i[25] S_opa_i[24] N270 _NC1333 _NC1334 OR4X1
X625 S_opa_i[27] S_opa_i[26] N269 N270 N2540 _NC1335 _NC1336 NOR4X0
X626 N1 N32 N58 N57 N266 _NC1337 _NC1338 NAND4X0
X627 N55 N54 N56 N267 _NC1339 _NC1340 NAND3X0
X628 N266 N267 S_exp_10b[4] S_exp_10b[3] N265 _NC1341 _NC1342 NOR4X0
X629 N2640 Sub_1_root_sub_150_2_CI N54 N161 _NC1343 _NC1344 AND3X1
X630 N2640 S_exp_10b[3] N166 _NC1345 _NC1346 AND2X1
X631 N2640 S_exp_10b[4] N167 _NC1347 _NC1348 AND2X1
X632 N151 N53 N2630 _NC1349 _NC1350 AND2X1
X633 N145 N53 N2630 N172 _NC1351 _NC1352 AO21X1
X634 N146 N53 N2630 N173 _NC1353 _NC1354 AO21X1
X635 N147 N53 N2630 N174 _NC1355 _NC1356 AO21X1
X636 N148 N53 N2630 N175 _NC1357 _NC1358 AO21X1
X637 N149 N53 N2630 N176 _NC1359 _NC1360 AO21X1
X638 N150 N53 N2630 N177 _NC1361 _NC1362 AO21X1
X639 N30 N28 S_shr1[3] N2620 _NC1363 _NC1364 OR3X1
X640 S_shr1[2] S_shr1[1] S_shr1[0] N2620 N2610 _NC1365 _NC1366 NOR4X0
X641 N184 N24 N211 N23 N238 _NC1367 _NC1368 AO22X1
X642 N185 N25 N212 N23 N239 _NC1369 _NC1370 AO22X1
X643 N186 N25 N213 N23 N240 _NC1371 _NC1372 AO22X1
X644 N187 N25 N214 N23 N241 _NC1373 _NC1374 AO22X1
X645 N188 N25 N215 N23 N242 _NC1375 _NC1376 AO22X1
X646 N189 N25 N216 N23 N243 _NC1377 _NC1378 AO22X1
X647 N190 N25 N217 N23 N244 _NC1379 _NC1380 AO22X1
X648 N191 N25 N218 N23 N245 _NC1381 _NC1382 AO22X1
X649 N192 N25 N219 N23 N246 _NC1383 _NC1384 AO22X1
X650 N193 N24 N220 N23 N247 _NC1385 _NC1386 AO22X1
X651 N194 N24 N221 N23 N248 _NC1387 _NC1388 AO22X1
X652 N195 N24 N222 N23 N249 _NC1389 _NC1390 AO22X1
X653 N196 N24 N223 N2610 N250 _NC1391 _NC1392 AO22X1
X654 N197 N24 N224 N2610 N251 _NC1393 _NC1394 AO22X1
X655 N198 N24 N225 N2610 N252 _NC1395 _NC1396 AO22X1
X656 N199 N24 N226 N2610 N253 _NC1397 _NC1398 AO22X1
X657 N200 N24 N227 N2610 N254 _NC1399 _NC1400 AO22X1
X658 N201 N24 N228 N2610 N255 _NC1401 _NC1402 AO22X1
X659 N202 N24 N229 N2610 N256 _NC1403 _NC1404 AO22X1
X660 N203 N24 N230 N2610 N257 _NC1405 _NC1406 AO22X1
X661 N204 N24 N231 N2610 N258 _NC1407 _NC1408 AO22X1
X662 N205 N24 N232 N2610 N259 _NC1409 _NC1410 AO22X1
X663 N206 N24 N233 N2610 N260 _NC1411 _NC1412 AO22X1
X664 N207 N24 N234 N2610 N261 _NC1413 _NC1414 AO22X1
X665 N208 N24 N235 N2610 N262 _NC1415 _NC1416 AO22X1
X666 N209 N24 N236 N23 N263 _NC1417 _NC1418 AO22X1
X667 N210 N24 N237 N23 N264 _NC1419 _NC1420 AO22X1
X668 N113 S_qutnt_i[1] N2160 _NC1421 _NC1422 XNOR2X1
X669 N112 N2160 N2600 _NC1423 _NC1424 XNOR2X1
X670 N2600 S_qutnt_i[3] N295 _NC1425 _NC1426 XOR2X1
X671 N2160 N112 N1990 N2590 _NC1427 _NC1428 AO21X1
X672 N2580 N2590 N2030 _NC1429 _NC1430 XNOR2X1
X673 N2580 N2590 N297 _NC1431 _NC1432 AND2X1
X674 N304 N108 S_qutnt_i[4] N295 N309 _NC1433 _NC1434 AO22X1
X675 N305 N108 S_qutnt_i[4] Add_105_I5_L07002_C191_A[1] N310 _NC1435 _NC1436 AO22X1
X676 N306 N108 S_qutnt_i[4] N297 N311 _NC1437 _NC1438 AO22X1
X677 N307 N108 N312 _NC1439 _NC1440 AND2X1
X678 N319 N106 S_qutnt_i[5] N309 N325 _NC1441 _NC1442 AO22X1
X679 N320 N106 S_qutnt_i[5] N310 N326 _NC1443 _NC1444 AO22X1
X680 N321 N106 S_qutnt_i[5] N311 N327 _NC1445 _NC1446 AO22X1
X681 N322 N106 N312 S_qutnt_i[5] N328 _NC1447 _NC1448 AO22X1
X682 N336 N105 S_qutnt_i[6] N325 N342 _NC1449 _NC1450 AO22X1
X683 N337 N105 S_qutnt_i[6] N326 N343 _NC1451 _NC1452 AO22X1
X684 N338 N105 S_qutnt_i[6] N327 N344 _NC1453 _NC1454 AO22X1
X685 N339 N105 S_qutnt_i[6] N328 N345 _NC1455 _NC1456 AO22X1
X686 N340 N105 S_qutnt_i[6] N329 N346 _NC1457 _NC1458 AO22X1
X687 N353 N104 S_qutnt_i[7] N342 N359 _NC1459 _NC1460 AO22X1
X688 N354 N104 S_qutnt_i[7] N343 N360 _NC1461 _NC1462 AO22X1
X689 N355 N104 S_qutnt_i[7] N344 N361 _NC1463 _NC1464 AO22X1
X690 N356 N104 S_qutnt_i[7] N345 N362 _NC1465 _NC1466 AO22X1
X691 N357 N104 S_qutnt_i[7] N346 N363 _NC1467 _NC1468 AO22X1
X692 N358 N104 S_qutnt_i[7] N68 N364 _NC1469 _NC1470 AO22X1
X693 N370 N103 S_qutnt_i[8] N359 N376 _NC1471 _NC1472 AO22X1
X694 N371 N103 S_qutnt_i[8] N360 N377 _NC1473 _NC1474 AO22X1
X695 N372 N103 S_qutnt_i[8] N361 N378 _NC1475 _NC1476 AO22X1
X696 N373 N103 S_qutnt_i[8] N362 N379 _NC1477 _NC1478 AO22X1
X697 N374 N103 S_qutnt_i[8] N363 N380 _NC1479 _NC1480 AO22X1
X698 N375 N103 S_qutnt_i[8] N364 N381 _NC1481 _NC1482 AO22X1
X699 N387 N101 S_qutnt_i[9] N376 N393 _NC1483 _NC1484 AO22X1
X700 N388 N101 S_qutnt_i[9] N377 N394 _NC1485 _NC1486 AO22X1
X701 N389 N101 S_qutnt_i[9] N378 N395 _NC1487 _NC1488 AO22X1
X702 N390 N101 S_qutnt_i[9] N379 N396 _NC1489 _NC1490 AO22X1
X703 N391 N101 S_qutnt_i[9] N380 N397 _NC1491 _NC1492 AO22X1
X704 N392 N101 S_qutnt_i[9] N381 N398 _NC1493 _NC1494 AO22X1
X705 N404 N100 S_qutnt_i[10] N393 N410 _NC1495 _NC1496 AO22X1
X706 N405 N100 S_qutnt_i[10] N394 N411 _NC1497 _NC1498 AO22X1
X707 N406 N100 S_qutnt_i[10] N395 N412 _NC1499 _NC1500 AO22X1
X708 N407 N100 S_qutnt_i[10] N396 N413 _NC1501 _NC1502 AO22X1
X709 N408 N100 S_qutnt_i[10] N397 N414 _NC1503 _NC1504 AO22X1
X710 N409 N100 S_qutnt_i[10] N398 N415 _NC1505 _NC1506 AO22X1
X711 N421 N99 S_qutnt_i[11] N410 N427 _NC1507 _NC1508 AO22X1
X712 N422 N99 S_qutnt_i[11] N411 N428 _NC1509 _NC1510 AO22X1
X713 N423 N99 S_qutnt_i[11] N412 N429 _NC1511 _NC1512 AO22X1
X714 N424 N99 S_qutnt_i[11] N413 N430 _NC1513 _NC1514 AO22X1
X715 N425 N99 S_qutnt_i[11] N414 N431 _NC1515 _NC1516 AO22X1
X716 N426 N99 S_qutnt_i[11] N415 N432 _NC1517 _NC1518 AO22X1
X717 N438 N98 S_qutnt_i[12] N427 N444 _NC1519 _NC1520 AO22X1
X718 N439 N98 S_qutnt_i[12] N428 N445 _NC1521 _NC1522 AO22X1
X719 N440 N98 S_qutnt_i[12] N429 N446 _NC1523 _NC1524 AO22X1
X720 N441 N98 S_qutnt_i[12] N430 N447 _NC1525 _NC1526 AO22X1
X721 N442 N98 S_qutnt_i[12] N431 N448 _NC1527 _NC1528 AO22X1
X722 N443 N98 S_qutnt_i[12] N432 N449 _NC1529 _NC1530 AO22X1
X723 N455 N97 S_qutnt_i[13] N444 N461 _NC1531 _NC1532 AO22X1
X724 N456 N97 S_qutnt_i[13] N445 N462 _NC1533 _NC1534 AO22X1
X725 N457 N97 S_qutnt_i[13] N446 N463 _NC1535 _NC1536 AO22X1
X726 N458 N97 S_qutnt_i[13] N447 N464 _NC1537 _NC1538 AO22X1
X727 N459 N97 S_qutnt_i[13] N448 N465 _NC1539 _NC1540 AO22X1
X728 N460 N97 S_qutnt_i[13] N449 N466 _NC1541 _NC1542 AO22X1
X729 N472 N96 S_qutnt_i[14] N461 N478 _NC1543 _NC1544 AO22X1
X730 N473 N96 S_qutnt_i[14] N462 N479 _NC1545 _NC1546 AO22X1
X731 N474 N96 S_qutnt_i[14] N463 N480 _NC1547 _NC1548 AO22X1
X732 N475 N96 S_qutnt_i[14] N464 N481 _NC1549 _NC1550 AO22X1
X733 N476 N96 S_qutnt_i[14] N465 N482 _NC1551 _NC1552 AO22X1
X734 N477 N96 S_qutnt_i[14] N466 N483 _NC1553 _NC1554 AO22X1
X735 N489 N95 S_qutnt_i[15] N478 N495 _NC1555 _NC1556 AO22X1
X736 N490 N95 S_qutnt_i[15] N479 N496 _NC1557 _NC1558 AO22X1
X737 N491 N95 S_qutnt_i[15] N480 N497 _NC1559 _NC1560 AO22X1
X738 N492 N95 S_qutnt_i[15] N481 N498 _NC1561 _NC1562 AO22X1
X739 N493 N95 S_qutnt_i[15] N482 N499 _NC1563 _NC1564 AO22X1
X740 N494 N95 S_qutnt_i[15] N483 N500 _NC1565 _NC1566 AO22X1
X741 N506 N94 S_qutnt_i[16] N495 N512 _NC1567 _NC1568 AO22X1
X742 N507 N94 S_qutnt_i[16] N496 N513 _NC1569 _NC1570 AO22X1
X743 N508 N94 S_qutnt_i[16] N497 N514 _NC1571 _NC1572 AO22X1
X744 N509 N94 S_qutnt_i[16] N498 N515 _NC1573 _NC1574 AO22X1
X745 N510 N94 S_qutnt_i[16] N499 N516 _NC1575 _NC1576 AO22X1
X746 N511 N94 S_qutnt_i[16] N500 N517 _NC1577 _NC1578 AO22X1
X747 N523 N93 S_qutnt_i[17] N512 N529 _NC1579 _NC1580 AO22X1
X748 N524 N93 S_qutnt_i[17] N513 N530 _NC1581 _NC1582 AO22X1
X749 N525 N93 S_qutnt_i[17] N514 N531 _NC1583 _NC1584 AO22X1
X750 N526 N93 S_qutnt_i[17] N515 N532 _NC1585 _NC1586 AO22X1
X751 N527 N93 S_qutnt_i[17] N516 N533 _NC1587 _NC1588 AO22X1
X752 N528 N93 S_qutnt_i[17] N517 N534 _NC1589 _NC1590 AO22X1
X753 N540 N86 S_qutnt_i[18] N529 N546 _NC1591 _NC1592 AO22X1
X754 N541 N86 S_qutnt_i[18] N530 N547 _NC1593 _NC1594 AO22X1
X755 N542 N86 S_qutnt_i[18] N531 N548 _NC1595 _NC1596 AO22X1
X756 N543 N86 S_qutnt_i[18] N532 N549 _NC1597 _NC1598 AO22X1
X757 N544 N86 S_qutnt_i[18] N533 N550 _NC1599 _NC1600 AO22X1
X758 N545 N86 S_qutnt_i[18] N534 N551 _NC1601 _NC1602 AO22X1
X759 N557 N79 S_qutnt_i[19] N546 N563 _NC1603 _NC1604 AO22X1
X760 N558 N79 S_qutnt_i[19] N547 N564 _NC1605 _NC1606 AO22X1
X761 N559 N79 S_qutnt_i[19] N548 N565 _NC1607 _NC1608 AO22X1
X762 N560 N79 S_qutnt_i[19] N549 N566 _NC1609 _NC1610 AO22X1
X763 N561 N79 S_qutnt_i[19] N550 N567 _NC1611 _NC1612 AO22X1
X764 N562 N79 S_qutnt_i[19] N551 N568 _NC1613 _NC1614 AO22X1
X765 N574 N71 S_qutnt_i[20] N563 N580 _NC1615 _NC1616 AO22X1
X766 N575 N71 S_qutnt_i[20] N564 N581 _NC1617 _NC1618 AO22X1
X767 N576 N71 S_qutnt_i[20] N565 N582 _NC1619 _NC1620 AO22X1
X768 N577 N71 S_qutnt_i[20] N566 N583 _NC1621 _NC1622 AO22X1
X769 N578 N71 S_qutnt_i[20] N567 N584 _NC1623 _NC1624 AO22X1
X770 N579 N71 S_qutnt_i[20] N568 N585 _NC1625 _NC1626 AO22X1
X771 N91 N64 S_qutnt_i[21] N580 N597 _NC1627 _NC1628 AO22X1
X772 N592 N64 S_qutnt_i[21] N581 N598 _NC1629 _NC1630 AO22X1
X773 N593 N64 S_qutnt_i[21] N582 N599 _NC1631 _NC1632 AO22X1
X774 N594 N64 S_qutnt_i[21] N583 N600 _NC1633 _NC1634 AO22X1
X775 N595 N64 S_qutnt_i[21] N584 N601 _NC1635 _NC1636 AO22X1
X776 N596 N64 S_qutnt_i[21] N585 N602 _NC1637 _NC1638 AO22X1
X777 N608 N63 S_qutnt_i[22] N597 N614 _NC1639 _NC1640 AO22X1
X778 N609 N63 S_qutnt_i[22] N598 N615 _NC1641 _NC1642 AO22X1
X779 N610 N63 S_qutnt_i[22] N599 N616 _NC1643 _NC1644 AO22X1
X780 N611 N63 S_qutnt_i[22] N600 N617 _NC1645 _NC1646 AO22X1
X781 N612 N63 S_qutnt_i[22] N601 N618 _NC1647 _NC1648 AO22X1
X782 N613 N63 S_qutnt_i[22] N602 N619 _NC1649 _NC1650 AO22X1
X783 N625 N62 S_qutnt_i[23] N614 N631 _NC1651 _NC1652 AO22X1
X784 N626 N62 S_qutnt_i[23] N615 N632 _NC1653 _NC1654 AO22X1
X785 N627 N62 S_qutnt_i[23] N616 N633 _NC1655 _NC1656 AO22X1
X786 N628 N62 S_qutnt_i[23] N617 N634 _NC1657 _NC1658 AO22X1
X787 N629 N62 S_qutnt_i[23] N618 N635 _NC1659 _NC1660 AO22X1
X788 N630 N62 S_qutnt_i[23] N619 N636 _NC1661 _NC1662 AO22X1
X789 N642 N61 S_qutnt_i[24] N631 N648 _NC1663 _NC1664 AO22X1
X790 N643 N61 S_qutnt_i[24] N632 N649 _NC1665 _NC1666 AO22X1
X791 N644 N61 S_qutnt_i[24] N633 N650 _NC1667 _NC1668 AO22X1
X792 N645 N61 S_qutnt_i[24] N634 N651 _NC1669 _NC1670 AO22X1
X793 N646 N61 S_qutnt_i[24] N635 N652 _NC1671 _NC1672 AO22X1
X794 N647 N61 S_qutnt_i[24] N636 N653 _NC1673 _NC1674 AO22X1
X795 N659 N60 S_qutnt_i[25] N648 N665 _NC1675 _NC1676 AO22X1
X796 N660 N60 S_qutnt_i[25] N649 N666 _NC1677 _NC1678 AO22X1
X797 N661 N60 S_qutnt_i[25] N650 N667 _NC1679 _NC1680 AO22X1
X798 N662 N60 S_qutnt_i[25] N651 N668 _NC1681 _NC1682 AO22X1
X799 N663 N60 S_qutnt_i[25] N652 N669 _NC1683 _NC1684 AO22X1
X800 N664 N60 S_qutnt_i[25] N653 N670 _NC1685 _NC1686 AO22X1
X801 N2500 N2520 N76 N2490 _NC1687 _NC1688 NOR3X0
X802 S_fraco2[0] N16 S_output_o[0] _NC1689 _NC1690 AND2X1
X803 S_fraco2[10] N2450 S_output_o[10] _NC1691 _NC1692 AND2X1
X804 S_fraco2[11] N16 S_output_o[11] _NC1693 _NC1694 AND2X1
X805 S_fraco2[12] N2450 S_output_o[12] _NC1695 _NC1696 AND2X1
X806 S_fraco2[13] N16 S_output_o[13] _NC1697 _NC1698 AND2X1
X807 S_fraco2[14] N2450 S_output_o[14] _NC1699 _NC1700 AND2X1
X808 S_fraco2[15] N16 S_output_o[15] _NC1701 _NC1702 AND2X1
X809 S_fraco2[16] N2450 S_output_o[16] _NC1703 _NC1704 AND2X1
X810 S_fraco2[17] N16 S_output_o[17] _NC1705 _NC1706 AND2X1
X811 S_fraco2[18] N2450 S_output_o[18] _NC1707 _NC1708 AND2X1
X812 S_fraco2[19] N16 S_output_o[19] _NC1709 _NC1710 AND2X1
X813 S_fraco2[1] N2450 S_output_o[1] _NC1711 _NC1712 AND2X1
X814 S_fraco2[20] N16 S_output_o[20] _NC1713 _NC1714 AND2X1
X815 S_fraco2[21] N2450 S_output_o[21] _NC1715 _NC1716 AND2X1
X816 N2560 N2500 N2530 _NC1717 _NC1718 OR2X1
X817 N2500 N2510 N2520 N2530 N2540 N2550 N2460 _NC1719 _NC1720 AOI222X1
X818 N2470 N2490 S_fraco2[22] N2480 _NC1721 _NC1722 NAND3X0
X819 S_fraco2[2] N16 S_output_o[2] _NC1723 _NC1724 AND2X1
X820 S_fraco2[3] N2450 S_output_o[3] _NC1725 _NC1726 AND2X1
X821 S_fraco2[4] N16 S_output_o[4] _NC1727 _NC1728 AND2X1
X822 S_fraco2[5] N2450 S_output_o[5] _NC1729 _NC1730 AND2X1
X823 S_fraco2[6] N16 S_output_o[6] _NC1731 _NC1732 AND2X1
X824 S_fraco2[7] N2450 S_output_o[7] _NC1733 _NC1734 AND2X1
X825 S_fraco2[8] N16 S_output_o[8] _NC1735 _NC1736 AND2X1
X826 S_fraco2[9] N2450 S_output_o[9] _NC1737 _NC1738 AND2X1
X827 N3290 N2220 N159 _NC1739 _NC1740 AND2X1
X828 N2260 N2270 N135 _NC1741 _NC1742 AND2X1
X829 N2430 N2440 N153 _NC1743 _NC1744 OR2X1
X830 N557 N153 N574 N154 N2310 _NC1745 _NC1746 OA22X1
X831 N495 S_qutnt_i[15] N512 N152 N2320 _NC1747 _NC1748 AOI22X1
X832 N60 Sub_1_root_sub_150_2_CI N2390 N2400 _NC1749 _NC1750 NAND3X0
X833 N2390 N2400 N1510 _NC1751 _NC1752 AND2X1
X834 N676 N77 N1500 N648 N1510 N665 N2350 _NC1753 _NC1754 AO222X1
X835 N2370 N2380 N1490 _NC1755 _NC1756 AND2X1
X836 N1480 N614 S_qutnt_i[21] N597 N1490 N631 N2360 _NC1757 _NC1758 AO222X1
X837 N540 N142 N91 N143 N2340 N1450 N2330 _NC1759 _NC1760 OA222X1
X838 N2310 N2320 N2330 N2300 _NC1761 _NC1762 NAND3X0
X839 N135 N427 N136 N478 N137 N2300 N2230 _NC1763 _NC1764 AOI222X1
X840 N2280 N2290 N157 _NC1765 _NC1766 AND2X1
X841 N393 S_qutnt_i[9] N410 N155 N2250 _NC1767 _NC1768 AO22X1
X842 N461 N157 N444 N156 N2250 N2240 _NC1769 _NC1770 AOI221X1
X843 N2230 N2240 N3230 N2180 _NC1771 _NC1772 AO21X1
X844 N2200 N2210 N130 _NC1773 _NC1774 AND2X1
X845 N376 N126 N342 N131 N359 N130 N2190 _NC1775 _NC1776 AOI222X1
X846 N2170 N2180 N304 N2190 N2150 _NC1777 _NC1778 NAND4X0
X847 N330 N2150 N2160 N113 S_r_zeros[0] _NC1779 _NC1780 AO22X1
X848 N116 N153 N110 N154 N2090 _NC1781 _NC1782 OA22X1
X849 N496 S_qutnt_i[15] N513 N152 N2100 _NC1783 _NC1784 AOI22X1
X850 N677 N77 N1500 N649 N1510 N666 N2130 _NC1785 _NC1786 AO222X1
X851 N1480 N615 S_qutnt_i[21] N598 N1490 N632 N2140 _NC1787 _NC1788 AO222X1
X852 N299 N142 N90 N143 N2120 N1450 N2110 _NC1789 _NC1790 OA222X1
X853 N2090 N2100 N2110 N2080 _NC1791 _NC1792 NAND3X0
X854 N135 N428 N136 N479 N137 N2080 N2050 _NC1793 _NC1794 AOI222X1
X855 N394 S_qutnt_i[9] N411 N155 N2070 _NC1795 _NC1796 AO22X1
X856 N462 N157 N445 N156 N2070 N2060 _NC1797 _NC1798 AOI221X1
X857 N2050 N2060 N3230 N2020 _NC1799 _NC1800 AO21X1
X858 N377 N126 N343 N131 N360 N130 N2040 _NC1801 _NC1802 AOI222X1
X859 N2010 N2020 N2030 N2040 N1980 _NC1803 _NC1804 NAND4X0
X860 N155 N412 S_qutnt_i[9] N395 N1970 _NC1805 _NC1806 AO22X1
X861 N156 N446 N157 N463 N1970 N1880 _NC1807 _NC1808 AO221X1
X862 N115 N153 N109 N154 N1910 _NC1809 _NC1810 OA22X1
X863 N497 S_qutnt_i[15] N514 N152 N1920 _NC1811 _NC1812 AOI22X1
X864 N678 N77 N1500 N650 N1510 N667 N1950 _NC1813 _NC1814 AO222X1
X865 N1480 N616 S_qutnt_i[21] N599 N1490 N633 N1960 _NC1815 _NC1816 AO222X1
X866 N125 N142 N89 N143 N1940 N1450 N1930 _NC1817 _NC1818 OA222X1
X867 N1910 N1920 N1930 N1900 _NC1819 _NC1820 NAND3X0
X868 N137 N1900 N136 N480 N135 N429 N1890 _NC1821 _NC1822 AO222X1
X869 N1880 N1890 N1870 _NC1823 _NC1824 OR2X1
X870 N327 N159 N378 N126 N1870 N127 N183 _NC1825 _NC1826 AOI222X1
X871 N361 N130 N1850 N1860 N344 N131 N1840 _NC1827 _NC1828 AOI222X1
X872 N447 N156 N464 N157 N1730 _NC1829 _NC1830 AOI22X1
X873 N396 S_qutnt_i[9] N413 N155 N1740 _NC1831 _NC1832 AOI22X1
X874 N114 N153 N107 N154 N1770 _NC1833 _NC1834 OA22X1
X875 N498 S_qutnt_i[15] N515 N152 N178 _NC1835 _NC1836 AOI22X1
X876 N679 N77 N1500 N651 N1510 N668 N181 _NC1837 _NC1838 AO222X1
X877 N1480 N617 S_qutnt_i[21] N600 N1490 N634 N182 _NC1839 _NC1840 AO222X1
X878 N121 N142 N88 N143 N180 N1450 N179 _NC1841 _NC1842 OA222X1
X879 N1770 N178 N179 N1760 _NC1843 _NC1844 NAND3X0
X880 N135 N430 N136 N481 N137 N1760 N1750 _NC1845 _NC1846 AOI222X1
X881 N1730 N1740 N1750 N171 _NC1847 _NC1848 NAND3X0
X882 N130 N362 N131 N345 N126 N379 N1720 _NC1849 _NC1850 AO222X1
X883 N448 N156 N465 N157 N1610 _NC1851 _NC1852 AOI22X1
X884 N397 S_qutnt_i[9] N414 N155 N1620 _NC1853 _NC1854 AOI22X1
X885 N72 N153 N70 N154 N165 _NC1855 _NC1856 OA22X1
X886 N499 S_qutnt_i[15] N516 N152 N1660 _NC1857 _NC1858 AOI22X1
X887 N680 N77 N1500 N652 N1510 N669 N169 _NC1859 _NC1860 AO222X1
X888 N1480 N618 S_qutnt_i[21] N601 N1490 N635 N170 _NC1861 _NC1862 AO222X1
X889 N73 N142 N69 N143 N168 N1450 N1670 _NC1863 _NC1864 OA222X1
X890 N165 N1660 N1670 N164 _NC1865 _NC1866 NAND3X0
X891 N135 N431 N136 N482 N137 N164 N163 _NC1867 _NC1868 AOI222X1
X892 N1610 N1620 N163 N158 _NC1869 _NC1870 NAND3X0
X893 N130 N363 N131 N346 N126 N380 N160 _NC1871 _NC1872 AO222X1
X894 N449 N156 N466 N157 N132 _NC1873 _NC1874 AOI22X1
X895 N398 S_qutnt_i[9] N415 N155 N133 _NC1875 _NC1876 AOI22X1
X896 N66 N153 N65 N154 N139 _NC1877 _NC1878 OA22X1
X897 N500 S_qutnt_i[15] N517 N152 N140 _NC1879 _NC1880 AOI22X1
X898 N681 N77 N1500 N653 N1510 N670 N1460 _NC1881 _NC1882 AO222X1
X899 N1480 N619 S_qutnt_i[21] N602 N1490 N636 N1470 _NC1883 _NC1884 AO222X1
X900 N67 N142 N59 N143 N144 N1450 N141 _NC1885 _NC1886 OA222X1
X901 N139 N140 N141 N138 _NC1887 _NC1888 NAND3X0
X902 N135 N432 N136 N483 N137 N138 N134 _NC1889 _NC1890 AOI222X1
X903 N132 N133 N134 N128 _NC1891 _NC1892 NAND3X0
X904 N130 N364 N131 N68 N129 _NC1893 _NC1894 AO22X1
X905 Clk_i N2470 Output_o[23] _NC1895 S_expo3[0] N2490 _NC1896 _NC1897 DFFSSRX1
X906 Clk_i S_output_o[0] Output_o[0] _NC1898 _NC1899 _NC1900 DFFX1
X907 Clk_i S_output_o[10] Output_o[10] _NC1901 _NC1902 _NC1903 DFFX1
X908 Clk_i S_output_o[11] Output_o[11] _NC1904 _NC1905 _NC1906 DFFX1
X909 Clk_i S_output_o[12] Output_o[12] _NC1907 _NC1908 _NC1909 DFFX1
X910 Clk_i S_output_o[13] Output_o[13] _NC1910 _NC1911 _NC1912 DFFX1
X911 Clk_i S_output_o[14] Output_o[14] _NC1913 _NC1914 _NC1915 DFFX1
X912 Clk_i S_output_o[15] Output_o[15] _NC1916 _NC1917 _NC1918 DFFX1
X913 Clk_i S_output_o[16] Output_o[16] _NC1919 _NC1920 _NC1921 DFFX1
X914 Clk_i S_output_o[17] Output_o[17] _NC1922 _NC1923 _NC1924 DFFX1
X915 Clk_i S_output_o[18] Output_o[18] _NC1925 _NC1926 _NC1927 DFFX1
X916 Clk_i S_output_o[19] Output_o[19] _NC1928 _NC1929 _NC1930 DFFX1
X917 Clk_i S_output_o[1] Output_o[1] _NC1931 _NC1932 _NC1933 DFFX1
X918 Clk_i S_output_o[20] Output_o[20] _NC1934 _NC1935 _NC1936 DFFX1
X919 Clk_i S_output_o[21] Output_o[21] _NC1937 _NC1938 _NC1939 DFFX1
X920 Clk_i S_output_o[2] Output_o[2] _NC1940 _NC1941 _NC1942 DFFX1
X921 Clk_i S_output_o[3] Output_o[3] _NC1943 _NC1944 _NC1945 DFFX1
X922 Clk_i S_output_o[4] Output_o[4] _NC1946 _NC1947 _NC1948 DFFX1
X923 Clk_i S_output_o[5] Output_o[5] _NC1949 _NC1950 _NC1951 DFFX1
X924 Clk_i S_output_o[6] Output_o[6] _NC1952 _NC1953 _NC1954 DFFX1
X925 Clk_i S_output_o[7] Output_o[7] _NC1955 _NC1956 _NC1957 DFFX1
X926 Clk_i S_output_o[8] Output_o[8] _NC1958 _NC1959 _NC1960 DFFX1
X927 Clk_i S_output_o[9] Output_o[9] _NC1961 _NC1962 _NC1963 DFFX1
X928 Clk_i N2470 Output_o[30] _NC1964 S_expo3[7] N2490 _NC1965 _NC1966 DFFSSRX1
X929 Clk_i N2470 Output_o[29] _NC1967 S_expo3[6] N2490 _NC1968 _NC1969 DFFSSRX1
X930 Clk_i N2470 Output_o[28] _NC1970 S_expo3[5] N2490 _NC1971 _NC1972 DFFSSRX1
X931 Clk_i N2470 Output_o[27] _NC1973 S_expo3[4] N2490 _NC1974 _NC1975 DFFSSRX1
X932 Clk_i N2470 Output_o[26] _NC1976 S_expo3[3] N2490 _NC1977 _NC1978 DFFSSRX1
X933 Clk_i N2470 Output_o[25] _NC1979 S_expo3[2] N2490 _NC1980 _NC1981 DFFSSRX1
X934 Clk_i N2470 Output_o[24] _NC1982 S_expo3[1] N2490 _NC1983 _NC1984 DFFSSRX1
X935 Clk_i S_output_o[22] Output_o[22] _NC1985 _NC1986 _NC1987 DFFX1
X936 Clk_i N1386 Ine_o _NC1988 _NC1989 _NC1990 DFFX1
X937 Clk_i N1100 S_expo3[0] _NC1991 _NC1992 _NC1993 DFFX1
X938 Clk_i N1101 S_expo3[1] _NC1994 _NC1995 _NC1996 DFFX1
X939 Clk_i N1102 S_expo3[2] _NC1997 _NC1998 _NC1999 DFFX1
X940 Clk_i N1103 S_expo3[3] _NC2000 _NC2001 _NC2002 DFFX1
X941 Clk_i N1104 S_expo3[4] _NC2003 _NC2004 _NC2005 DFFX1
X942 Clk_i N1105 S_expo3[5] _NC2006 _NC2007 _NC2008 DFFX1
X943 Clk_i N1106 S_expo3[6] _NC2009 _NC2010 _NC2011 DFFX1
X944 Clk_i N1107 S_expo3[7] _NC2012 _NC2013 _NC2014 DFFX1
X945 Clk_i N1108 S_expo3[8] _NC2015 _NC2016 _NC2017 DFFX1
X946 Clk_i N1109 S_fraco2[0] _NC2018 _NC2019 _NC2020 DFFX1
X947 Clk_i N1110 S_fraco2[1] _NC2021 _NC2022 _NC2023 DFFX1
X948 Clk_i N1111 S_fraco2[2] _NC2024 _NC2025 _NC2026 DFFX1
X949 Clk_i N1112 S_fraco2[3] _NC2027 _NC2028 _NC2029 DFFX1
X950 Clk_i N1113 S_fraco2[4] _NC2030 _NC2031 _NC2032 DFFX1
X951 Clk_i N1114 S_fraco2[5] _NC2033 _NC2034 _NC2035 DFFX1
X952 Clk_i N1115 S_fraco2[6] _NC2036 _NC2037 _NC2038 DFFX1
X953 Clk_i N1116 S_fraco2[7] _NC2039 _NC2040 _NC2041 DFFX1
X954 Clk_i N1117 S_fraco2[8] _NC2042 _NC2043 _NC2044 DFFX1
X955 Clk_i N1118 S_fraco2[9] _NC2045 _NC2046 _NC2047 DFFX1
X956 Clk_i N1119 S_fraco2[10] _NC2048 _NC2049 _NC2050 DFFX1
X957 Clk_i N1120 S_fraco2[11] _NC2051 _NC2052 _NC2053 DFFX1
X958 Clk_i N1121 S_fraco2[12] _NC2054 _NC2055 _NC2056 DFFX1
X959 Clk_i N1122 S_fraco2[13] _NC2057 _NC2058 _NC2059 DFFX1
X960 Clk_i N1123 S_fraco2[14] _NC2060 _NC2061 _NC2062 DFFX1
X961 Clk_i N1124 S_fraco2[15] _NC2063 _NC2064 _NC2065 DFFX1
X962 Clk_i N1125 S_fraco2[16] _NC2066 _NC2067 _NC2068 DFFX1
X963 Clk_i N1126 S_fraco2[17] _NC2069 _NC2070 _NC2071 DFFX1
X964 Clk_i N1127 S_fraco2[18] _NC2072 _NC2073 _NC2074 DFFX1
X965 Clk_i N1128 S_fraco2[19] _NC2075 _NC2076 _NC2077 DFFX1
X966 Clk_i N1129 S_fraco2[20] _NC2078 _NC2079 _NC2080 DFFX1
X967 Clk_i N1130 S_fraco2[21] _NC2081 _NC2082 _NC2083 DFFX1
X968 Clk_i N1131 S_fraco2[22] _NC2084 _NC2085 _NC2086 DFFX1
X969 Clk_i N238 S_fraco1[0] _NC2087 _NC2088 _NC2089 DFFX1
X970 Clk_i N239 _NC2090 N124 _NC2091 _NC2092 DFFX1
X971 Clk_i N240 S_fraco1[2] N123 _NC2093 _NC2094 DFFX1
X972 Clk_i N241 S_fraco1[3] N122 _NC2095 _NC2096 DFFX1
X973 Clk_i N242 S_fraco1[4] _NC2097 _NC2098 _NC2099 DFFX1
X974 Clk_i N243 S_fraco1[5] _NC2100 _NC2101 _NC2102 DFFX1
X975 Clk_i N244 S_fraco1[6] _NC2103 _NC2104 _NC2105 DFFX1
X976 Clk_i N245 S_fraco1[7] _NC2106 _NC2107 _NC2108 DFFX1
X977 Clk_i N246 S_fraco1[8] _NC2109 _NC2110 _NC2111 DFFX1
X978 Clk_i N247 S_fraco1[9] _NC2112 _NC2113 _NC2114 DFFX1
X979 Clk_i N248 S_fraco1[10] _NC2115 _NC2116 _NC2117 DFFX1
X980 Clk_i N249 S_fraco1[11] _NC2118 _NC2119 _NC2120 DFFX1
X981 Clk_i N250 S_fraco1[12] _NC2121 _NC2122 _NC2123 DFFX1
X982 Clk_i N251 S_fraco1[13] _NC2124 _NC2125 _NC2126 DFFX1
X983 Clk_i N252 S_fraco1[14] _NC2127 _NC2128 _NC2129 DFFX1
X984 Clk_i N253 S_fraco1[15] _NC2130 _NC2131 _NC2132 DFFX1
X985 Clk_i N254 S_fraco1[16] _NC2133 _NC2134 _NC2135 DFFX1
X986 Clk_i N255 S_fraco1[17] _NC2136 _NC2137 _NC2138 DFFX1
X987 Clk_i N256 S_fraco1[18] _NC2139 _NC2140 _NC2141 DFFX1
X988 Clk_i N257 S_fraco1[19] _NC2142 _NC2143 _NC2144 DFFX1
X989 Clk_i N258 S_fraco1[20] _NC2145 _NC2146 _NC2147 DFFX1
X990 Clk_i N259 S_fraco1[21] _NC2148 _NC2149 _NC2150 DFFX1
X991 Clk_i N260 S_fraco1[22] _NC2151 _NC2152 _NC2153 DFFX1
X992 Clk_i N261 S_fraco1[23] _NC2154 _NC2155 _NC2156 DFFX1
X993 Clk_i N262 S_fraco1[24] _NC2157 _NC2158 _NC2159 DFFX1
X994 Clk_i N263 S_fraco1[25] _NC2160 _NC2161 _NC2162 DFFX1
X995 Clk_i N264 S_fraco1[26] _NC2163 _NC2164 _NC2165 DFFX1
X996 Clk_i N161 S_shl1[0] _NC2166 _NC2167 _NC2168 DFFX1
X997 Clk_i N172 S_shr1[0] N6 _NC2169 _NC2170 DFFX1
X998 Clk_i N173 S_shr1[1] N5 _NC2171 _NC2172 DFFX1
X999 Clk_i N174 S_shr1[2] N2 _NC2173 _NC2174 DFFX1
X1000 Clk_i N176 S_shr1[4] _NC2175 _NC2176 _NC2177 DFFX1
X1001 Clk_i N177 S_shr1[5] _NC2178 _NC2179 _NC2180 DFFX1
X1002 Clk_i N162 S_expo1[0] _NC2181 _NC2182 _NC2183 DFFX1
X1003 Clk_i N2640 S_expo1[1] _NC2184 S_exp_10b[0] Vdd _NC2185 _NC2186 DFFSSRX1
X1004 Clk_i N2640 S_expo1[2] _NC2187 S_exp_10b[1] Vdd _NC2188 _NC2189 DFFSSRX1
X1005 Clk_i N2640 S_expo1[3] _NC2190 S_exp_10b[2] Vdd _NC2191 _NC2192 DFFSSRX1
X1006 Clk_i N166 S_expo1[4] _NC2193 _NC2194 _NC2195 DFFX1
X1007 Clk_i N167 S_expo1[5] _NC2196 _NC2197 _NC2198 DFFX1
X1008 Clk_i N2640 S_expo1[6] _NC2199 S_exp_10b[5] Vdd _NC2200 _NC2201 DFFSSRX1
X1009 Clk_i N2640 S_expo1[7] _NC2202 S_exp_10b[6] Vdd _NC2203 _NC2204 DFFSSRX1
X1010 Clk_i N2640 S_expo1[8] _NC2205 S_exp_10b[7] Vdd _NC2206 _NC2207 DFFSSRX1
X1011 Clk_i S_output_o[31] Output_o[31] _NC2208 _NC2209 _NC2210 DFFX1
X1012 Clk_i Rmode_i[0] _NC2211 N119 _NC2212 _NC2213 DFFX1
X1013 Clk_i Rmode_i[1] S_rmode_i[1] N118 _NC2214 _NC2215 DFFX1
X1014 Clk_i Sign_i S_sign_i N117 _NC2216 _NC2217 DFFX1
X1015 Clk_i Exp_10_i[0] S_exp_10_i[0] _NC2218 _NC2219 _NC2220 DFFX1
X1016 Clk_i Exp_10_i[1] S_exp_10_i[1] _NC2221 _NC2222 _NC2223 DFFX1
X1017 Clk_i Exp_10_i[2] S_exp_10_i[2] _NC2224 _NC2225 _NC2226 DFFX1
X1018 Clk_i Exp_10_i[3] S_exp_10_i[3] _NC2227 _NC2228 _NC2229 DFFX1
X1019 Clk_i Exp_10_i[4] S_exp_10_i[4] _NC2230 _NC2231 _NC2232 DFFX1
X1020 Clk_i Exp_10_i[5] S_exp_10_i[5] _NC2233 _NC2234 _NC2235 DFFX1
X1021 Clk_i Exp_10_i[6] S_exp_10_i[6] _NC2236 _NC2237 _NC2238 DFFX1
X1022 Clk_i Exp_10_i[7] S_exp_10_i[7] _NC2239 _NC2240 _NC2241 DFFX1
X1023 Clk_i Exp_10_i[8] S_exp_10_i[8] _NC2242 _NC2243 _NC2244 DFFX1
X1024 Clk_i Exp_10_i[9] S_exp_10_i[9] _NC2245 _NC2246 _NC2247 DFFX1
X1025 Clk_i Rmndr_i[0] S_rmndr_i[0] _NC2248 _NC2249 _NC2250 DFFX1
X1026 Clk_i Rmndr_i[1] S_rmndr_i[1] _NC2251 _NC2252 _NC2253 DFFX1
X1027 Clk_i Rmndr_i[2] S_rmndr_i[2] _NC2254 _NC2255 _NC2256 DFFX1
X1028 Clk_i Rmndr_i[3] S_rmndr_i[3] _NC2257 _NC2258 _NC2259 DFFX1
X1029 Clk_i Rmndr_i[4] S_rmndr_i[4] _NC2260 _NC2261 _NC2262 DFFX1
X1030 Clk_i Rmndr_i[5] S_rmndr_i[5] _NC2263 _NC2264 _NC2265 DFFX1
X1031 Clk_i Rmndr_i[6] S_rmndr_i[6] _NC2266 _NC2267 _NC2268 DFFX1
X1032 Clk_i Rmndr_i[7] S_rmndr_i[7] _NC2269 _NC2270 _NC2271 DFFX1
X1033 Clk_i Rmndr_i[8] S_rmndr_i[8] _NC2272 _NC2273 _NC2274 DFFX1
X1034 Clk_i Rmndr_i[9] S_rmndr_i[9] _NC2275 _NC2276 _NC2277 DFFX1
X1035 Clk_i Rmndr_i[10] S_rmndr_i[10] _NC2278 _NC2279 _NC2280 DFFX1
X1036 Clk_i Rmndr_i[11] S_rmndr_i[11] _NC2281 _NC2282 _NC2283 DFFX1
X1037 Clk_i Rmndr_i[12] S_rmndr_i[12] _NC2284 _NC2285 _NC2286 DFFX1
X1038 Clk_i Rmndr_i[13] S_rmndr_i[13] _NC2287 _NC2288 _NC2289 DFFX1
X1039 Clk_i Rmndr_i[14] S_rmndr_i[14] _NC2290 _NC2291 _NC2292 DFFX1
X1040 Clk_i Rmndr_i[15] S_rmndr_i[15] _NC2293 _NC2294 _NC2295 DFFX1
X1041 Clk_i Rmndr_i[16] S_rmndr_i[16] _NC2296 _NC2297 _NC2298 DFFX1
X1042 Clk_i Rmndr_i[17] S_rmndr_i[17] _NC2299 _NC2300 _NC2301 DFFX1
X1043 Clk_i Rmndr_i[18] S_rmndr_i[18] _NC2302 _NC2303 _NC2304 DFFX1
X1044 Clk_i Rmndr_i[19] S_rmndr_i[19] _NC2305 _NC2306 _NC2307 DFFX1
X1045 Clk_i Rmndr_i[20] S_rmndr_i[20] _NC2308 _NC2309 _NC2310 DFFX1
X1046 Clk_i Rmndr_i[21] S_rmndr_i[21] _NC2311 _NC2312 _NC2313 DFFX1
X1047 Clk_i Rmndr_i[22] S_rmndr_i[22] _NC2314 _NC2315 _NC2316 DFFX1
X1048 Clk_i Rmndr_i[23] S_rmndr_i[23] _NC2317 _NC2318 _NC2319 DFFX1
X1049 Clk_i Rmndr_i[24] S_rmndr_i[24] _NC2320 _NC2321 _NC2322 DFFX1
X1050 Clk_i Rmndr_i[25] S_rmndr_i[25] _NC2323 _NC2324 _NC2325 DFFX1
X1051 Clk_i Rmndr_i[26] S_rmndr_i[26] _NC2326 _NC2327 _NC2328 DFFX1
X1052 Clk_i Qutnt_i[0] S_qutnt_i[0] N113 _NC2329 _NC2330 DFFX1
X1053 Clk_i Qutnt_i[1] S_qutnt_i[1] _NC2331 _NC2332 _NC2333 DFFX1
X1054 Clk_i Qutnt_i[2] S_qutnt_i[2] N112 _NC2334 _NC2335 DFFX1
X1055 Clk_i Qutnt_i[3] S_qutnt_i[3] _NC2336 _NC2337 _NC2338 DFFX1
X1056 Clk_i Qutnt_i[4] S_qutnt_i[4] N108 _NC2339 _NC2340 DFFX1
X1057 Clk_i Qutnt_i[5] S_qutnt_i[5] N106 _NC2341 _NC2342 DFFX1
X1058 Clk_i Qutnt_i[26] S_qutnt_i[26] Sub_1_root_sub_150_2_CI _NC2343 _NC2344 DFFX1
X1059 Clk_i Opb_i[23] S_expb[0] _NC2345 _NC2346 _NC2347 DFFX1
X1060 Clk_i Opb_i[24] S_expb[1] _NC2348 _NC2349 _NC2350 DFFX1
X1061 Clk_i Opb_i[25] S_expb[2] _NC2351 _NC2352 _NC2353 DFFX1
X1062 Clk_i Opb_i[26] S_expb[3] _NC2354 _NC2355 _NC2356 DFFX1
X1063 Clk_i Opb_i[27] S_expb[4] _NC2357 _NC2358 _NC2359 DFFX1
X1064 Clk_i Opb_i[28] S_expb[5] _NC2360 _NC2361 _NC2362 DFFX1
X1065 Clk_i Opb_i[29] S_expb[6] _NC2363 _NC2364 _NC2365 DFFX1
X1066 Clk_i Opb_i[30] S_expb[7] _NC2366 _NC2367 _NC2368 DFFX1
X1067 Clk_i Opa_i[23] S_expa[0] _NC2369 _NC2370 _NC2371 DFFX1
X1068 Clk_i Opa_i[24] S_expa[1] _NC2372 _NC2373 _NC2374 DFFX1
X1069 Clk_i Opa_i[25] S_expa[2] _NC2375 _NC2376 _NC2377 DFFX1
X1070 Clk_i Opa_i[26] S_expa[3] _NC2378 _NC2379 _NC2380 DFFX1
X1071 Clk_i Opa_i[27] S_expa[4] _NC2381 _NC2382 _NC2383 DFFX1
X1072 Clk_i Opa_i[28] S_expa[5] _NC2384 _NC2385 _NC2386 DFFX1
X1073 Clk_i Opa_i[29] S_expa[6] _NC2387 _NC2388 _NC2389 DFFX1
X1074 Clk_i Opa_i[30] S_expa[7] _NC2390 _NC2391 _NC2392 DFFX1
X1075 Clk_i Opb_i[0] S_opb_i[0] _NC2393 _NC2394 _NC2395 DFFX1
X1076 Clk_i Opb_i[1] S_opb_i[1] _NC2396 _NC2397 _NC2398 DFFX1
X1077 Clk_i Opb_i[2] S_opb_i[2] _NC2399 _NC2400 _NC2401 DFFX1
X1078 Clk_i Opb_i[3] S_opb_i[3] _NC2402 _NC2403 _NC2404 DFFX1
X1079 Clk_i Opb_i[4] S_opb_i[4] _NC2405 _NC2406 _NC2407 DFFX1
X1080 Clk_i Opb_i[5] S_opb_i[5] _NC2408 _NC2409 _NC2410 DFFX1
X1081 Clk_i Opb_i[6] S_opb_i[6] _NC2411 _NC2412 _NC2413 DFFX1
X1082 Clk_i Opb_i[7] S_opb_i[7] _NC2414 _NC2415 _NC2416 DFFX1
X1083 Clk_i Opb_i[8] S_opb_i[8] _NC2417 _NC2418 _NC2419 DFFX1
X1084 Clk_i Opb_i[9] S_opb_i[9] _NC2420 _NC2421 _NC2422 DFFX1
X1085 Clk_i Opb_i[10] S_opb_i[10] _NC2423 _NC2424 _NC2425 DFFX1
X1086 Clk_i Opb_i[11] S_opb_i[11] _NC2426 _NC2427 _NC2428 DFFX1
X1087 Clk_i Opb_i[12] S_opb_i[12] _NC2429 _NC2430 _NC2431 DFFX1
X1088 Clk_i Opb_i[13] S_opb_i[13] _NC2432 _NC2433 _NC2434 DFFX1
X1089 Clk_i Opb_i[14] S_opb_i[14] _NC2435 _NC2436 _NC2437 DFFX1
X1090 Clk_i Opb_i[15] S_opb_i[15] _NC2438 _NC2439 _NC2440 DFFX1
X1091 Clk_i Opb_i[16] S_opb_i[16] _NC2441 _NC2442 _NC2443 DFFX1
X1092 Clk_i Opb_i[17] S_opb_i[17] _NC2444 _NC2445 _NC2446 DFFX1
X1093 Clk_i Opb_i[18] S_opb_i[18] _NC2447 _NC2448 _NC2449 DFFX1
X1094 Clk_i Opb_i[19] S_opb_i[19] _NC2450 _NC2451 _NC2452 DFFX1
X1095 Clk_i Opb_i[20] S_opb_i[20] _NC2453 _NC2454 _NC2455 DFFX1
X1096 Clk_i Opb_i[21] S_opb_i[21] _NC2456 _NC2457 _NC2458 DFFX1
X1097 Clk_i Opb_i[22] S_opb_i[22] _NC2459 _NC2460 _NC2461 DFFX1
X1098 Clk_i Opb_i[23] S_opb_i[23] _NC2462 _NC2463 _NC2464 DFFX1
X1099 Clk_i Opb_i[24] S_opb_i[24] _NC2465 _NC2466 _NC2467 DFFX1
X1100 Clk_i Opb_i[25] S_opb_i[25] _NC2468 _NC2469 _NC2470 DFFX1
X1101 Clk_i Opb_i[26] S_opb_i[26] _NC2471 _NC2472 _NC2473 DFFX1
X1102 Clk_i Opb_i[27] S_opb_i[27] _NC2474 _NC2475 _NC2476 DFFX1
X1103 Clk_i Opb_i[28] S_opb_i[28] _NC2477 _NC2478 _NC2479 DFFX1
X1104 Clk_i Opb_i[29] S_opb_i[29] _NC2480 _NC2481 _NC2482 DFFX1
X1105 Clk_i Opb_i[30] S_opb_i[30] _NC2483 _NC2484 _NC2485 DFFX1
X1106 Clk_i Opa_i[0] S_opa_i[0] _NC2486 _NC2487 _NC2488 DFFX1
X1107 Clk_i Opa_i[1] S_opa_i[1] _NC2489 _NC2490 _NC2491 DFFX1
X1108 Clk_i Opa_i[2] S_opa_i[2] _NC2492 _NC2493 _NC2494 DFFX1
X1109 Clk_i Opa_i[3] S_opa_i[3] _NC2495 _NC2496 _NC2497 DFFX1
X1110 Clk_i Opa_i[4] S_opa_i[4] _NC2498 _NC2499 _NC2500 DFFX1
X1111 Clk_i Opa_i[5] S_opa_i[5] _NC2501 _NC2502 _NC2503 DFFX1
X1112 Clk_i Opa_i[6] S_opa_i[6] _NC2504 _NC2505 _NC2506 DFFX1
X1113 Clk_i Opa_i[7] S_opa_i[7] _NC2507 _NC2508 _NC2509 DFFX1
X1114 Clk_i Opa_i[8] S_opa_i[8] _NC2510 _NC2511 _NC2512 DFFX1
X1115 Clk_i Opa_i[9] S_opa_i[9] _NC2513 _NC2514 _NC2515 DFFX1
X1116 Clk_i Opa_i[10] S_opa_i[10] _NC2516 _NC2517 _NC2518 DFFX1
X1117 Clk_i Opa_i[11] S_opa_i[11] _NC2519 _NC2520 _NC2521 DFFX1
X1118 Clk_i Opa_i[12] S_opa_i[12] _NC2522 _NC2523 _NC2524 DFFX1
X1119 Clk_i Opa_i[13] S_opa_i[13] _NC2525 _NC2526 _NC2527 DFFX1
X1120 Clk_i Opa_i[14] S_opa_i[14] _NC2528 _NC2529 _NC2530 DFFX1
X1121 Clk_i Opa_i[15] S_opa_i[15] _NC2531 _NC2532 _NC2533 DFFX1
X1122 Clk_i Opa_i[16] S_opa_i[16] _NC2534 _NC2535 _NC2536 DFFX1
X1123 Clk_i Opa_i[17] S_opa_i[17] _NC2537 _NC2538 _NC2539 DFFX1
X1124 Clk_i Opa_i[18] S_opa_i[18] _NC2540 _NC2541 _NC2542 DFFX1
X1125 Clk_i Opa_i[19] S_opa_i[19] _NC2543 _NC2544 _NC2545 DFFX1
X1126 Clk_i Opa_i[20] S_opa_i[20] _NC2546 _NC2547 _NC2548 DFFX1
X1127 Clk_i Opa_i[21] S_opa_i[21] _NC2549 _NC2550 _NC2551 DFFX1
X1128 Clk_i Opa_i[22] S_opa_i[22] _NC2552 _NC2553 _NC2554 DFFX1
X1129 Clk_i Opa_i[23] S_opa_i[23] _NC2555 _NC2556 _NC2557 DFFX1
X1130 Clk_i Opa_i[24] S_opa_i[24] _NC2558 _NC2559 _NC2560 DFFX1
X1131 Clk_i Opa_i[25] S_opa_i[25] _NC2561 _NC2562 _NC2563 DFFX1
X1132 Clk_i Opa_i[26] S_opa_i[26] _NC2564 _NC2565 _NC2566 DFFX1
X1133 Clk_i Opa_i[27] S_opa_i[27] _NC2567 _NC2568 _NC2569 DFFX1
X1134 Clk_i Opa_i[28] S_opa_i[28] _NC2570 _NC2571 _NC2572 DFFX1
X1135 Clk_i Opa_i[29] S_opa_i[29] _NC2573 _NC2574 _NC2575 DFFX1
X1136 Clk_i Opa_i[30] S_opa_i[30] _NC2576 _NC2577 _NC2578 DFFX1
.ENDS post_norm_div

.SUBCKT post_norm_div_DW01_inc_1 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24]
X0 A[0] _NC0 _NC1 SUM[0] INVX0
X1 A[1] A[0] Carry[0] _NC2 _NC3 _NC4 HADDX1
X2 A[2] Carry[0] Carry[1] _NC5 _NC6 _NC7 HADDX1
X3 A[3] Carry[1] Carry[2] _NC8 _NC9 _NC10 HADDX1
X4 A[4] Carry[2] Carry[3] _NC11 _NC12 _NC13 HADDX1
X5 A[5] Carry[3] Carry[4] _NC14 _NC15 _NC16 HADDX1
X6 A[6] Carry[4] Carry[5] _NC17 _NC18 _NC19 HADDX1
X7 A[7] Carry[5] Carry[6] _NC20 _NC21 _NC22 HADDX1
X8 A[8] Carry[6] Carry[7] _NC23 _NC24 _NC25 HADDX1
X9 A[9] Carry[7] Carry[8] _NC26 _NC27 _NC28 HADDX1
X10 A[10] Carry[8] Carry[9] _NC29 _NC30 _NC31 HADDX1
X11 A[11] Carry[9] Carry[10] _NC32 _NC33 _NC34 HADDX1
X12 A[12] Carry[10] Carry[11] _NC35 _NC36 _NC37 HADDX1
X13 A[13] Carry[11] Carry[12] _NC38 _NC39 _NC40 HADDX1
X14 A[14] Carry[12] Carry[13] _NC41 _NC42 _NC43 HADDX1
X15 A[15] Carry[13] Carry[14] _NC44 _NC45 _NC46 HADDX1
X16 A[16] Carry[14] Carry[15] _NC47 _NC48 _NC49 HADDX1
X17 A[17] Carry[15] Carry[16] _NC50 _NC51 _NC52 HADDX1
X18 A[18] Carry[16] Carry[17] _NC53 _NC54 _NC55 HADDX1
X19 A[19] Carry[17] Carry[18] _NC56 _NC57 _NC58 HADDX1
X20 A[20] Carry[18] Carry[19] _NC59 _NC60 _NC61 HADDX1
X21 A[21] Carry[19] Carry[20] _NC62 _NC63 _NC64 HADDX1
X22 A[22] Carry[20] Carry[21] _NC65 _NC66 _NC67 HADDX1
X23 A[23] Carry[21] SUM[24] _NC68 _NC69 _NC70 HADDX1
.ENDS post_norm_div_DW01_inc_1

.SUBCKT post_norm_div_DW01_inc_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8]
X0 A[0] _NC0 _NC1 SUM[0] INVX0
X1 Carry[6] A[8] SUM[8] _NC2 _NC3 XOR2X1
X2 A[1] A[0] Carry[0] _NC4 _NC5 _NC6 HADDX1
X3 A[2] Carry[0] Carry[1] _NC7 _NC8 _NC9 HADDX1
X4 A[3] Carry[1] Carry[2] _NC10 _NC11 _NC12 HADDX1
X5 A[4] Carry[2] Carry[3] _NC13 _NC14 _NC15 HADDX1
X6 A[5] Carry[3] Carry[4] _NC16 _NC17 _NC18 HADDX1
X7 A[6] Carry[4] Carry[5] _NC19 _NC20 _NC21 HADDX1
X8 A[7] Carry[5] Carry[6] _NC22 _NC23 _NC24 HADDX1
.ENDS post_norm_div_DW01_inc_0

.SUBCKT serial_div Clk_i Dvdnd_i[0] Dvdnd_i[1] Dvdnd_i[2] Dvdnd_i[3] Dvdnd_i[4] Dvdnd_i[5] Dvdnd_i[6] Dvdnd_i[7] Dvdnd_i[8] Dvdnd_i[9] Dvdnd_i[10] Dvdnd_i[11] Dvdnd_i[12] Dvdnd_i[13] Dvdnd_i[14] Dvdnd_i[15] Dvdnd_i[16] Dvdnd_i[17] Dvdnd_i[18] Dvdnd_i[19] Dvdnd_i[20] Dvdnd_i[21] Dvdnd_i[22] Dvdnd_i[23] Dvdnd_i[24] Dvdnd_i[25] Dvdnd_i[26] Dvdnd_i[27] Dvdnd_i[28] Dvdnd_i[29] Dvdnd_i[30] Dvdnd_i[31] Dvdnd_i[32] Dvdnd_i[33] Dvdnd_i[34] Dvdnd_i[35] Dvdnd_i[36] Dvdnd_i[37] Dvdnd_i[38] Dvdnd_i[39] Dvdnd_i[40] Dvdnd_i[41] Dvdnd_i[42] Dvdnd_i[43] Dvdnd_i[44] Dvdnd_i[45] Dvdnd_i[46] Dvdnd_i[47] Dvdnd_i[48] Dvdnd_i[49] Dvsor_i[0] Dvsor_i[1] Dvsor_i[2] Dvsor_i[3] Dvsor_i[4] Dvsor_i[5] Dvsor_i[6] Dvsor_i[7] Dvsor_i[8] Dvsor_i[9] Dvsor_i[10] Dvsor_i[11] Dvsor_i[12] Dvsor_i[13] Dvsor_i[14] Dvsor_i[15] Dvsor_i[16] Dvsor_i[17] Dvsor_i[18] Dvsor_i[19] Dvsor_i[20] Dvsor_i[21] Dvsor_i[22] Dvsor_i[23] Dvsor_i[24] Dvsor_i[25] Dvsor_i[26] Sign_dvd_i Sign_div_i Start_i Ready_o Qutnt_o[0] Qutnt_o[1] Qutnt_o[2] Qutnt_o[3] Qutnt_o[4] Qutnt_o[5] Qutnt_o[6] Qutnt_o[7] Qutnt_o[8] Qutnt_o[9] Qutnt_o[10] Qutnt_o[11] Qutnt_o[12] Qutnt_o[13] Qutnt_o[14] Qutnt_o[15] Qutnt_o[16] Qutnt_o[17] Qutnt_o[18] Qutnt_o[19] Qutnt_o[20] Qutnt_o[21] Qutnt_o[22] Qutnt_o[23] Qutnt_o[24] Qutnt_o[25] Qutnt_o[26] Rmndr_o[0] Rmndr_o[1] Rmndr_o[2] Rmndr_o[3] Rmndr_o[4] Rmndr_o[5] Rmndr_o[6] Rmndr_o[7] Rmndr_o[8] Rmndr_o[9] Rmndr_o[10] Rmndr_o[11] Rmndr_o[12] Rmndr_o[13] Rmndr_o[14] Rmndr_o[15] Rmndr_o[16] Rmndr_o[17] Rmndr_o[18] Rmndr_o[19] Rmndr_o[20] Rmndr_o[21] Rmndr_o[22] Rmndr_o[23] Rmndr_o[24] Rmndr_o[25] Rmndr_o[26] Sign_o Div_zero_o
X0 S_count[4] N30 N113 _NC0 _NC1 XOR2X1
X1 S_count[3] N32 N30 _NC2 _NC3 NOR2X0
X2 S_count[3] N32 N112 _NC4 _NC5 XNOR2X1
X3 S_count[2] N31 N29 N111 _NC6 _NC7 AO21X1
X4 N31 S_count[2] N29 _NC8 _NC9 NOR2X0
X5 S_count[1] S_count[0] N28 N110 _NC10 _NC11 AO21X1
X6 S_count[1] S_count[0] N28 _NC12 _NC13 NOR2X0
X7 N12 _NC14 _NC15 N17 INVX0
X8 N12 _NC16 _NC17 N16 INVX0
X9 S_start_i _NC18 _NC19 N27 NBUFFX4
X10 N41 S_count[4] N100 _NC20 _NC21 NOR2X0
X11 S_state N38 N76 _NC22 _NC23 NAND2X1
X12 N38 N122 N120 _NC24 _NC25 NAND2X1
X13 S_count[3] S_count[4] N109 _NC26 _NC27 NOR2X0
X14 N119 _NC28 _NC29 N256 INVX0
X15 N120 _NC30 _NC31 N33 INVX0
X16 N101 _NC32 _NC33 N243 INVX0
X17 N102 _NC34 _NC35 N244 INVX0
X18 N103 _NC36 _NC37 N245 INVX0
X19 N104 _NC38 _NC39 N246 INVX0
X20 N105 _NC40 _NC41 N247 INVX0
X21 N106 _NC42 _NC43 N248 INVX0
X22 N107 _NC44 _NC45 N249 INVX0
X23 N108 _NC46 _NC47 N250 INVX0
X24 N1110 _NC48 _NC49 N251 INVX0
X25 N1130 _NC50 _NC51 N252 INVX0
X26 N115 _NC52 _NC53 N253 INVX0
X27 N116 _NC54 _NC55 N254 INVX0
X28 N117 _NC56 _NC57 N255 INVX0
X29 N77 _NC58 _NC59 N36 INVX0
X30 N38 N79 N78 _NC60 _NC61 NAND2X1
X31 N78 _NC62 _NC63 N35 INVX0
X32 N38 N82 N81 _NC64 _NC65 NAND2X1
X33 N81 _NC66 _NC67 N34 INVX0
X34 N84 _NC68 _NC69 N37 INVX0
X35 N87 _NC70 _NC71 N39 INVX0
X36 N89 _NC72 _NC73 N40 INVX0
X37 N91 _NC74 _NC75 N47 INVX0
X38 N93 _NC76 _NC77 N238 INVX0
X39 N95 _NC78 _NC79 N239 INVX0
X40 N97 _NC80 _NC81 N240 INVX0
X41 N98 _NC82 _NC83 N241 INVX0
X42 N99 _NC84 _NC85 N242 INVX0
X43 S_dvdnd_i[5] S_dvdnd_i[4] N1380 _NC86 _NC87 NOR2X0
X44 N76 _NC88 _NC89 N13 NBUFFX2
X45 N76 _NC90 _NC91 N14 NBUFFX2
X46 N76 _NC92 _NC93 N15 NBUFFX2
X47 N28 _NC94 _NC95 N31 INVX0
X48 N29 _NC96 _NC97 N32 INVX0
X49 N109 N83 N122 _NC98 _NC99 NAND2X1
X50 N76 _NC100 _NC101 N12 NBUFFX2
X51 N24 N27 N48 _NC102 _NC103 NOR2X0
X52 N1500 _NC104 _NC105 N10 NBUFFX2
X53 N158 N27 N49 _NC106 _NC107 NOR2X0
X54 N1500 _NC108 _NC109 N9 NBUFFX2
X55 N1500 _NC110 _NC111 N8 NBUFFX2
X56 N1500 _NC112 _NC113 N6 NBUFFX2
X57 N122 _NC114 _NC115 N257 INVX0
X58 N48 _NC116 _NC117 N23 NBUFFX2
X59 N158 _NC118 _NC119 N26 INVX0
X60 N48 _NC120 _NC121 N21 NBUFFX2
X61 N48 _NC122 _NC123 N22 NBUFFX2
X62 N5 _NC124 _NC125 N24 INVX0
X63 N49 _NC126 _NC127 N20 NBUFFX2
X64 N158 _NC128 _NC129 N25 INVX0
X65 N49 _NC130 _NC131 N19 NBUFFX2
X66 N49 _NC132 _NC133 N18 NBUFFX2
X67 N6 _NC134 _NC135 N11 INVX0
X68 S_state N27 N5 _NC136 _NC137 OR2X1
X69 S_dvdnd_i[26] N11 N4 _NC138 _NC139 AND2X1
X70 Clk_i N237 S_count[0] N44 _NC140 _NC141 DFFX1
X71 Clk_i N235 S_state _NC142 _NC143 _NC144 DFFX1
X72 N4 N132 N133 N134 N135 N136 N137 N138 N139 N140 N141 N142 N143 N144 N145 N146 N147 N148 N149 N150 N151 N152 N153 N154 N155 N156 N157 S_dvsor_i[0] S_dvsor_i[1] S_dvsor_i[2] S_dvsor_i[3] S_dvsor_i[4] S_dvsor_i[5] S_dvsor_i[6] S_dvsor_i[7] S_dvsor_i[8] S_dvsor_i[9] S_dvsor_i[10] S_dvsor_i[11] S_dvsor_i[12] S_dvsor_i[13] S_dvsor_i[14] S_dvsor_i[15] S_dvsor_i[16] S_dvsor_i[17] S_dvsor_i[18] S_dvsor_i[19] S_dvsor_i[20] S_dvsor_i[21] S_dvsor_i[22] S_dvsor_i[23] S_dvsor_i[24] S_dvsor_i[25] S_dvsor_i[26] Vss Vdd Vss N158 _NC145 serial_div_DW_cmp_0
X73 N4 N132 N133 N134 N135 N136 N137 N138 N139 N140 N141 N142 N143 N144 N145 N146 N147 N148 N149 N150 N151 N152 N153 N154 N155 N156 N157 S_dvsor_i[0] S_dvsor_i[1] S_dvsor_i[2] S_dvsor_i[3] S_dvsor_i[4] S_dvsor_i[5] S_dvsor_i[6] S_dvsor_i[7] S_dvsor_i[8] S_dvsor_i[9] S_dvsor_i[10] S_dvsor_i[11] S_dvsor_i[12] S_dvsor_i[13] S_dvsor_i[14] S_dvsor_i[15] S_dvsor_i[16] S_dvsor_i[17] S_dvsor_i[18] S_dvsor_i[19] S_dvsor_i[20] S_dvsor_i[21] S_dvsor_i[22] S_dvsor_i[23] S_dvsor_i[24] S_dvsor_i[25] S_dvsor_i[26] Vss N160 N161 N162 N163 N164 N165 N166 N167 N168 N169 N170 N171 N172 N173 N174 N175 N176 N177 N178 N179 N180 N181 N182 N183 N184 N185 N186 _NC146 serial_div_DW01_sub_0
X74 S_count[0] S_count[2] N43 N118 _NC147 _NC148 NOR3X0
X75 S_count[3] N118 S_count[4] N1500 _NC149 _NC150 NAND3X0
X76 S_dvd[0] N6 S_dvdnd_i[27] N11 N132 _NC151 _NC152 AO22X1
X77 S_dvd[1] N6 S_dvdnd_i[28] N11 N133 _NC153 _NC154 AO22X1
X78 S_dvd[2] N8 S_dvdnd_i[29] N11 N134 _NC155 _NC156 AO22X1
X79 S_dvd[3] N8 S_dvdnd_i[30] N11 N135 _NC157 _NC158 AO22X1
X80 S_dvd[4] N8 S_dvdnd_i[31] N11 N136 _NC159 _NC160 AO22X1
X81 S_dvd[5] N9 S_dvdnd_i[32] N11 N137 _NC161 _NC162 AO22X1
X82 S_dvd[6] N8 S_dvdnd_i[33] N11 N138 _NC163 _NC164 AO22X1
X83 S_dvd[7] N8 S_dvdnd_i[34] N11 N139 _NC165 _NC166 AO22X1
X84 S_dvd[8] N8 S_dvdnd_i[35] N11 N140 _NC167 _NC168 AO22X1
X85 S_dvd[9] N8 S_dvdnd_i[36] N11 N141 _NC169 _NC170 AO22X1
X86 S_dvd[10] N9 S_dvdnd_i[37] N11 N142 _NC171 _NC172 AO22X1
X87 S_dvd[11] N9 S_dvdnd_i[38] N11 N143 _NC173 _NC174 AO22X1
X88 S_dvd[12] N9 S_dvdnd_i[39] N11 N144 _NC175 _NC176 AO22X1
X89 S_dvd[13] N9 S_dvdnd_i[40] N11 N145 _NC177 _NC178 AO22X1
X90 S_dvd[14] N9 S_dvdnd_i[41] N11 N146 _NC179 _NC180 AO22X1
X91 S_dvd[15] N9 S_dvdnd_i[42] N11 N147 _NC181 _NC182 AO22X1
X92 S_dvd[16] N10 S_dvdnd_i[43] N11 N148 _NC183 _NC184 AO22X1
X93 S_dvd[17] N10 S_dvdnd_i[44] N11 N149 _NC185 _NC186 AO22X1
X94 S_dvd[18] N10 S_dvdnd_i[45] N11 N150 _NC187 _NC188 AO22X1
X95 S_dvd[19] N10 S_dvdnd_i[46] N11 N151 _NC189 _NC190 AO22X1
X96 S_dvd[20] N10 S_dvdnd_i[47] N11 N152 _NC191 _NC192 AO22X1
X97 S_dvd[21] N10 S_dvdnd_i[48] N11 N153 _NC193 _NC194 AO22X1
X98 S_dvd[22] N6 S_dvdnd_i[49] N11 N154 _NC195 _NC196 AO22X1
X99 S_dvd[23] N6 N155 _NC197 _NC198 AND2X1
X100 S_dvd[24] N6 N156 _NC199 _NC200 AND2X1
X101 S_dvd[25] N6 N157 _NC201 _NC202 AND2X1
X102 S_dvsor_i[12] S_dvsor_i[11] S_dvsor_i[14] S_dvsor_i[13] N130 _NC203 _NC204 OR4X1
X103 S_dvdnd_i[14] S_dvdnd_i[13] S_dvdnd_i[12] N1490 _NC205 _NC206 OR3X1
X104 N1490 S_dvdnd_i[0] S_dvdnd_i[11] S_dvdnd_i[10] N1420 _NC207 _NC208 NOR4X0
X105 S_dvdnd_i[1] S_dvdnd_i[19] S_dvdnd_i[18] N1480 _NC209 _NC210 OR3X1
X106 N1480 S_dvdnd_i[15] S_dvdnd_i[17] S_dvdnd_i[16] N1430 _NC211 _NC212 NOR4X0
X107 S_dvdnd_i[25] S_dvdnd_i[24] S_dvdnd_i[23] N1470 _NC213 _NC214 OR3X1
X108 N1470 S_dvdnd_i[20] S_dvdnd_i[22] S_dvdnd_i[21] N1440 _NC215 _NC216 NOR4X0
X109 S_dvdnd_i[2] S_dvdnd_i[29] S_dvdnd_i[31] S_dvdnd_i[30] N1460 _NC217 _NC218 OR4X1
X110 N1460 S_dvdnd_i[26] S_dvdnd_i[28] S_dvdnd_i[27] N1450 _NC219 _NC220 NOR4X0
X111 N1420 N1430 N1440 N1450 N1320 _NC221 _NC222 NAND4X0
X112 S_dvdnd_i[9] S_dvdnd_i[8] S_dvdnd_i[7] S_dvdnd_i[6] N1390 _NC223 _NC224 NOR4X0
X113 S_dvdnd_i[47] S_dvdnd_i[48] S_dvdnd_i[46] N1410 _NC225 _NC226 OR3X1
X114 N1410 S_dvdnd_i[43] S_dvdnd_i[45] S_dvdnd_i[44] N1400 _NC227 _NC228 NOR4X0
X115 N1380 N7 N1390 N1400 N1330 _NC229 _NC230 NAND4X0
X116 S_dvdnd_i[38] S_dvdnd_i[3] S_dvdnd_i[39] N1370 _NC231 _NC232 OR3X1
X117 S_dvdnd_i[41] S_dvdnd_i[42] S_dvdnd_i[40] N1370 N1340 _NC233 _NC234 OR4X1
X118 S_dvdnd_i[35] S_dvdnd_i[37] S_dvdnd_i[36] N1360 _NC235 _NC236 OR3X1
X119 S_dvdnd_i[33] S_dvdnd_i[34] S_dvdnd_i[32] N1360 N1350 _NC237 _NC238 OR4X1
X120 N1320 N1330 N1340 N1350 N131 _NC239 _NC240 NOR4X0
X121 N130 N131 S_dvsor_i[10] S_dvsor_i[0] N123 _NC241 _NC242 NOR4X0
X122 S_dvsor_i[19] S_dvsor_i[18] S_dvsor_i[20] S_dvsor_i[1] N129 _NC243 _NC244 OR4X1
X123 N129 S_dvsor_i[15] S_dvsor_i[17] S_dvsor_i[16] N124 _NC245 _NC246 NOR4X0
X124 S_dvsor_i[25] S_dvsor_i[24] S_dvsor_i[2] S_dvsor_i[26] N128 _NC247 _NC248 OR4X1
X125 N128 S_dvsor_i[21] S_dvsor_i[23] S_dvsor_i[22] N125 _NC249 _NC250 NOR4X0
X126 S_dvsor_i[7] S_dvsor_i[6] S_dvsor_i[9] S_dvsor_i[8] N127 _NC251 _NC252 OR4X1
X127 N127 S_dvsor_i[3] S_dvsor_i[5] S_dvsor_i[4] N126 _NC253 _NC254 NOR4X0
X128 N123 N124 N125 N126 Div_zero_o _NC255 _NC256 AND4X1
X129 S_state N44 N43 N42 N83 _NC257 _NC258 AND4X1
X130 N257 N27 N24 N121 _NC259 _NC260 NOR3X0
X131 S_count[0] N24 N44 N121 N237 _NC261 _NC262 AO22X1
X132 N24 S_count[4] N113 N5 N120 N236 _NC263 _NC264 AO221X1
X133 S_state N122 N27 N235 _NC265 _NC266 AO21X1
X134 N257 N38 Ready_o N5 N234 _NC267 _NC268 AO22X1
X135 N24 S_count[1] N110 N5 N120 N233 _NC269 _NC270 AO221X1
X136 S_count[2] N24 N111 N121 N232 _NC271 _NC272 AO22X1
X137 N24 S_count[3] N112 N5 N120 N231 _NC273 _NC274 AO221X1
X138 N20 N120 Qutnt_o[0] N33 N230 _NC275 _NC276 AO22X1
X139 S_count[0] S_state N43 N42 N80 _NC277 _NC278 AND4X1
X140 N109 N80 N27 N119 _NC279 _NC280 AO21X1
X141 N20 N119 Qutnt_o[1] N256 N229 _NC281 _NC282 AO22X1
X142 S_state N118 N96 _NC283 _NC284 AND2X1
X143 N109 N96 N27 N117 _NC285 _NC286 AO21X1
X144 N19 N117 Qutnt_o[2] N255 N228 _NC287 _NC288 AO22X1
X145 S_count[0] S_state S_count[1] N42 N94 _NC289 _NC290 AND4X1
X146 N109 N94 N27 N116 _NC291 _NC292 AO21X1
X147 N19 N116 Qutnt_o[3] N254 N227 _NC293 _NC294 AO22X1
X148 S_count[2] S_state N1120 _NC295 _NC296 AND2X1
X149 N1120 N43 N114 _NC297 _NC298 AND2X1
X150 N114 N44 N92 _NC299 _NC300 AND2X1
X151 N109 N92 N27 N115 _NC301 _NC302 AO21X1
X152 N19 N115 Qutnt_o[4] N253 N226 _NC303 _NC304 AO22X1
X153 N114 S_count[0] N90 _NC305 _NC306 AND2X1
X154 N109 N90 N27 N1130 _NC307 _NC308 AO21X1
X155 N19 N1130 Qutnt_o[5] N252 N225 _NC309 _NC310 AO22X1
X156 N1120 S_count[1] N1100 _NC311 _NC312 AND2X1
X157 N1100 N44 N88 _NC313 _NC314 AND2X1
X158 N109 N88 N27 N1110 _NC315 _NC316 AO21X1
X159 N19 N1110 Qutnt_o[6] N251 N224 _NC317 _NC318 AO22X1
X160 N1100 S_count[0] N86 _NC319 _NC320 AND2X1
X161 N109 N86 N27 N108 _NC321 _NC322 AO21X1
X162 N19 N108 Qutnt_o[7] N250 N223 _NC323 _NC324 AO22X1
X163 N100 N83 N27 N107 _NC325 _NC326 AO21X1
X164 N19 N107 Qutnt_o[8] N249 N222 _NC327 _NC328 AO22X1
X165 N100 N80 N27 N106 _NC329 _NC330 AO21X1
X166 N19 N106 Qutnt_o[9] N248 N221 _NC331 _NC332 AO22X1
X167 N100 N96 N27 N105 _NC333 _NC334 AO21X1
X168 N19 N105 Qutnt_o[10] N247 N220 _NC335 _NC336 AO22X1
X169 N100 N94 N27 N104 _NC337 _NC338 AO21X1
X170 N19 N104 Qutnt_o[11] N246 N219 _NC339 _NC340 AO22X1
X171 N100 N92 N27 N103 _NC341 _NC342 AO21X1
X172 N19 N103 Qutnt_o[12] N245 N218 _NC343 _NC344 AO22X1
X173 N100 N90 N27 N102 _NC345 _NC346 AO21X1
X174 N19 N102 Qutnt_o[13] N244 N217 _NC347 _NC348 AO22X1
X175 N100 N88 N27 N101 _NC349 _NC350 AO21X1
X176 N19 N101 Qutnt_o[14] N243 N216 _NC351 _NC352 AO22X1
X177 N100 N86 N27 N99 _NC353 _NC354 AO21X1
X178 N18 N99 Qutnt_o[15] N242 N215 _NC355 _NC356 AO22X1
X179 S_count[4] N41 N85 _NC357 _NC358 AND2X1
X180 N85 N83 N27 N98 _NC359 _NC360 AO21X1
X181 N18 N98 Qutnt_o[16] N241 N214 _NC361 _NC362 AO22X1
X182 N85 N80 N27 N97 _NC363 _NC364 AO21X1
X183 N18 N97 Qutnt_o[17] N240 N213 _NC365 _NC366 AO22X1
X184 N96 N85 N27 N95 _NC367 _NC368 AO21X1
X185 N18 N95 Qutnt_o[18] N239 N212 _NC369 _NC370 AO22X1
X186 N94 N85 N27 N93 _NC371 _NC372 AO21X1
X187 N18 N93 Qutnt_o[19] N238 N211 _NC373 _NC374 AO22X1
X188 N92 N85 N27 N91 _NC375 _NC376 AO21X1
X189 N18 N91 Qutnt_o[20] N47 N210 _NC377 _NC378 AO22X1
X190 N90 N85 N27 N89 _NC379 _NC380 AO21X1
X191 N18 N89 Qutnt_o[21] N40 N209 _NC381 _NC382 AO22X1
X192 N88 N85 N27 N87 _NC383 _NC384 AO21X1
X193 N18 N87 Qutnt_o[22] N39 N208 _NC385 _NC386 AO22X1
X194 N85 N86 N27 N84 _NC387 _NC388 AO21X1
X195 N18 N84 Qutnt_o[23] N37 N207 _NC389 _NC390 AO22X1
X196 S_count[4] S_count[3] N83 N82 _NC391 _NC392 NAND3X0
X197 N18 N81 Qutnt_o[24] N34 N206 _NC393 _NC394 AO22X1
X198 S_count[4] S_count[3] N80 N79 _NC395 _NC396 NAND3X0
X199 N18 N78 Qutnt_o[25] N35 N205 _NC397 _NC398 AO22X1
X200 S_state N11 N27 N77 _NC399 _NC400 AO21X1
X201 N18 N77 Qutnt_o[26] N36 N204 _NC401 _NC402 AO22X1
X202 N160 N26 N158 N4 N75 _NC403 _NC404 AO22X1
X203 S_dvd[0] N12 N16 N75 N203 _NC405 _NC406 AO22X1
X204 N161 N26 N158 N132 N74 _NC407 _NC408 AO22X1
X205 S_dvd[1] N12 N16 N74 N202 _NC409 _NC410 AO22X1
X206 N162 N26 N158 N133 N73 _NC411 _NC412 AO22X1
X207 S_dvd[2] N12 N16 N73 N201 _NC413 _NC414 AO22X1
X208 N163 N26 N158 N134 N72 _NC415 _NC416 AO22X1
X209 S_dvd[3] N12 N16 N72 N200 _NC417 _NC418 AO22X1
X210 N164 N26 N158 N135 N71 _NC419 _NC420 AO22X1
X211 S_dvd[4] N13 N16 N71 N199 _NC421 _NC422 AO22X1
X212 N165 N26 N158 N136 N70 _NC423 _NC424 AO22X1
X213 S_dvd[5] N13 N16 N70 N198 _NC425 _NC426 AO22X1
X214 N166 N26 N158 N137 N69 _NC427 _NC428 AO22X1
X215 S_dvd[6] N13 N16 N69 N197 _NC429 _NC430 AO22X1
X216 N167 N26 N158 N138 N68 _NC431 _NC432 AO22X1
X217 S_dvd[7] N13 N16 N68 N196 _NC433 _NC434 AO22X1
X218 N168 N26 N158 N139 N67 _NC435 _NC436 AO22X1
X219 S_dvd[8] N13 N16 N67 N195 _NC437 _NC438 AO22X1
X220 N169 N26 N158 N140 N66 _NC439 _NC440 AO22X1
X221 S_dvd[9] N13 N16 N66 N194 _NC441 _NC442 AO22X1
X222 N170 N26 N158 N141 N65 _NC443 _NC444 AO22X1
X223 S_dvd[10] N13 N16 N65 N193 _NC445 _NC446 AO22X1
X224 N171 N26 N158 N142 N64 _NC447 _NC448 AO22X1
X225 S_dvd[11] N14 N16 N64 N192 _NC449 _NC450 AO22X1
X226 N172 N26 N158 N143 N63 _NC451 _NC452 AO22X1
X227 S_dvd[12] N14 N17 N63 N191 _NC453 _NC454 AO22X1
X228 N173 N26 N158 N144 N62 _NC455 _NC456 AO22X1
X229 S_dvd[13] N14 N17 N62 N190 _NC457 _NC458 AO22X1
X230 N174 N26 N158 N145 N61 _NC459 _NC460 AO22X1
X231 S_dvd[14] N14 N17 N61 N189 _NC461 _NC462 AO22X1
X232 N175 N26 N158 N146 N60 _NC463 _NC464 AO22X1
X233 S_dvd[15] N14 N17 N60 N188 _NC465 _NC466 AO22X1
X234 N176 N26 N158 N147 N59 _NC467 _NC468 AO22X1
X235 S_dvd[16] N14 N17 N59 N187 _NC469 _NC470 AO22X1
X236 N177 N26 N158 N148 N58 _NC471 _NC472 AO22X1
X237 S_dvd[17] N14 N17 N58 N1860 _NC473 _NC474 AO22X1
X238 N178 N26 N158 N149 N57 _NC475 _NC476 AO22X1
X239 S_dvd[18] N15 N17 N57 N1850 _NC477 _NC478 AO22X1
X240 N179 N26 N158 N150 N56 _NC479 _NC480 AO22X1
X241 S_dvd[19] N15 N17 N56 N1840 _NC481 _NC482 AO22X1
X242 N180 N25 N158 N151 N55 _NC483 _NC484 AO22X1
X243 S_dvd[20] N15 N17 N55 N1830 _NC485 _NC486 AO22X1
X244 N181 N25 N158 N152 N54 _NC487 _NC488 AO22X1
X245 S_dvd[21] N15 N17 N54 N1820 _NC489 _NC490 AO22X1
X246 N182 N25 N158 N153 N53 _NC491 _NC492 AO22X1
X247 S_dvd[22] N15 N17 N53 N1810 _NC493 _NC494 AO22X1
X248 N183 N25 N158 N154 N52 _NC495 _NC496 AO22X1
X249 S_dvd[23] N15 N17 N52 N1800 _NC497 _NC498 AO22X1
X250 N184 N25 N155 N158 N51 _NC499 _NC500 AO22X1
X251 S_dvd[24] N15 N17 N51 N1790 _NC501 _NC502 AO22X1
X252 N185 N25 N156 N158 N50 _NC503 _NC504 AO22X1
X253 S_dvd[25] N15 N16 N50 N1780 _NC505 _NC506 AO22X1
X254 Rmndr_o[0] N24 N21 N75 N1770 _NC507 _NC508 AO22X1
X255 Rmndr_o[1] N24 N21 N74 N1760 _NC509 _NC510 AO22X1
X256 Rmndr_o[2] N24 N21 N73 N1750 _NC511 _NC512 AO22X1
X257 Rmndr_o[3] N24 N21 N72 N1740 _NC513 _NC514 AO22X1
X258 Rmndr_o[4] N24 N21 N71 N1730 _NC515 _NC516 AO22X1
X259 Rmndr_o[5] N24 N21 N70 N1720 _NC517 _NC518 AO22X1
X260 Rmndr_o[6] N24 N21 N69 N1710 _NC519 _NC520 AO22X1
X261 Rmndr_o[7] N24 N21 N68 N1700 _NC521 _NC522 AO22X1
X262 Rmndr_o[8] N24 N21 N67 N1690 _NC523 _NC524 AO22X1
X263 Rmndr_o[9] N24 N21 N66 N1680 _NC525 _NC526 AO22X1
X264 Rmndr_o[10] N24 N21 N65 N1670 _NC527 _NC528 AO22X1
X265 Rmndr_o[11] N24 N21 N64 N1660 _NC529 _NC530 AO22X1
X266 Rmndr_o[12] N24 N22 N63 N1650 _NC531 _NC532 AO22X1
X267 Rmndr_o[13] N24 N22 N62 N1640 _NC533 _NC534 AO22X1
X268 Rmndr_o[14] N24 N22 N61 N1630 _NC535 _NC536 AO22X1
X269 Rmndr_o[15] N24 N22 N60 N1620 _NC537 _NC538 AO22X1
X270 Rmndr_o[16] N24 N22 N59 N1610 _NC539 _NC540 AO22X1
X271 Rmndr_o[17] N24 N22 N58 N1600 _NC541 _NC542 AO22X1
X272 Rmndr_o[18] N24 N22 N57 N159 _NC543 _NC544 AO22X1
X273 Rmndr_o[19] N24 N22 N56 N1580 _NC545 _NC546 AO22X1
X274 Rmndr_o[20] N24 N22 N55 N1570 _NC547 _NC548 AO22X1
X275 Rmndr_o[21] N24 N22 N54 N1560 _NC549 _NC550 AO22X1
X276 Rmndr_o[22] N24 N22 N53 N1550 _NC551 _NC552 AO22X1
X277 Rmndr_o[23] N24 N22 N52 N1540 _NC553 _NC554 AO22X1
X278 Rmndr_o[24] N24 N23 N51 N1530 _NC555 _NC556 AO22X1
X279 Rmndr_o[25] N24 N23 N50 N1520 _NC557 _NC558 AO22X1
X280 N5 N18 N45 _NC559 _NC560 AND2X1
X281 N23 N157 N46 _NC561 _NC562 AND2X1
X282 N45 N186 N46 N158 Rmndr_o[26] N24 N1510 _NC563 _NC564 AO222X1
X283 Sign_dvd_i Sign_div_i Sign_o _NC565 _NC566 XOR2X1
X284 Clk_i N1510 Rmndr_o[26] _NC567 _NC568 _NC569 DFFX1
X285 Clk_i N230 Qutnt_o[0] _NC570 _NC571 _NC572 DFFX1
X286 Clk_i N229 Qutnt_o[1] _NC573 _NC574 _NC575 DFFX1
X287 Clk_i N228 Qutnt_o[2] _NC576 _NC577 _NC578 DFFX1
X288 Clk_i N227 Qutnt_o[3] _NC579 _NC580 _NC581 DFFX1
X289 Clk_i N226 Qutnt_o[4] _NC582 _NC583 _NC584 DFFX1
X290 Clk_i N225 Qutnt_o[5] _NC585 _NC586 _NC587 DFFX1
X291 Clk_i N224 Qutnt_o[6] _NC588 _NC589 _NC590 DFFX1
X292 Clk_i N223 Qutnt_o[7] _NC591 _NC592 _NC593 DFFX1
X293 Clk_i N222 Qutnt_o[8] _NC594 _NC595 _NC596 DFFX1
X294 Clk_i N221 Qutnt_o[9] _NC597 _NC598 _NC599 DFFX1
X295 Clk_i N220 Qutnt_o[10] _NC600 _NC601 _NC602 DFFX1
X296 Clk_i N219 Qutnt_o[11] _NC603 _NC604 _NC605 DFFX1
X297 Clk_i N218 Qutnt_o[12] _NC606 _NC607 _NC608 DFFX1
X298 Clk_i N217 Qutnt_o[13] _NC609 _NC610 _NC611 DFFX1
X299 Clk_i N216 Qutnt_o[14] _NC612 _NC613 _NC614 DFFX1
X300 Clk_i N215 Qutnt_o[15] _NC615 _NC616 _NC617 DFFX1
X301 Clk_i N214 Qutnt_o[16] _NC618 _NC619 _NC620 DFFX1
X302 Clk_i N213 Qutnt_o[17] _NC621 _NC622 _NC623 DFFX1
X303 Clk_i N212 Qutnt_o[18] _NC624 _NC625 _NC626 DFFX1
X304 Clk_i N211 Qutnt_o[19] _NC627 _NC628 _NC629 DFFX1
X305 Clk_i N210 Qutnt_o[20] _NC630 _NC631 _NC632 DFFX1
X306 Clk_i N209 Qutnt_o[21] _NC633 _NC634 _NC635 DFFX1
X307 Clk_i N208 Qutnt_o[22] _NC636 _NC637 _NC638 DFFX1
X308 Clk_i N207 Qutnt_o[23] _NC639 _NC640 _NC641 DFFX1
X309 Clk_i N206 Qutnt_o[24] _NC642 _NC643 _NC644 DFFX1
X310 Clk_i N205 Qutnt_o[25] _NC645 _NC646 _NC647 DFFX1
X311 Clk_i N204 Qutnt_o[26] _NC648 _NC649 _NC650 DFFX1
X312 Clk_i N1780 S_dvd[25] _NC651 _NC652 _NC653 DFFX1
X313 Clk_i N1520 Rmndr_o[25] _NC654 _NC655 _NC656 DFFX1
X314 Clk_i N1790 S_dvd[24] _NC657 _NC658 _NC659 DFFX1
X315 Clk_i N1530 Rmndr_o[24] _NC660 _NC661 _NC662 DFFX1
X316 Clk_i N1800 S_dvd[23] _NC663 _NC664 _NC665 DFFX1
X317 Clk_i N1540 Rmndr_o[23] _NC666 _NC667 _NC668 DFFX1
X318 Clk_i N1810 S_dvd[22] _NC669 _NC670 _NC671 DFFX1
X319 Clk_i N1550 Rmndr_o[22] _NC672 _NC673 _NC674 DFFX1
X320 Clk_i N1820 S_dvd[21] _NC675 _NC676 _NC677 DFFX1
X321 Clk_i N1560 Rmndr_o[21] _NC678 _NC679 _NC680 DFFX1
X322 Clk_i N1830 S_dvd[20] _NC681 _NC682 _NC683 DFFX1
X323 Clk_i N1570 Rmndr_o[20] _NC684 _NC685 _NC686 DFFX1
X324 Clk_i N1840 S_dvd[19] _NC687 _NC688 _NC689 DFFX1
X325 Clk_i N1580 Rmndr_o[19] _NC690 _NC691 _NC692 DFFX1
X326 Clk_i N1850 S_dvd[18] _NC693 _NC694 _NC695 DFFX1
X327 Clk_i N159 Rmndr_o[18] _NC696 _NC697 _NC698 DFFX1
X328 Clk_i N1860 S_dvd[17] _NC699 _NC700 _NC701 DFFX1
X329 Clk_i N1600 Rmndr_o[17] _NC702 _NC703 _NC704 DFFX1
X330 Clk_i N187 S_dvd[16] _NC705 _NC706 _NC707 DFFX1
X331 Clk_i N1610 Rmndr_o[16] _NC708 _NC709 _NC710 DFFX1
X332 Clk_i N188 S_dvd[15] _NC711 _NC712 _NC713 DFFX1
X333 Clk_i N1620 Rmndr_o[15] _NC714 _NC715 _NC716 DFFX1
X334 Clk_i N189 S_dvd[14] _NC717 _NC718 _NC719 DFFX1
X335 Clk_i N1630 Rmndr_o[14] _NC720 _NC721 _NC722 DFFX1
X336 Clk_i N190 S_dvd[13] _NC723 _NC724 _NC725 DFFX1
X337 Clk_i N1640 Rmndr_o[13] _NC726 _NC727 _NC728 DFFX1
X338 Clk_i N191 S_dvd[12] _NC729 _NC730 _NC731 DFFX1
X339 Clk_i N1650 Rmndr_o[12] _NC732 _NC733 _NC734 DFFX1
X340 Clk_i N192 S_dvd[11] _NC735 _NC736 _NC737 DFFX1
X341 Clk_i N1660 Rmndr_o[11] _NC738 _NC739 _NC740 DFFX1
X342 Clk_i N193 S_dvd[10] _NC741 _NC742 _NC743 DFFX1
X343 Clk_i N1670 Rmndr_o[10] _NC744 _NC745 _NC746 DFFX1
X344 Clk_i N194 S_dvd[9] _NC747 _NC748 _NC749 DFFX1
X345 Clk_i N1680 Rmndr_o[9] _NC750 _NC751 _NC752 DFFX1
X346 Clk_i N195 S_dvd[8] _NC753 _NC754 _NC755 DFFX1
X347 Clk_i N1690 Rmndr_o[8] _NC756 _NC757 _NC758 DFFX1
X348 Clk_i N196 S_dvd[7] _NC759 _NC760 _NC761 DFFX1
X349 Clk_i N1700 Rmndr_o[7] _NC762 _NC763 _NC764 DFFX1
X350 Clk_i N197 S_dvd[6] _NC765 _NC766 _NC767 DFFX1
X351 Clk_i N1710 Rmndr_o[6] _NC768 _NC769 _NC770 DFFX1
X352 Clk_i N198 S_dvd[5] _NC771 _NC772 _NC773 DFFX1
X353 Clk_i N1720 Rmndr_o[5] _NC774 _NC775 _NC776 DFFX1
X354 Clk_i N199 S_dvd[4] _NC777 _NC778 _NC779 DFFX1
X355 Clk_i N1730 Rmndr_o[4] _NC780 _NC781 _NC782 DFFX1
X356 Clk_i N200 S_dvd[3] _NC783 _NC784 _NC785 DFFX1
X357 Clk_i N1740 Rmndr_o[3] _NC786 _NC787 _NC788 DFFX1
X358 Clk_i N201 S_dvd[2] _NC789 _NC790 _NC791 DFFX1
X359 Clk_i N1750 Rmndr_o[2] _NC792 _NC793 _NC794 DFFX1
X360 Clk_i N202 S_dvd[1] _NC795 _NC796 _NC797 DFFX1
X361 Clk_i N1760 Rmndr_o[1] _NC798 _NC799 _NC800 DFFX1
X362 Clk_i N203 S_dvd[0] _NC801 _NC802 _NC803 DFFX1
X363 Clk_i N1770 Rmndr_o[0] _NC804 _NC805 _NC806 DFFX1
X364 Clk_i N231 S_count[3] N41 _NC807 _NC808 DFFX1
X365 Clk_i N232 S_count[2] N42 _NC809 _NC810 DFFX1
X366 Clk_i N233 S_count[1] N43 _NC811 _NC812 DFFX1
X367 Clk_i N236 S_count[4] _NC813 _NC814 _NC815 DFFX1
X368 Clk_i N234 Ready_o _NC816 _NC817 _NC818 DFFX1
X369 Clk_i Start_i S_start_i N38 _NC819 _NC820 DFFX1
X370 Clk_i Dvsor_i[0] S_dvsor_i[0] _NC821 _NC822 _NC823 DFFX1
X371 Clk_i Dvsor_i[1] S_dvsor_i[1] _NC824 _NC825 _NC826 DFFX1
X372 Clk_i Dvsor_i[2] S_dvsor_i[2] _NC827 _NC828 _NC829 DFFX1
X373 Clk_i Dvsor_i[3] S_dvsor_i[3] _NC830 _NC831 _NC832 DFFX1
X374 Clk_i Dvsor_i[4] S_dvsor_i[4] _NC833 _NC834 _NC835 DFFX1
X375 Clk_i Dvsor_i[5] S_dvsor_i[5] _NC836 _NC837 _NC838 DFFX1
X376 Clk_i Dvsor_i[6] S_dvsor_i[6] _NC839 _NC840 _NC841 DFFX1
X377 Clk_i Dvsor_i[7] S_dvsor_i[7] _NC842 _NC843 _NC844 DFFX1
X378 Clk_i Dvsor_i[8] S_dvsor_i[8] _NC845 _NC846 _NC847 DFFX1
X379 Clk_i Dvsor_i[9] S_dvsor_i[9] _NC848 _NC849 _NC850 DFFX1
X380 Clk_i Dvsor_i[10] S_dvsor_i[10] _NC851 _NC852 _NC853 DFFX1
X381 Clk_i Dvsor_i[11] S_dvsor_i[11] _NC854 _NC855 _NC856 DFFX1
X382 Clk_i Dvsor_i[12] S_dvsor_i[12] _NC857 _NC858 _NC859 DFFX1
X383 Clk_i Dvsor_i[13] S_dvsor_i[13] _NC860 _NC861 _NC862 DFFX1
X384 Clk_i Dvsor_i[14] S_dvsor_i[14] _NC863 _NC864 _NC865 DFFX1
X385 Clk_i Dvsor_i[15] S_dvsor_i[15] _NC866 _NC867 _NC868 DFFX1
X386 Clk_i Dvsor_i[16] S_dvsor_i[16] _NC869 _NC870 _NC871 DFFX1
X387 Clk_i Dvsor_i[17] S_dvsor_i[17] _NC872 _NC873 _NC874 DFFX1
X388 Clk_i Dvsor_i[18] S_dvsor_i[18] _NC875 _NC876 _NC877 DFFX1
X389 Clk_i Dvsor_i[19] S_dvsor_i[19] _NC878 _NC879 _NC880 DFFX1
X390 Clk_i Dvsor_i[20] S_dvsor_i[20] _NC881 _NC882 _NC883 DFFX1
X391 Clk_i Dvsor_i[21] S_dvsor_i[21] _NC884 _NC885 _NC886 DFFX1
X392 Clk_i Dvsor_i[22] S_dvsor_i[22] _NC887 _NC888 _NC889 DFFX1
X393 Clk_i Dvsor_i[23] S_dvsor_i[23] _NC890 _NC891 _NC892 DFFX1
X394 Clk_i Dvsor_i[24] S_dvsor_i[24] _NC893 _NC894 _NC895 DFFX1
X395 Clk_i Dvsor_i[25] S_dvsor_i[25] _NC896 _NC897 _NC898 DFFX1
X396 Clk_i Dvsor_i[26] S_dvsor_i[26] _NC899 _NC900 _NC901 DFFX1
X397 Clk_i Dvdnd_i[0] S_dvdnd_i[0] _NC902 _NC903 _NC904 DFFX1
X398 Clk_i Dvdnd_i[1] S_dvdnd_i[1] _NC905 _NC906 _NC907 DFFX1
X399 Clk_i Dvdnd_i[2] S_dvdnd_i[2] _NC908 _NC909 _NC910 DFFX1
X400 Clk_i Dvdnd_i[3] S_dvdnd_i[3] _NC911 _NC912 _NC913 DFFX1
X401 Clk_i Dvdnd_i[4] S_dvdnd_i[4] _NC914 _NC915 _NC916 DFFX1
X402 Clk_i Dvdnd_i[5] S_dvdnd_i[5] _NC917 _NC918 _NC919 DFFX1
X403 Clk_i Dvdnd_i[6] S_dvdnd_i[6] _NC920 _NC921 _NC922 DFFX1
X404 Clk_i Dvdnd_i[7] S_dvdnd_i[7] _NC923 _NC924 _NC925 DFFX1
X405 Clk_i Dvdnd_i[8] S_dvdnd_i[8] _NC926 _NC927 _NC928 DFFX1
X406 Clk_i Dvdnd_i[9] S_dvdnd_i[9] _NC929 _NC930 _NC931 DFFX1
X407 Clk_i Dvdnd_i[10] S_dvdnd_i[10] _NC932 _NC933 _NC934 DFFX1
X408 Clk_i Dvdnd_i[11] S_dvdnd_i[11] _NC935 _NC936 _NC937 DFFX1
X409 Clk_i Dvdnd_i[12] S_dvdnd_i[12] _NC938 _NC939 _NC940 DFFX1
X410 Clk_i Dvdnd_i[13] S_dvdnd_i[13] _NC941 _NC942 _NC943 DFFX1
X411 Clk_i Dvdnd_i[14] S_dvdnd_i[14] _NC944 _NC945 _NC946 DFFX1
X412 Clk_i Dvdnd_i[15] S_dvdnd_i[15] _NC947 _NC948 _NC949 DFFX1
X413 Clk_i Dvdnd_i[16] S_dvdnd_i[16] _NC950 _NC951 _NC952 DFFX1
X414 Clk_i Dvdnd_i[17] S_dvdnd_i[17] _NC953 _NC954 _NC955 DFFX1
X415 Clk_i Dvdnd_i[18] S_dvdnd_i[18] _NC956 _NC957 _NC958 DFFX1
X416 Clk_i Dvdnd_i[19] S_dvdnd_i[19] _NC959 _NC960 _NC961 DFFX1
X417 Clk_i Dvdnd_i[20] S_dvdnd_i[20] _NC962 _NC963 _NC964 DFFX1
X418 Clk_i Dvdnd_i[21] S_dvdnd_i[21] _NC965 _NC966 _NC967 DFFX1
X419 Clk_i Dvdnd_i[22] S_dvdnd_i[22] _NC968 _NC969 _NC970 DFFX1
X420 Clk_i Dvdnd_i[23] S_dvdnd_i[23] _NC971 _NC972 _NC973 DFFX1
X421 Clk_i Dvdnd_i[24] S_dvdnd_i[24] _NC974 _NC975 _NC976 DFFX1
X422 Clk_i Dvdnd_i[25] S_dvdnd_i[25] _NC977 _NC978 _NC979 DFFX1
X423 Clk_i Dvdnd_i[26] S_dvdnd_i[26] _NC980 _NC981 _NC982 DFFX1
X424 Clk_i Dvdnd_i[27] S_dvdnd_i[27] _NC983 _NC984 _NC985 DFFX1
X425 Clk_i Dvdnd_i[28] S_dvdnd_i[28] _NC986 _NC987 _NC988 DFFX1
X426 Clk_i Dvdnd_i[29] S_dvdnd_i[29] _NC989 _NC990 _NC991 DFFX1
X427 Clk_i Dvdnd_i[30] S_dvdnd_i[30] _NC992 _NC993 _NC994 DFFX1
X428 Clk_i Dvdnd_i[31] S_dvdnd_i[31] _NC995 _NC996 _NC997 DFFX1
X429 Clk_i Dvdnd_i[32] S_dvdnd_i[32] _NC998 _NC999 _NC1000 DFFX1
X430 Clk_i Dvdnd_i[33] S_dvdnd_i[33] _NC1001 _NC1002 _NC1003 DFFX1
X431 Clk_i Dvdnd_i[34] S_dvdnd_i[34] _NC1004 _NC1005 _NC1006 DFFX1
X432 Clk_i Dvdnd_i[35] S_dvdnd_i[35] _NC1007 _NC1008 _NC1009 DFFX1
X433 Clk_i Dvdnd_i[36] S_dvdnd_i[36] _NC1010 _NC1011 _NC1012 DFFX1
X434 Clk_i Dvdnd_i[37] S_dvdnd_i[37] _NC1013 _NC1014 _NC1015 DFFX1
X435 Clk_i Dvdnd_i[38] S_dvdnd_i[38] _NC1016 _NC1017 _NC1018 DFFX1
X436 Clk_i Dvdnd_i[39] S_dvdnd_i[39] _NC1019 _NC1020 _NC1021 DFFX1
X437 Clk_i Dvdnd_i[40] S_dvdnd_i[40] _NC1022 _NC1023 _NC1024 DFFX1
X438 Clk_i Dvdnd_i[41] S_dvdnd_i[41] _NC1025 _NC1026 _NC1027 DFFX1
X439 Clk_i Dvdnd_i[42] S_dvdnd_i[42] _NC1028 _NC1029 _NC1030 DFFX1
X440 Clk_i Dvdnd_i[43] S_dvdnd_i[43] _NC1031 _NC1032 _NC1033 DFFX1
X441 Clk_i Dvdnd_i[44] S_dvdnd_i[44] _NC1034 _NC1035 _NC1036 DFFX1
X442 Clk_i Dvdnd_i[45] S_dvdnd_i[45] _NC1037 _NC1038 _NC1039 DFFX1
X443 Clk_i Dvdnd_i[46] S_dvdnd_i[46] _NC1040 _NC1041 _NC1042 DFFX1
X444 Clk_i Dvdnd_i[47] S_dvdnd_i[47] _NC1043 _NC1044 _NC1045 DFFX1
X445 Clk_i Dvdnd_i[48] S_dvdnd_i[48] _NC1046 _NC1047 _NC1048 DFFX1
X446 Clk_i Dvdnd_i[49] S_dvdnd_i[49] N7 _NC1049 _NC1050 DFFX1
.ENDS serial_div

.SUBCKT serial_div_DW_cmp_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
X0 N1072 B[21] N1164 _NC0 _NC1 NOR2X0
X1 A[20] N1164 N1172 _NC2 _NC3 NOR2X0
X2 N1070 B[23] N1171 _NC4 _NC5 NOR2X0
X3 A[22] N1171 N1173 _NC6 _NC7 NOR2X0
X4 B[23] N1070 N1173 B[22] N1170 _NC8 _NC9 AO22X1
X5 B[21] N1072 N1172 B[20] N1170 N1157 _NC10 _NC11 AO221X1
X6 A[22] N1090 N1171 N1163 _NC12 _NC13 AOI21X1
X7 N1170 N1163 N1158 _NC14 _NC15 OR2X1
X8 N1074 B[19] N1169 _NC16 _NC17 NOR2X0
X9 A[18] N1092 N1169 N1108 _NC18 _NC19 AO21X1
X10 A[18] N1169 N1168 _NC20 _NC21 NOR2X0
X11 B[19] N1074 N1168 B[18] N1165 _NC22 _NC23 AO22X1
X12 N1076 B[17] N1114 _NC24 _NC25 NOR2X0
X13 A[16] N1114 N1167 _NC26 _NC27 NOR2X0
X14 B[17] N1076 N1167 B[16] N1165 N1166 _NC28 _NC29 AO221X1
X15 N1073 N1165 N1166 N1159 _NC30 _NC31 OA21X1
X16 A[20] N1091 N1162 _NC32 _NC33 NAND2X0
X17 N1071 N1162 N1163 N1109 _NC34 _NC35 NAND3X0
X18 N1102 B[25] N1153 _NC36 _NC37 NOR2X0
X19 N1103 B[26] N1155 _NC38 _NC39 NOR2X0
X20 N1153 N1155 N1160 _NC40 _NC41 NOR2X0
X21 B[25] N1102 B[24] N1101 N1161 _NC42 _NC43 AO22X1
X22 B[26] N1103 N1160 N1161 N1156 _NC44 _NC45 AO22X1
X23 N1157 N1158 N1159 N1069 N1156 N1104 _NC46 _NC47 AO221X1
X24 N1101 B[24] N1154 _NC48 _NC49 NOR2X0
X25 N1153 N1154 N1155 N1110 _NC50 _NC51 OR3X1
X26 N1089 N1110 N1105 _NC52 _NC53 NAND2X0
X27 N1085 B[7] N1142 _NC54 _NC55 NOR2X0
X28 A[6] N1098 N1142 N1140 _NC56 _NC57 AO21X1
X29 B[1] N1088 N1152 _NC58 _NC59 NOR2X0
X30 A[0] N1152 N1150 _NC60 _NC61 NOR2X0
X31 N1087 B[3] N1149 _NC62 _NC63 NOR2X0
X32 A[2] N1149 N1151 _NC64 _NC65 NOR2X0
X33 B[3] N1087 N1151 B[2] N1148 _NC66 _NC67 AO22X1
X34 B[1] N1088 N1150 B[0] N1148 N1145 _NC68 _NC69 AO221X1
X35 N1100 A[2] N1149 N1147 _NC70 _NC71 AOI21X1
X36 A[5] N1099 N1144 _NC72 _NC73 NAND2X0
X37 N1147 N1148 B[4] N1086 N1144 N1146 _NC74 _NC75 OA221X1
X38 N1084 N1145 N1146 N1121 _NC76 _NC77 NAND3X0
X39 N1144 N1086 B[4] N1143 _NC78 _NC79 NAND3X0
X40 A[5] N1099 N1143 N1138 _NC80 _NC81 OA21X1
X41 A[6] N1142 N1141 _NC82 _NC83 NOR2X0
X42 B[7] N1085 N1141 B[6] N1139 _NC84 _NC85 AOI22X1
X43 N1138 N1139 N1139 N1140 N1122 _NC86 _NC87 AO22X1
X44 A[13] N1095 N1127 _NC88 _NC89 NAND2X0
X45 N1127 N1080 B[12] N1137 _NC90 _NC91 NAND3X0
X46 A[13] N1095 N1137 N1133 _NC92 _NC93 OA21X1
X47 N1079 B[15] N1135 _NC94 _NC95 NOR2X0
X48 A[14] N1135 N1136 _NC96 _NC97 NOR2X0
X49 B[15] N1079 N1136 B[14] N1134 _NC98 _NC99 AOI22X1
X50 A[14] N1094 N1135 N1129 _NC100 _NC101 AO21X1
X51 N1133 N1134 N1134 N1129 N1123 _NC102 _NC103 AO22X1
X52 N1082 B[11] N1131 _NC104 _NC105 NOR2X0
X53 A[10] N1131 N1132 _NC106 _NC107 NOR2X0
X54 B[11] N1082 N1132 B[10] N1125 _NC108 _NC109 AOI22X1
X55 A[10] N1096 N1131 N1120 _NC110 _NC111 AO21X1
X56 A[9] N1097 N1117 _NC112 _NC113 NAND2X0
X57 N1117 N1083 B[8] N1130 _NC114 _NC115 NAND3X0
X58 A[9] N1097 N1130 N1126 _NC116 _NC117 OA21X1
X59 N1080 B[12] N1128 _NC118 _NC119 OR2X1
X60 N1127 N1128 N1078 N1119 _NC120 _NC121 NAND3X0
X61 N1125 N1120 N1126 N1125 N1119 N1124 _NC122 _NC123 AO221X1
X62 N1123 N1124 N1115 _NC124 _NC125 AND2X1
X63 N1121 N1122 N1115 N1111 _NC126 _NC127 NAND3X0
X64 N1083 B[8] N1118 _NC128 _NC129 OR2X1
X65 N1081 N1077 N1117 N1118 N1116 _NC130 _NC131 NAND4X0
X66 N1115 N1116 N1112 _NC132 _NC133 NAND2X0
X67 A[16] N1093 N1113 _NC134 _NC135 NAND2X0
X68 N1111 N1112 N1075 N1113 N1107 _NC136 _NC137 NAND4X0
X69 N1107 N1108 N1109 N1110 N1106 _NC138 _NC139 NOR4X0
X70 N1104 N1105 N1106 GE_LT_GT_LE _NC140 _NC141 AO21X1
X71 B[16] _NC142 _NC143 N1093 INVX0
X72 B[5] _NC144 _NC145 N1099 INVX0
X73 B[9] _NC146 _NC147 N1097 INVX0
X74 B[13] _NC148 _NC149 N1095 INVX0
X75 B[22] _NC150 _NC151 N1090 INVX0
X76 N1108 _NC152 _NC153 N1073 INVX0
X77 B[2] _NC154 _NC155 N1100 INVX0
X78 B[10] _NC156 _NC157 N1096 INVX0
X79 B[6] _NC158 _NC159 N1098 INVX0
X80 B[14] _NC160 _NC161 N1094 INVX0
X81 A[1] _NC162 _NC163 N1088 INVX0
X82 B[18] _NC164 _NC165 N1092 INVX0
X83 N1119 _NC166 _NC167 N1077 INVX0
X84 N1120 _NC168 _NC169 N1081 INVX0
X85 N1129 _NC170 _NC171 N1078 INVX0
X86 B[20] _NC172 _NC173 N1091 INVX0
X87 N1164 _NC174 _NC175 N1071 INVX0
X88 A[24] _NC176 _NC177 N1101 INVX0
X89 N1156 _NC178 _NC179 N1089 INVX0
X90 N1140 _NC180 _NC181 N1084 INVX0
X91 N1109 _NC182 _NC183 N1069 INVX0
X92 A[26] _NC184 _NC185 N1103 INVX0
X93 A[25] _NC186 _NC187 N1102 INVX0
X94 A[15] _NC188 _NC189 N1079 INVX0
X95 A[7] _NC190 _NC191 N1085 INVX0
X96 A[11] _NC192 _NC193 N1082 INVX0
X97 A[19] _NC194 _NC195 N1074 INVX0
X98 A[23] _NC196 _NC197 N1070 INVX0
X99 A[3] _NC198 _NC199 N1087 INVX0
X100 A[17] _NC200 _NC201 N1076 INVX0
X101 A[21] _NC202 _NC203 N1072 INVX0
X102 A[4] _NC204 _NC205 N1086 INVX0
X103 A[8] _NC206 _NC207 N1083 INVX0
X104 A[12] _NC208 _NC209 N1080 INVX0
X105 N1114 _NC210 _NC211 N1075 INVX0
.ENDS serial_div_DW_cmp_0

.SUBCKT serial_div_DW01_sub_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] DIFF[9] DIFF[10] DIFF[11] DIFF[12] DIFF[13] DIFF[14] DIFF[15] DIFF[16] DIFF[17] DIFF[18] DIFF[19] DIFF[20] DIFF[21] DIFF[22] DIFF[23] DIFF[24] DIFF[25] DIFF[26] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 B[26] _NC2 _NC3 N2 INVX0
X2 B[25] _NC4 _NC5 N3 INVX0
X3 B[24] _NC6 _NC7 N4 INVX0
X4 B[13] _NC8 _NC9 N15 INVX0
X5 B[9] _NC10 _NC11 N19 INVX0
X6 B[5] _NC12 _NC13 N23 INVX0
X7 B[23] _NC14 _NC15 N5 INVX0
X8 B[21] _NC16 _NC17 N7 INVX0
X9 B[19] _NC18 _NC19 N9 INVX0
X10 B[17] _NC20 _NC21 N11 INVX0
X11 B[15] _NC22 _NC23 N13 INVX0
X12 B[12] _NC24 _NC25 N16 INVX0
X13 B[11] _NC26 _NC27 N17 INVX0
X14 B[8] _NC28 _NC29 N20 INVX0
X15 B[7] _NC30 _NC31 N21 INVX0
X16 B[4] _NC32 _NC33 N24 INVX0
X17 B[3] _NC34 _NC35 N25 INVX0
X18 A[0] _NC36 _NC37 N1 INVX0
X19 N1 B[0] Carry[0] _NC38 _NC39 NAND2X1
X20 B[1] _NC40 _NC41 N27 INVX0
X21 B[2] _NC42 _NC43 N26 INVX0
X22 B[22] _NC44 _NC45 N6 INVX0
X23 B[20] _NC46 _NC47 N8 INVX0
X24 B[16] _NC48 _NC49 N12 INVX0
X25 B[18] _NC50 _NC51 N10 INVX0
X26 B[14] _NC52 _NC53 N14 INVX0
X27 B[10] _NC54 _NC55 N18 INVX0
X28 B[6] _NC56 _NC57 N22 INVX0
X29 A[26] N2 Carry[25] DIFF[26] _NC58 _NC59 XOR3X1
X30 A[1] N27 Carry[0] Carry[1] DIFF[1] _NC60 _NC61 FADDX1
X31 A[2] N26 Carry[1] Carry[2] DIFF[2] _NC62 _NC63 FADDX1
X32 A[3] N25 Carry[2] Carry[3] DIFF[3] _NC64 _NC65 FADDX1
X33 A[4] N24 Carry[3] Carry[4] DIFF[4] _NC66 _NC67 FADDX1
X34 A[5] N23 Carry[4] Carry[5] DIFF[5] _NC68 _NC69 FADDX1
X35 A[6] N22 Carry[5] Carry[6] DIFF[6] _NC70 _NC71 FADDX1
X36 A[7] N21 Carry[6] Carry[7] DIFF[7] _NC72 _NC73 FADDX1
X37 A[8] N20 Carry[7] Carry[8] DIFF[8] _NC74 _NC75 FADDX1
X38 A[9] N19 Carry[8] Carry[9] DIFF[9] _NC76 _NC77 FADDX1
X39 A[10] N18 Carry[9] Carry[10] DIFF[10] _NC78 _NC79 FADDX1
X40 A[11] N17 Carry[10] Carry[11] DIFF[11] _NC80 _NC81 FADDX1
X41 A[12] N16 Carry[11] Carry[12] DIFF[12] _NC82 _NC83 FADDX1
X42 A[13] N15 Carry[12] Carry[13] DIFF[13] _NC84 _NC85 FADDX1
X43 A[14] N14 Carry[13] Carry[14] DIFF[14] _NC86 _NC87 FADDX1
X44 A[15] N13 Carry[14] Carry[15] DIFF[15] _NC88 _NC89 FADDX1
X45 A[16] N12 Carry[15] Carry[16] DIFF[16] _NC90 _NC91 FADDX1
X46 A[17] N11 Carry[16] Carry[17] DIFF[17] _NC92 _NC93 FADDX1
X47 A[18] N10 Carry[17] Carry[18] DIFF[18] _NC94 _NC95 FADDX1
X48 A[19] N9 Carry[18] Carry[19] DIFF[19] _NC96 _NC97 FADDX1
X49 A[20] N8 Carry[19] Carry[20] DIFF[20] _NC98 _NC99 FADDX1
X50 A[21] N7 Carry[20] Carry[21] DIFF[21] _NC100 _NC101 FADDX1
X51 A[22] N6 Carry[21] Carry[22] DIFF[22] _NC102 _NC103 FADDX1
X52 A[23] N5 Carry[22] Carry[23] DIFF[23] _NC104 _NC105 FADDX1
X53 A[24] N4 Carry[23] Carry[24] DIFF[24] _NC106 _NC107 FADDX1
X54 A[25] N3 Carry[24] Carry[25] DIFF[25] _NC108 _NC109 FADDX1
.ENDS serial_div_DW01_sub_0

.SUBCKT pre_norm_div Clk_i Opa_i[0] Opa_i[1] Opa_i[2] Opa_i[3] Opa_i[4] Opa_i[5] Opa_i[6] Opa_i[7] Opa_i[8] Opa_i[9] Opa_i[10] Opa_i[11] Opa_i[12] Opa_i[13] Opa_i[14] Opa_i[15] Opa_i[16] Opa_i[17] Opa_i[18] Opa_i[19] Opa_i[20] Opa_i[21] Opa_i[22] Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Opa_i[31] Opb_i[0] Opb_i[1] Opb_i[2] Opb_i[3] Opb_i[4] Opb_i[5] Opb_i[6] Opb_i[7] Opb_i[8] Opb_i[9] Opb_i[10] Opb_i[11] Opb_i[12] Opb_i[13] Opb_i[14] Opb_i[15] Opb_i[16] Opb_i[17] Opb_i[18] Opb_i[19] Opb_i[20] Opb_i[21] Opb_i[22] Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Opb_i[31] Exp_10_o[0] Exp_10_o[1] Exp_10_o[2] Exp_10_o[3] Exp_10_o[4] Exp_10_o[5] Exp_10_o[6] Exp_10_o[7] Exp_10_o[8] Exp_10_o[9] Dvdnd_50_o[0] Dvdnd_50_o[1] Dvdnd_50_o[2] Dvdnd_50_o[3] Dvdnd_50_o[4] Dvdnd_50_o[5] Dvdnd_50_o[6] Dvdnd_50_o[7] Dvdnd_50_o[8] Dvdnd_50_o[9] Dvdnd_50_o[10] Dvdnd_50_o[11] Dvdnd_50_o[12] Dvdnd_50_o[13] Dvdnd_50_o[14] Dvdnd_50_o[15] Dvdnd_50_o[16] Dvdnd_50_o[17] Dvdnd_50_o[18] Dvdnd_50_o[19] Dvdnd_50_o[20] Dvdnd_50_o[21] Dvdnd_50_o[22] Dvdnd_50_o[23] Dvdnd_50_o[24] Dvdnd_50_o[25] Dvdnd_50_o[26] Dvdnd_50_o[27] Dvdnd_50_o[28] Dvdnd_50_o[29] Dvdnd_50_o[30] Dvdnd_50_o[31] Dvdnd_50_o[32] Dvdnd_50_o[33] Dvdnd_50_o[34] Dvdnd_50_o[35] Dvdnd_50_o[36] Dvdnd_50_o[37] Dvdnd_50_o[38] Dvdnd_50_o[39] Dvdnd_50_o[40] Dvdnd_50_o[41] Dvdnd_50_o[42] Dvdnd_50_o[43] Dvdnd_50_o[44] Dvdnd_50_o[45] Dvdnd_50_o[46] Dvdnd_50_o[47] Dvdnd_50_o[48] Dvdnd_50_o[49] Dvsor_27_o[0] Dvsor_27_o[1] Dvsor_27_o[2] Dvsor_27_o[3] Dvsor_27_o[4] Dvsor_27_o[5] Dvsor_27_o[6] Dvsor_27_o[7] Dvsor_27_o[8] Dvsor_27_o[9] Dvsor_27_o[10] Dvsor_27_o[11] Dvsor_27_o[12] Dvsor_27_o[13] Dvsor_27_o[14] Dvsor_27_o[15] Dvsor_27_o[16] Dvsor_27_o[17] Dvsor_27_o[18] Dvsor_27_o[19] Dvsor_27_o[20] Dvsor_27_o[21] Dvsor_27_o[22] Dvsor_27_o[23] Dvsor_27_o[24] Dvsor_27_o[25] Dvsor_27_o[26]
X0 N679 S_div_zeros[5] S_div_zeros[4] Dvsor_27_o[9] _NC0 _NC1 NOR3X0
X1 N404 N678 N679 N4230 _NC2 _NC3 MUX21X1
X2 N122 N116 N676 Dvsor_27_o[8] _NC4 _NC5 AND3X1
X3 N675 N3970 N676 N4230 _NC6 _NC7 MUX21X1
X4 N673 N116 N122 Dvsor_27_o[7] _NC8 _NC9 AND3X1
X5 N672 N74 S_div_zeros[4] Dvsor_27_o[6] _NC10 _NC11 NOR3X0
X6 N671 N73 S_div_zeros[4] Dvsor_27_o[5] _NC12 _NC13 NOR3X0
X7 S_div_zeros[4] S_div_zeros[5] N670 Dvsor_27_o[4] _NC14 _NC15 NOR3X0
X8 S_div_zeros[4] N74 N669 Dvsor_27_o[3] _NC16 _NC17 NOR3X0
X9 S_div_zeros[4] N73 N668 Dvsor_27_o[2] _NC18 _NC19 NOR3X0
X10 N667 N116 Dvsor_27_o[23] _NC20 _NC21 AND2X1
X11 N673 N666 N667 N122 _NC22 _NC23 MUX21X1
X12 N4080 N665 N666 N4230 _NC24 _NC25 MUX21X1
X13 N664 N663 N665 N422 _NC26 _NC27 MUX21X1
X14 N662 N661 N663 N421 _NC28 _NC29 MUX21X1
X15 Opb_i[22] N199 N661 N79 _NC30 _NC31 MUX21X1
X16 N672 N658 N659 N122 _NC32 _NC33 MUX21X1
X17 N657 N4170 N658 N4230 _NC34 _NC35 MUX21X1
X18 N655 N654 N656 N422 _NC36 _NC37 MUX21X1
X19 N653 N652 N654 N421 _NC38 _NC39 MUX21X1
X20 Opb_i[21] Opb_i[22] N652 N79 _NC40 _NC41 MUX21X1
X21 N651 S_div_zeros[3] N672 _NC42 _NC43 OR2X1
X22 N671 N649 N650 N122 _NC44 _NC45 MUX21X1
X23 N648 N4150 N649 N4230 _NC46 _NC47 MUX21X1
X24 N646 N645 N647 N422 _NC48 _NC49 MUX21X1
X25 N644 N662 N645 N421 _NC50 _NC51 MUX21X1
X26 Opb_i[20] Opb_i[21] N662 N79 _NC52 _NC53 MUX21X1
X27 N643 S_div_zeros[3] N671 _NC54 _NC55 OR2X1
X28 N670 N641 N642 N122 _NC56 _NC57 MUX21X1
X29 N640 N4120 N641 N4230 _NC58 _NC59 MUX21X1
X30 N638 N637 N639 N422 _NC60 _NC61 MUX21X1
X31 N636 N653 N637 N421 _NC62 _NC63 MUX21X1
X32 Opb_i[19] Opb_i[20] N653 N79 _NC64 _NC65 MUX21X1
X33 N635 S_div_zeros[3] N670 _NC66 _NC67 OR2X1
X34 N634 S_div_zeros[5] S_div_zeros[4] Dvsor_27_o[1] _NC68 _NC69 NOR3X0
X35 N669 N632 N633 N122 _NC70 _NC71 MUX21X1
X36 N631 N630 N632 N4230 _NC72 _NC73 MUX21X1
X37 N629 N418 N630 N422 _NC74 _NC75 MUX21X1
X38 N628 N644 N664 N421 _NC76 _NC77 MUX21X1
X39 N72 Opb_i[19] N644 N79 _NC78 _NC79 MUX21X1
X40 N627 S_div_zeros[3] N669 _NC80 _NC81 OR2X1
X41 N668 N625 N626 N122 _NC82 _NC83 MUX21X1
X42 N624 N623 N625 N4230 _NC84 _NC85 MUX21X1
X43 N622 N4160 N623 N422 _NC86 _NC87 MUX21X1
X44 N621 N636 N655 N421 _NC88 _NC89 MUX21X1
X45 Opb_i[17] N72 N636 N79 _NC90 _NC91 MUX21X1
X46 N620 S_div_zeros[3] N668 _NC92 _NC93 OR2X1
X47 N634 N618 N619 N122 _NC94 _NC95 MUX21X1
X48 N678 N617 N618 N4230 _NC96 _NC97 MUX21X1
X49 N616 N4140 N617 N422 _NC98 _NC99 MUX21X1
X50 N615 N628 N646 N421 _NC100 _NC101 MUX21X1
X51 Opb_i[16] Opb_i[17] N628 N79 _NC102 _NC103 MUX21X1
X52 N405 N4070 N678 N422 _NC104 _NC105 MUX21X1
X53 N612 N611 N613 N122 _NC106 _NC107 MUX21X1
X54 N674 N610 N611 N4230 _NC108 _NC109 MUX21X1
X55 N609 N4110 N610 N422 _NC110 _NC111 MUX21X1
X56 N608 N621 N638 N421 _NC112 _NC113 MUX21X1
X57 Opb_i[15] Opb_i[16] N621 N79 _NC114 _NC115 MUX21X1
X58 N607 N606 N674 N422 _NC116 _NC117 MUX21X1
X59 S_div_zeros[4] N74 N605 Dvsor_27_o[15] _NC118 _NC119 NOR3X0
X60 N403 N660 N605 N4230 _NC120 _NC121 MUX21X1
X61 N604 N629 N660 N422 _NC122 _NC123 MUX21X1
X62 N603 N4130 N629 N421 _NC124 _NC125 MUX21X1
X63 Opb_i[14] Opb_i[15] N615 N79 _NC126 _NC127 MUX21X1
X64 N601 N600 N602 N422 _NC128 _NC129 MUX21X1
X65 S_div_zeros[4] N73 N599 Dvsor_27_o[14] _NC130 _NC131 NOR3X0
X66 N651 N657 N599 N4230 _NC132 _NC133 MUX21X1
X67 N598 N622 N657 N422 _NC134 _NC135 MUX21X1
X68 N597 N4100 N622 N421 _NC136 _NC137 MUX21X1
X69 Opb_i[13] Opb_i[14] N608 N79 _NC138 _NC139 MUX21X1
X70 N596 N595 N651 N422 _NC140 _NC141 MUX21X1
X71 N594 S_div_zeros[5] S_div_zeros[4] Dvsor_27_o[13] _NC142 _NC143 NOR3X0
X72 N643 N648 N594 N4230 _NC144 _NC145 MUX21X1
X73 N4070 N616 N648 N422 _NC146 _NC147 MUX21X1
X74 N593 N603 N616 N421 _NC148 _NC149 MUX21X1
X75 N453 N452 N603 N79 _NC150 _NC151 MUX21X1
X76 N591 N590 N592 N421 _NC152 _NC153 MUX21X1
X77 N614 N405 N643 N422 _NC154 _NC155 MUX21X1
X78 N588 N587 N589 N421 _NC156 _NC157 MUX21X1
X79 N585 N74 S_div_zeros[4] Dvsor_27_o[12] _NC158 _NC159 NOR3X0
X80 N635 N640 N585 N4230 _NC160 _NC161 MUX21X1
X81 N606 N609 N640 N422 _NC162 _NC163 MUX21X1
X82 N402 N597 N609 N421 _NC164 _NC165 MUX21X1
X83 N454 N453 N597 N80 _NC166 _NC167 MUX21X1
X84 N4000 N401 N606 N421 _NC168 _NC169 MUX21X1
X85 N584 N607 N635 N422 _NC170 _NC171 MUX21X1
X86 N3980 N3990 N607 N421 _NC172 _NC173 MUX21X1
X87 N583 N73 S_div_zeros[4] Dvsor_27_o[11] _NC174 _NC175 NOR3X0
X88 N627 N631 N583 N4230 _NC176 _NC177 MUX21X1
X89 N4060 N604 N631 N422 _NC178 _NC179 MUX21X1
X90 N4090 N593 N604 N421 _NC180 _NC181 MUX21X1
X91 N456 N454 N593 N80 _NC182 _NC183 MUX21X1
X92 Opb_i[8] Opb_i[9] N590 N80 _NC184 _NC185 MUX21X1
X93 N587 N591 N600 N421 _NC186 _NC187 MUX21X1
X94 Opb_i[6] Opb_i[7] N591 N80 _NC188 _NC189 MUX21X1
X95 Opb_i[4] N69 N587 N80 _NC190 _NC191 MUX21X1
X96 N586 N588 N601 N421 _NC192 _NC193 MUX21X1
X97 Opb_i[2] Opb_i[3] N588 N80 _NC194 _NC195 MUX21X1
X98 Opb_i[0] Opb_i[1] N586 N80 _NC196 _NC197 MUX21X1
X99 N582 N74 S_div_zeros[4] Dvsor_27_o[10] _NC198 _NC199 NOR3X0
X100 N620 N624 N582 N4230 _NC200 _NC201 MUX21X1
X101 N595 N598 N624 N422 _NC202 _NC203 MUX21X1
X102 N401 N402 N598 N421 _NC204 _NC205 MUX21X1
X103 Opb_i[9] Opb_i[10] N581 N80 _NC206 _NC207 MUX21X1
X104 Opb_i[7] Opb_i[8] N580 N80 _NC208 _NC209 MUX21X1
X105 N3990 N4000 N595 N421 _NC210 _NC211 MUX21X1
X106 N69 Opb_i[6] N579 N80 _NC212 _NC213 MUX21X1
X107 Opb_i[3] Opb_i[4] N578 N80 _NC214 _NC215 MUX21X1
X108 N596 S_div_zeros[2] N620 _NC216 _NC217 OR2X1
X109 N577 N3980 N596 N421 _NC218 _NC219 MUX21X1
X110 Opb_i[1] Opb_i[2] N576 N80 _NC220 _NC221 MUX21X1
X111 N612 N73 S_div_zeros[4] Dvsor_27_o[0] _NC222 _NC223 NOR3X0
X112 N577 S_div_zeros[1] N584 _NC224 _NC225 OR2X1
X113 N575 S_dvd_zeros[5] S_dvd_zeros[4] Dvdnd_50_o[35] _NC226 _NC227 NOR3X0
X114 N134 N574 N575 N153 _NC228 _NC229 MUX21X1
X115 N111 N105 N572 Dvdnd_50_o[34] _NC230 _NC231 AND3X1
X116 N571 N127 N572 N153 _NC232 _NC233 MUX21X1
X117 N569 N105 N111 Dvdnd_50_o[33] _NC234 _NC235 AND3X1
X118 N568 N76 S_dvd_zeros[4] Dvdnd_50_o[32] _NC236 _NC237 NOR3X0
X119 N567 N75 S_dvd_zeros[4] Dvdnd_50_o[31] _NC238 _NC239 NOR3X0
X120 S_dvd_zeros[4] S_dvd_zeros[5] N566 Dvdnd_50_o[30] _NC240 _NC241 NOR3X0
X121 S_dvd_zeros[4] N76 N565 Dvdnd_50_o[29] _NC242 _NC243 NOR3X0
X122 S_dvd_zeros[4] N75 N5640 Dvdnd_50_o[28] _NC244 _NC245 NOR3X0
X123 N5630 N105 Dvdnd_50_o[49] _NC246 _NC247 AND2X1
X124 N569 N5620 N5630 N111 _NC248 _NC249 MUX21X1
X125 N138 N5610 N5620 N153 _NC250 _NC251 MUX21X1
X126 N5600 N5590 N5610 N152 _NC252 _NC253 MUX21X1
X127 N558 N557 N5590 N151 _NC254 _NC255 MUX21X1
X128 Opa_i[22] N192 N557 N77 _NC256 _NC257 MUX21X1
X129 N568 N554 N555 N111 _NC258 _NC259 MUX21X1
X130 N5530 N147 N554 N153 _NC260 _NC261 MUX21X1
X131 N5510 N5500 N5520 N152 _NC262 _NC263 MUX21X1
X132 N5490 N5480 N5500 N151 _NC264 _NC265 MUX21X1
X133 Opa_i[21] Opa_i[22] N5480 N77 _NC266 _NC267 MUX21X1
X134 N5470 S_dvd_zeros[3] N568 _NC268 _NC269 OR2X1
X135 N567 N5450 N5460 N111 _NC270 _NC271 MUX21X1
X136 N5440 N145 N5450 N153 _NC272 _NC273 MUX21X1
X137 N5420 N541 N5430 N152 _NC274 _NC275 MUX21X1
X138 N540 N558 N541 N151 _NC276 _NC277 MUX21X1
X139 Opa_i[20] Opa_i[21] N558 N77 _NC278 _NC279 MUX21X1
X140 N539 S_dvd_zeros[3] N567 _NC280 _NC281 OR2X1
X141 N566 N537 N538 N111 _NC282 _NC283 MUX21X1
X142 N5360 N142 N537 N153 _NC284 _NC285 MUX21X1
X143 N5340 N5330 N5350 N152 _NC286 _NC287 MUX21X1
X144 N5320 N5490 N5330 N151 _NC288 _NC289 MUX21X1
X145 Opa_i[19] Opa_i[20] N5490 N77 _NC290 _NC291 MUX21X1
X146 N5310 S_dvd_zeros[3] N566 _NC292 _NC293 OR2X1
X147 N5300 S_dvd_zeros[5] S_dvd_zeros[4] Dvdnd_50_o[27] _NC294 _NC295 NOR3X0
X148 N565 N5280 N5290 N111 _NC296 _NC297 MUX21X1
X149 N5270 N5260 N5280 N153 _NC298 _NC299 MUX21X1
X150 N5250 N148 N5260 N152 _NC300 _NC301 MUX21X1
X151 N524 N540 N5600 N151 _NC302 _NC303 MUX21X1
X152 N103 Opa_i[19] N540 N77 _NC304 _NC305 MUX21X1
X153 N523 S_dvd_zeros[3] N565 _NC306 _NC307 OR2X1
X154 N5640 N521 N522 N111 _NC308 _NC309 MUX21X1
X155 N520 N5190 N521 N153 _NC310 _NC311 MUX21X1
X156 N5180 N146 N5190 N152 _NC312 _NC313 MUX21X1
X157 N5170 N5320 N5510 N151 _NC314 _NC315 MUX21X1
X158 Opa_i[17] N103 N5320 N77 _NC316 _NC317 MUX21X1
X159 N5160 S_dvd_zeros[3] N5640 _NC318 _NC319 OR2X1
X160 N5300 N5140 N5150 N111 _NC320 _NC321 MUX21X1
X161 N574 N5130 N5140 N153 _NC322 _NC323 MUX21X1
X162 N5120 N144 N5130 N152 _NC324 _NC325 MUX21X1
X163 N5110 N524 N5420 N151 _NC326 _NC327 MUX21X1
X164 Opa_i[16] Opa_i[17] N524 N77 _NC328 _NC329 MUX21X1
X165 N135 N137 N574 N152 _NC330 _NC331 MUX21X1
X166 N5080 N507 N5090 N111 _NC332 _NC333 MUX21X1
X167 N570 N506 N507 N153 _NC334 _NC335 MUX21X1
X168 N505 N141 N506 N152 _NC336 _NC337 MUX21X1
X169 N504 N5170 N5340 N151 _NC338 _NC339 MUX21X1
X170 Opa_i[15] Opa_i[16] N5170 N77 _NC340 _NC341 MUX21X1
X171 N503 N5020 N570 N152 _NC342 _NC343 MUX21X1
X172 S_dvd_zeros[4] N76 N5010 Dvdnd_50_o[41] _NC344 _NC345 NOR3X0
X173 N133 N556 N5010 N153 _NC346 _NC347 MUX21X1
X174 N5000 N5250 N556 N152 _NC348 _NC349 MUX21X1
X175 N4990 N143 N5250 N151 _NC350 _NC351 MUX21X1
X176 Opa_i[14] Opa_i[15] N5110 N77 _NC352 _NC353 MUX21X1
X177 N4970 N4960 N4980 N152 _NC354 _NC355 MUX21X1
X178 S_dvd_zeros[4] N75 N4950 Dvdnd_50_o[40] _NC356 _NC357 NOR3X0
X179 N5470 N5530 N4950 N153 _NC358 _NC359 MUX21X1
X180 N4940 N5180 N5530 N152 _NC360 _NC361 MUX21X1
X181 N4930 N140 N5180 N151 _NC362 _NC363 MUX21X1
X182 Opa_i[13] Opa_i[14] N504 N77 _NC364 _NC365 MUX21X1
X183 N4920 N4910 N5470 N152 _NC366 _NC367 MUX21X1
X184 N490 S_dvd_zeros[5] S_dvd_zeros[4] Dvdnd_50_o[39] _NC368 _NC369 NOR3X0
X185 N539 N5440 N490 N153 _NC370 _NC371 MUX21X1
X186 N137 N5120 N5440 N152 _NC372 _NC373 MUX21X1
X187 N489 N4990 N5120 N151 _NC374 _NC375 MUX21X1
X188 N3950 N98 N4990 N77 _NC376 _NC377 MUX21X1
X189 N487 N486 N488 N151 _NC378 _NC379 MUX21X1
X190 N5100 N135 N539 N152 _NC380 _NC381 MUX21X1
X191 N4840 N4830 N4850 N151 _NC382 _NC383 MUX21X1
X192 N4810 N76 S_dvd_zeros[4] Dvdnd_50_o[38] _NC384 _NC385 NOR3X0
X193 N5310 N5360 N4810 N153 _NC386 _NC387 MUX21X1
X194 N5020 N505 N5360 N152 _NC388 _NC389 MUX21X1
X195 N132 N4930 N505 N151 _NC390 _NC391 MUX21X1
X196 N97 N3950 N4930 N78 _NC392 _NC393 MUX21X1
X197 N130 N131 N5020 N151 _NC394 _NC395 MUX21X1
X198 N4800 N503 N5310 N152 _NC396 _NC397 MUX21X1
X199 N128 N129 N503 N151 _NC398 _NC399 MUX21X1
X200 N4790 N75 S_dvd_zeros[4] Dvdnd_50_o[37] _NC400 _NC401 NOR3X0
X201 N523 N5270 N4790 N153 _NC402 _NC403 MUX21X1
X202 N136 N5000 N5270 N152 _NC404 _NC405 MUX21X1
X203 N139 N489 N5000 N151 _NC406 _NC407 MUX21X1
X204 N95 N97 N489 N78 _NC408 _NC409 MUX21X1
X205 N91 Opa_i[9] N486 N78 _NC410 _NC411 MUX21X1
X206 N4830 N487 N4960 N151 _NC412 _NC413 MUX21X1
X207 Opa_i[6] Opa_i[7] N487 N78 _NC414 _NC415 MUX21X1
X208 Opa_i[4] N87 N4830 N78 _NC416 _NC417 MUX21X1
X209 N4820 N4840 N4970 N151 _NC418 _NC419 MUX21X1
X210 Opa_i[2] N84 N4840 N78 _NC420 _NC421 MUX21X1
X211 Opa_i[0] N81 N4820 N78 _NC422 _NC423 MUX21X1
X212 N4780 N76 S_dvd_zeros[4] Dvdnd_50_o[36] _NC424 _NC425 NOR3X0
X213 N5160 N520 N4780 N153 _NC426 _NC427 MUX21X1
X214 N4910 N4940 N520 N152 _NC428 _NC429 MUX21X1
X215 N131 N132 N4940 N151 _NC430 _NC431 MUX21X1
X216 Opa_i[9] N94 N4770 N78 _NC432 _NC433 MUX21X1
X217 Opa_i[7] N91 N4760 N78 _NC434 _NC435 MUX21X1
X218 N129 N130 N4910 N151 _NC436 _NC437 MUX21X1
X219 N87 Opa_i[6] N4750 N78 _NC438 _NC439 MUX21X1
X220 N84 Opa_i[4] N474 N78 _NC440 _NC441 MUX21X1
X221 N4920 S_dvd_zeros[2] N5160 _NC442 _NC443 OR2X1
X222 N473 N128 N4920 N151 _NC444 _NC445 MUX21X1
X223 N81 Opa_i[2] N472 N78 _NC446 _NC447 MUX21X1
X224 N5080 N75 S_dvd_zeros[4] Dvdnd_50_o[26] _NC448 _NC449 NOR3X0
X225 N473 S_dvd_zeros[1] N4800 _NC450 _NC451 OR2X1
X226 N920 N4470 N926 _NC452 _NC453 AND2X1
X227 N257 N104 N263 _NC454 _NC455 AND2X1
X228 Add_90_I24_L07002_C104_carry[3] N1216 N1227 _NC456 _NC457 XOR2X1
X229 N1211 _NC458 _NC459 N1222 INVX0
X230 Add_90_I23_L07002_C104_carry[3] N1199 N1210 _NC460 _NC461 XOR2X1
X231 N1194 _NC462 _NC463 N1205 INVX0
X232 Add_90_I22_L07002_C104_carry[3] N1182 N1193 _NC464 _NC465 XOR2X1
X233 N1177 _NC466 _NC467 N1188 INVX0
X234 Add_90_I21_L07002_C104_carry[3] N1165 N1176 _NC468 _NC469 XOR2X1
X235 N1160 _NC470 _NC471 N1171 INVX0
X236 Add_90_I20_L07002_C104_carry[3] N1148 N1159 _NC472 _NC473 XOR2X1
X237 N1143 _NC474 _NC475 N1154 INVX0
X238 Add_90_I19_L07002_C104_carry[3] N1131 N1142 _NC476 _NC477 XOR2X1
X239 N1126 _NC478 _NC479 N1137 INVX0
X240 Add_90_I18_L07002_C104_carry[3] N1114 N1125 _NC480 _NC481 XOR2X1
X241 Add_90_I17_L07002_C104_carry[3] N1097 N1108 _NC482 _NC483 XOR2X1
X242 N1092 _NC484 _NC485 N1103 INVX0
X243 Add_90_I16_L07002_C104_carry[3] N1080 N1091 _NC486 _NC487 XOR2X1
X244 N1075 _NC488 _NC489 N1086 INVX0
X245 Add_90_I15_L07002_C104_carry[3] N1063 N1074 _NC490 _NC491 XOR2X1
X246 N1058 _NC492 _NC493 N1069 INVX0
X247 Add_90_I14_L07002_C104_carry[3] N1046 N1057 _NC494 _NC495 XOR2X1
X248 N1041 _NC496 _NC497 N1052 INVX0
X249 Add_90_I13_L07002_C104_carry[3] N1029 N1040 _NC498 _NC499 XOR2X1
X250 N1024 _NC500 _NC501 N1035 INVX0
X251 Add_90_I12_L07002_C104_carry[3] N1012 N1023 _NC502 _NC503 XOR2X1
X252 N1007 _NC504 _NC505 N1018 INVX0
X253 Add_90_I11_L07002_C104_carry[3] N995 N1006 _NC506 _NC507 XOR2X1
X254 N990 _NC508 _NC509 N1001 INVX0
X255 Add_90_I10_L07002_C104_carry[3] N978 N989 _NC510 _NC511 XOR2X1
X256 N973 _NC512 _NC513 N984 INVX0
X257 Add_90_I9_L07002_C104_carry[3] N961 N972 _NC514 _NC515 XOR2X1
X258 N956 _NC516 _NC517 N967 INVX0
X259 N939 _NC518 _NC519 N950 INVX0
X260 N922 _NC520 _NC521 N933 INVX0
X261 N906 _NC522 _NC523 N916 INVX0
X262 N892 _NC524 _NC525 N901 INVX0
X263 Add_90_I24_L07002_C103_carry[3] N553 N564 _NC526 _NC527 XOR2X1
X264 N548 _NC528 _NC529 N559 INVX0
X265 Add_90_I23_L07002_C103_carry[3] N536 N547 _NC530 _NC531 XOR2X1
X266 N531 _NC532 _NC533 N542 INVX0
X267 Add_90_I22_L07002_C103_carry[3] N519 N530 _NC534 _NC535 XOR2X1
X268 N514 _NC536 _NC537 N525 INVX0
X269 Add_90_I21_L07002_C103_carry[3] N502 N513 _NC538 _NC539 XOR2X1
X270 N497 _NC540 _NC541 N508 INVX0
X271 Add_90_I20_L07002_C103_carry[3] N485 N496 _NC542 _NC543 XOR2X1
X272 N480 _NC544 _NC545 N491 INVX0
X273 Add_90_I19_L07002_C103_carry[3] N468 N479 _NC546 _NC547 XOR2X1
X274 Add_90_I18_L07002_C103_carry[3] N451 N462 _NC548 _NC549 XOR2X1
X275 N446 _NC550 _NC551 N457 INVX0
X276 Add_90_I17_L07002_C103_carry[3] N434 N445 _NC552 _NC553 XOR2X1
X277 N429 _NC554 _NC555 N440 INVX0
X278 Add_90_I16_L07002_C103_carry[3] N417 N428 _NC556 _NC557 XOR2X1
X279 N412 _NC558 _NC559 N423 INVX0
X280 Add_90_I15_L07002_C103_carry[3] N400 N411 _NC560 _NC561 XOR2X1
X281 N395 _NC562 _NC563 N406 INVX0
X282 Add_90_I14_L07002_C103_carry[3] N383 N394 _NC564 _NC565 XOR2X1
X283 N378 _NC566 _NC567 N389 INVX0
X284 Add_90_I13_L07002_C103_carry[3] N366 N377 _NC568 _NC569 XOR2X1
X285 N361 _NC570 _NC571 N372 INVX0
X286 Add_90_I12_L07002_C103_carry[3] N349 N360 _NC572 _NC573 XOR2X1
X287 N344 _NC574 _NC575 N355 INVX0
X288 Add_90_I11_L07002_C103_carry[3] N332 N343 _NC576 _NC577 XOR2X1
X289 N327 _NC578 _NC579 N338 INVX0
X290 Add_90_I10_L07002_C103_carry[3] N315 N326 _NC580 _NC581 XOR2X1
X291 N310 _NC582 _NC583 N321 INVX0
X292 Add_90_I9_L07002_C103_carry[3] N298 N309 _NC584 _NC585 XOR2X1
X293 N293 _NC586 _NC587 N304 INVX0
X294 N276 _NC588 _NC589 N287 INVX0
X295 N259 _NC590 _NC591 N270 INVX0
X296 N243 _NC592 _NC593 N253 INVX0
X297 N229 _NC594 _NC595 N238 INVX0
X298 Opa_i[23] N150 N1526 _NC596 _NC597 XOR2X1
X299 N150 Opa_i[23] Add_116_carry[0] _NC598 _NC599 AND2X1
X300 Opa_i[24] Add_116_carry[0] N1527 _NC600 _NC601 XOR2X1
X301 Add_116_carry[0] Opa_i[24] Add_116_carry[1] _NC602 _NC603 AND2X1
X302 Opa_i[25] Add_116_carry[1] N1528 _NC604 _NC605 XOR2X1
X303 Add_116_carry[1] Opa_i[25] Add_116_carry[2] _NC606 _NC607 AND2X1
X304 Opa_i[26] Add_116_carry[2] N1529 _NC608 _NC609 XOR2X1
X305 Add_116_carry[2] Opa_i[26] Add_116_carry[3] _NC610 _NC611 AND2X1
X306 Opa_i[27] Add_116_carry[3] N1530 _NC612 _NC613 XOR2X1
X307 Add_116_carry[3] Opa_i[27] Add_116_carry[4] _NC614 _NC615 AND2X1
X308 Opa_i[28] Add_116_carry[4] N1531 _NC616 _NC617 XOR2X1
X309 Add_116_carry[4] Opa_i[28] Add_116_carry[5] _NC618 _NC619 AND2X1
X310 Opa_i[29] Add_116_carry[5] N1532 _NC620 _NC621 XOR2X1
X311 Add_116_carry[5] Opa_i[29] Add_116_carry[6] _NC622 _NC623 AND2X1
X312 Opa_i[30] Add_116_carry[6] N1533 _NC624 _NC625 XOR2X1
X313 Add_116_carry[6] Opa_i[30] N1534 _NC626 _NC627 AND2X1
X314 Opb_i[23] N420 N1535 _NC628 _NC629 XOR2X1
X315 N420 Opb_i[23] Add_117_carry[0] _NC630 _NC631 AND2X1
X316 Opb_i[24] Add_117_carry[0] N1536 _NC632 _NC633 XOR2X1
X317 Add_117_carry[0] Opb_i[24] Add_117_carry[1] _NC634 _NC635 AND2X1
X318 Opb_i[25] Add_117_carry[1] N1537 _NC636 _NC637 XOR2X1
X319 Add_117_carry[1] Opb_i[25] Add_117_carry[2] _NC638 _NC639 AND2X1
X320 Opb_i[26] Add_117_carry[2] N1538 _NC640 _NC641 XOR2X1
X321 Add_117_carry[2] Opb_i[26] Add_117_carry[3] _NC642 _NC643 AND2X1
X322 Opb_i[27] Add_117_carry[3] N1539 _NC644 _NC645 XOR2X1
X323 Add_117_carry[3] Opb_i[27] Add_117_carry[4] _NC646 _NC647 AND2X1
X324 Opb_i[28] Add_117_carry[4] N1540 _NC648 _NC649 XOR2X1
X325 Add_117_carry[4] Opb_i[28] Add_117_carry[5] _NC650 _NC651 AND2X1
X326 Opb_i[29] Add_117_carry[5] N1541 _NC652 _NC653 XOR2X1
X327 Add_117_carry[5] Opb_i[29] Add_117_carry[6] _NC654 _NC655 AND2X1
X328 Opb_i[30] Add_117_carry[6] N1542 _NC656 _NC657 XOR2X1
X329 Add_117_carry[6] Opb_i[30] N1543 _NC658 _NC659 AND2X1
X330 N67 N59 N1562 _NC660 _NC661 XOR2X1
X331 N104 _NC662 _NC663 N103 INVX0
X332 Opa_i[17] _NC664 _NC665 N102 INVX0
X333 Opa_i[16] _NC666 _NC667 N101 INVX0
X334 Opa_i[15] _NC668 _NC669 N100 INVX0
X335 Opa_i[14] _NC670 _NC671 N99 INVX0
X336 Opa_i[13] _NC672 _NC673 N98 INVX0
X337 N97 _NC674 _NC675 N96 INVX0
X338 N95 _NC676 _NC677 N94 INVX0
X339 Opa_i[9] _NC678 _NC679 N93 INVX0
X340 N92 _NC680 _NC681 N91 INVX0
X341 Opa_i[7] _NC682 _NC683 N90 INVX0
X342 Opa_i[6] _NC684 _NC685 N89 INVX0
X343 Opa_i[5] _NC686 _NC687 N88 INVX0
X344 N88 _NC688 _NC689 N87 INVX0
X345 Opa_i[4] _NC690 _NC691 N86 INVX0
X346 N85 _NC692 _NC693 N84 INVX0
X347 Opa_i[2] _NC694 _NC695 N83 INVX0
X348 N82 _NC696 _NC697 N81 INVX0
X349 N3610 Opb_i[20] N3090 _NC698 _NC699 NOR2X0
X350 Opb_i[1] _NC700 _NC701 N4650 INVX0
X351 Opb_i[2] _NC702 _NC703 N4640 INVX0
X352 Opb_i[3] _NC704 _NC705 N4630 INVX0
X353 Opb_i[7] _NC706 _NC707 N4590 INVX0
X354 Opb_i[4] _NC708 _NC709 N4620 INVX0
X355 Opb_i[6] _NC710 _NC711 N4600 INVX0
X356 Opb_i[8] _NC712 _NC713 N4580 INVX0
X357 Opb_i[10] _NC714 _NC715 N456 INVX0
X358 Opb_i[9] _NC716 _NC717 N4570 INVX0
X359 Opb_i[13] _NC718 _NC719 N452 INVX0
X360 Opb_i[12] _NC720 _NC721 N453 INVX0
X361 Opb_i[21] _NC722 _NC723 N439 INVX0
X362 Opb_i[19] _NC724 _NC725 N4400 INVX0
X363 Opb_i[14] _NC726 _NC727 N4510 INVX0
X364 Opb_i[16] _NC728 _NC729 N4490 INVX0
X365 Opb_i[15] _NC730 _NC731 N4500 INVX0
X366 Opb_i[17] _NC732 _NC733 N4480 INVX0
X367 Opa_i[21] _NC734 _NC735 N387 INVX0
X368 Opb_i[5] _NC736 _NC737 N69 NBUFFX2
X369 N352 Opb_i[8] N353 _NC738 _NC739 NOR2X0
X370 Opb_i[10] N70 N351 _NC740 _NC741 NOR2X0
X371 N3580 Opb_i[3] N3590 _NC742 _NC743 NOR2X0
X372 N579 _NC744 _NC745 N4000 INVX0
X373 N581 _NC746 _NC747 N402 INVX0
X374 N580 _NC748 _NC749 N401 INVX0
X375 N578 _NC750 _NC751 N3990 INVX0
X376 N576 _NC752 _NC753 N3980 INVX0
X377 Opb_i[0] N79 N577 _NC754 _NC755 NAND2X1
X378 N370 Opb_i[20] N368 _NC756 _NC757 NOR2X0
X379 N199 Opb_i[22] N3240 _NC758 _NC759 NOR2X0
X380 Opa_i[19] _NC760 _NC761 N388 INVX0
X381 N371 N3720 N199 _NC762 _NC763 NAND2X1
X382 Opa_i[0] N77 N473 _NC764 _NC765 NAND2X1
X383 Opb_i[11] _NC766 _NC767 N70 NBUFFX2
X384 Add_90_I8_L07002_C104_carry[3] N4670 N955 _NC768 _NC769 XNOR2X1
X385 Opb_i[18] _NC770 _NC771 N71 NBUFFX2
X386 Opb_i[18] _NC772 _NC773 N72 NBUFFX2
X387 N192 Opa_i[22] N220 _NC774 _NC775 NOR2X0
X388 N3660 N367 N192 _NC776 _NC777 NAND2X1
X389 N59 N67 N68 _NC778 _NC779 NAND2X1
X390 Opa_i[1] _NC780 _NC781 N82 INVX0
X391 N3620 _NC782 _NC783 N437 INVX0
X392 N3090 N4400 N3100 _NC784 _NC785 NAND2X1
X393 N3240 N439 N3610 _NC786 _NC787 NAND2X1
X394 Opa_i[3] _NC788 _NC789 N85 INVX0
X395 N2560 N176 N178 _NC790 _NC791 NOR2X0
X396 Opa_i[8] _NC792 _NC793 N92 INVX0
X397 N258 _NC794 _NC795 N385 INVX0
X398 N205 N388 N206 _NC796 _NC797 NAND2X1
X399 N220 N387 N2570 _NC798 _NC799 NAND2X1
X400 N351 N352 N2720 _NC800 _NC801 NAND2X1
X401 N353 N354 N285 _NC802 _NC803 NAND2X1
X402 Opa_i[11] _NC804 _NC805 N97 INVX0
X403 N2570 Opa_i[20] N205 _NC806 _NC807 NOR2X0
X404 N4460 N71 N2620 _NC808 _NC809 NOR2X0
X405 N351 N70 N283 _NC810 _NC811 NOR2X0
X406 N3580 N3590 N2790 _NC812 _NC813 NOR2X0
X407 N264 N1026 N3120 _NC814 _NC815 NAND2X1
X408 N264 N1025 N3260 _NC816 _NC817 NAND2X1
X409 N264 N1024 N3390 _NC818 _NC819 NAND2X1
X410 N4480 N4470 N3430 _NC820 _NC821 NAND2X1
X411 N353 N4590 N354 _NC822 _NC823 NAND2X1
X412 N4450 N4500 N3460 _NC824 _NC825 NAND2X1
X413 N4460 N4490 N3440 _NC826 _NC827 NAND2X1
X414 N4440 N4510 N3450 _NC828 _NC829 NAND2X1
X415 N4430 N452 N3470 _NC830 _NC831 NAND2X1
X416 N4420 N453 N318 _NC832 _NC833 NAND2X1
X417 N3590 N4640 N3600 _NC834 _NC835 NAND2X1
X418 N4620 N4610 N3580 _NC836 _NC837 NAND2X1
X419 N351 N4570 N352 _NC838 _NC839 NAND2X1
X420 N455 N4600 N2750 _NC840 _NC841 NAND2X1
X421 N69 _NC842 _NC843 N4610 INVX0
X422 Opa_i[18] _NC844 _NC845 N104 INVX0
X423 N3600 N2800 N282 _NC846 _NC847 NOR2X0
X424 N1079 _NC848 _NC849 N126 INVX0
X425 N1078 _NC850 _NC851 N4280 INVX0
X426 N1077 _NC852 _NC853 N4320 INVX0
X427 N1076 _NC854 _NC855 N436 INVX0
X428 N1094 _NC856 _NC857 N4310 INVX0
X429 N1093 _NC858 _NC859 N435 INVX0
X430 N1096 _NC860 _NC861 N125 INVX0
X431 N1095 _NC862 _NC863 N4270 INVX0
X432 N1109 _NC864 _NC865 N438 INVX0
X433 N1114 _NC866 _NC867 N118 INVX0
X434 N1097 _NC868 _NC869 N119 INVX0
X435 Opa_i[10] _NC870 _NC871 N95 INVX0
X436 Opa_i[12] _NC872 _NC873 N3950 INVX0
X437 N1130 _NC874 _NC875 N123 INVX0
X438 N1129 _NC876 _NC877 N4250 INVX0
X439 N1128 _NC878 _NC879 N4290 INVX0
X440 N1127 _NC880 _NC881 N4330 INVX0
X441 N1113 _NC882 _NC883 N124 INVX0
X442 N1112 _NC884 _NC885 N4260 INVX0
X443 N1111 _NC886 _NC887 N4300 INVX0
X444 N1110 _NC888 _NC889 N4340 INVX0
X445 N472 _NC890 _NC891 N128 INVX0
X446 N4770 _NC892 _NC893 N132 INVX0
X447 N474 _NC894 _NC895 N129 INVX0
X448 N4760 _NC896 _NC897 N131 INVX0
X449 N4750 _NC898 _NC899 N130 INVX0
X450 N3560 N3570 N3550 _NC900 _NC901 NOR2X0
X451 N592 _NC902 _NC903 N4070 INVX0
X452 N589 _NC904 _NC905 N405 INVX0
X453 N608 _NC906 _NC907 N4100 INVX0
X454 N615 _NC908 _NC909 N4130 INVX0
X455 N590 _NC910 _NC911 N4090 INVX0
X456 N70 _NC912 _NC913 N454 INVX0
X457 N199 _NC914 _NC915 N420 INVX0
X458 N252 N2530 N251 _NC916 _NC917 NOR2X0
X459 N2760 N2770 N2740 _NC918 _NC919 NOR2X0
X460 N1131 _NC920 _NC921 N117 INVX0
X461 N1080 _NC922 _NC923 N120 INVX0
X462 N656 _NC924 _NC925 N4170 INVX0
X463 N73 N659 Dvsor_27_o[22] _NC926 _NC927 NOR2X0
X464 N938 N4480 N4670 _NC928 _NC929 NAND2X1
X465 N192 _NC930 _NC931 N150 INVX0
X466 N586 N421 N614 _NC932 _NC933 NAND2X1
X467 N5520 _NC934 _NC935 N147 INVX0
X468 N75 N555 Dvdnd_50_o[48] _NC936 _NC937 NOR2X0
X469 N2950 N2960 N2940 _NC938 _NC939 NOR2X0
X470 N3060 N3070 N3050 _NC940 _NC941 NOR2X0
X471 N3210 N3220 N320 _NC942 _NC943 NOR2X0
X472 N334 N335 N333 _NC944 _NC945 NOR2X0
X473 N71 _NC946 _NC947 N4470 INVX0
X474 N2970 N2980 N4240 S_div_zeros[3] _NC948 _NC949 OA21X1
X475 N4820 N151 N5100 _NC950 _NC951 NAND2X1
X476 N286 N2870 N4240 S_div_zeros[4] _NC952 _NC953 OA21X1
X477 N191 N1920 N190 _NC954 _NC955 NOR2X0
X478 N202 N203 N201 _NC956 _NC957 NOR2X0
X479 N2300 N2310 N2290 _NC958 _NC959 NOR2X0
X480 N217 N218 N216 _NC960 _NC961 NOR2X0
X481 N3650 Opa_i[20] N3630 _NC962 _NC963 NOR2X0
X482 Add_90_I8_L07002_C103_carry[3] N4660 N292 _NC964 _NC965 XNOR2X1
X483 N3100 _NC966 _NC967 N4240 INVX0
X484 N86 N88 N2540 _NC968 _NC969 NAND2X1
X485 N102 N104 N2390 _NC970 _NC971 NAND2X1
X486 N3930 N100 N242 _NC972 _NC973 NAND2X1
X487 N3940 N101 N2400 _NC974 _NC975 NAND2X1
X488 N3920 N99 N2410 _NC976 _NC977 NAND2X1
X489 N2550 N83 N2560 _NC978 _NC979 NAND2X1
X490 N3910 N98 N2430 _NC980 _NC981 NAND2X1
X491 N3900 N3950 N214 _NC982 _NC983 NAND2X1
X492 N206 _NC984 _NC985 N154 INVX0
X493 N3430 N4450 N2610 _NC986 _NC987 NOR2X0
X494 N249 N90 N250 _NC988 _NC989 NAND2X1
X495 N3440 N4440 N2630 _NC990 _NC991 NOR2X0
X496 N247 N93 N248 _NC992 _NC993 NAND2X1
X497 N3960 N89 N171 _NC994 _NC995 NAND2X1
X498 N455 N2750 N2730 _NC996 _NC997 NAND2X1
X499 N354 _NC998 _NC999 N455 INVX0
X500 N3450 _NC1000 _NC1001 N4430 INVX0
X501 N3440 _NC1002 _NC1003 N4450 INVX0
X502 N3460 _NC1004 _NC1005 N4440 INVX0
X503 N3470 _NC1006 _NC1007 N4420 INVX0
X504 N318 _NC1008 _NC1009 N4410 INVX0
X505 N3430 _NC1010 _NC1011 N4460 INVX0
X506 N3460 N4430 N268 _NC1012 _NC1013 NOR2X0
X507 N3450 N4420 N267 _NC1014 _NC1015 NOR2X0
X508 N3470 N4410 N264 _NC1016 _NC1017 NOR2X0
X509 N160 N362 N222 _NC1018 _NC1019 NAND2X1
X510 N160 N363 N208 _NC1020 _NC1021 NAND2X1
X511 N160 N361 N235 _NC1022 _NC1023 NAND2X1
X512 S_div_zeros[0] _NC1024 _NC1025 N419 INVX0
X513 N416 _NC1026 _NC1027 N115 INVX0
X514 N415 _NC1028 _NC1029 N3760 INVX0
X515 N413 _NC1030 _NC1031 N384 INVX0
X516 N414 _NC1032 _NC1033 N3800 INVX0
X517 N664 _NC1034 _NC1035 N418 INVX0
X518 N655 _NC1036 _NC1037 N4160 INVX0
X519 N646 _NC1038 _NC1039 N4140 INVX0
X520 N638 _NC1040 _NC1041 N4110 INVX0
X521 N463 _NC1042 _NC1043 N386 INVX0
X522 S_dvd_zeros[0] _NC1044 _NC1045 N149 INVX0
X523 N602 _NC1046 _NC1047 N403 INVX0
X524 N74 N626 Dvsor_27_o[18] _NC1048 _NC1049 NOR2X0
X525 N403 S_div_zeros[3] N673 _NC1050 _NC1051 NOR2X0
X526 N584 S_div_zeros[2] N675 _NC1052 _NC1053 NOR2X0
X527 N2590 N2600 N4240 S_div_zeros[5] _NC1054 _NC1055 OA21X1
X528 N2590 N2600 N4240 N73 _NC1056 _NC1057 OA21X1
X529 N677 _NC1058 _NC1059 N404 INVX0
X530 S_div_zeros[4] _NC1060 _NC1061 N122 INVX0
X531 N647 _NC1062 _NC1063 N4150 INVX0
X532 N74 N650 Dvsor_27_o[21] _NC1064 _NC1065 NOR2X0
X533 N467 _NC1066 _NC1067 N112 INVX0
X534 N466 _NC1068 _NC1069 N3730 INVX0
X535 N464 _NC1070 _NC1071 N3810 INVX0
X536 N465 _NC1072 _NC1073 N3770 INVX0
X537 N450 _NC1074 _NC1075 N113 INVX0
X538 N449 _NC1076 _NC1077 N3740 INVX0
X539 N447 _NC1078 _NC1079 N3820 INVX0
X540 N448 _NC1080 _NC1081 N3780 INVX0
X541 N4670 _NC1082 _NC1083 N121 INVX0
X542 N451 _NC1084 _NC1085 N107 INVX0
X543 N434 _NC1086 _NC1087 N108 INVX0
X544 N73 N633 Dvsor_27_o[19] _NC1088 _NC1089 NOR2X0
X545 N73 N613 Dvsor_27_o[16] _NC1090 _NC1091 NOR2X0
X546 N639 _NC1092 _NC1093 N4120 INVX0
X547 S_div_zeros[5] N642 Dvsor_27_o[20] _NC1094 _NC1095 NOR2X0
X548 N600 _NC1096 _NC1097 N4060 INVX0
X549 N614 S_div_zeros[2] N677 _NC1098 _NC1099 NOR2X0
X550 N601 N422 N627 _NC1100 _NC1101 NAND2X1
X551 N2590 N2600 N4240 N74 _NC1102 _NC1103 OA21X1
X552 S_div_zeros[3] _NC1104 _NC1105 N4230 INVX0
X553 S_div_zeros[2] _NC1106 _NC1107 N422 INVX0
X554 S_div_zeros[1] _NC1108 _NC1109 N421 INVX0
X555 N5600 _NC1110 _NC1111 N148 INVX0
X556 N5430 _NC1112 _NC1113 N145 INVX0
X557 N76 N5460 Dvdnd_50_o[47] _NC1114 _NC1115 NOR2X0
X558 N5350 _NC1116 _NC1117 N142 INVX0
X559 S_dvd_zeros[5] N538 Dvdnd_50_o[46] _NC1118 _NC1119 NOR2X0
X560 N4980 _NC1120 _NC1121 N133 INVX0
X561 N488 _NC1122 _NC1123 N137 INVX0
X562 N4850 _NC1124 _NC1125 N135 INVX0
X563 N504 _NC1126 _NC1127 N140 INVX0
X564 N5110 _NC1128 _NC1129 N143 INVX0
X565 N486 _NC1130 _NC1131 N139 INVX0
X566 N4800 S_dvd_zeros[2] N571 _NC1132 _NC1133 NOR2X0
X567 N275 N102 N4660 _NC1134 _NC1135 NAND2X1
X568 N5100 S_dvd_zeros[2] N573 _NC1136 _NC1137 NOR2X0
X569 N4970 N152 N523 _NC1138 _NC1139 NAND2X1
X570 S_dvd_zeros[1] _NC1140 _NC1141 N151 INVX0
X571 N172 N173 N170 _NC1142 _NC1143 NOR2X0
X572 N468 _NC1144 _NC1145 N106 INVX0
X573 N417 _NC1146 _NC1147 N109 INVX0
X574 N193 N194 N154 S_dvd_zeros[3] _NC1148 _NC1149 OA21X1
X575 N182 N183 N154 S_dvd_zeros[4] _NC1150 _NC1151 OA21X1
X576 N2400 N3920 N159 _NC1152 _NC1153 NOR2X0
X577 N2390 N3930 N157 _NC1154 _NC1155 NOR2X0
X578 N3940 N103 N158 _NC1156 _NC1157 NOR2X0
X579 N242 _NC1158 _NC1159 N3920 INVX0
X580 N2410 _NC1160 _NC1161 N3910 INVX0
X581 N2400 _NC1162 _NC1163 N3930 INVX0
X582 N2430 _NC1164 _NC1165 N3900 INVX0
X583 N2390 _NC1166 _NC1167 N3940 INVX0
X584 N242 N3910 N164 _NC1168 _NC1169 NOR2X0
X585 N2410 N3900 N163 _NC1170 _NC1171 NOR2X0
X586 N2540 N2550 N175 _NC1172 _NC1173 NOR2X0
X587 N2540 N84 N2550 _NC1174 _NC1175 NOR2X0
X588 N214 _NC1176 _NC1177 N3890 INVX0
X589 N2430 N3890 N160 _NC1178 _NC1179 NOR2X0
X590 N3960 N171 N169 _NC1180 _NC1181 NAND2X1
X591 N250 _NC1182 _NC1183 N3960 INVX0
X592 N249 N250 N181 _NC1184 _NC1185 NAND2X1
X593 N247 N248 N168 _NC1186 _NC1187 NAND2X1
X594 N248 N91 N249 _NC1188 _NC1189 NOR2X0
X595 N247 N96 N179 _NC1190 _NC1191 NOR2X0
X596 N94 N96 N247 _NC1192 _NC1193 NOR2X0
X597 N419 _NC1194 _NC1195 N80 NBUFFX2
X598 N419 _NC1196 _NC1197 N79 NBUFFX2
X599 N660 _NC1198 _NC1199 N4080 INVX0
X600 N674 _NC1200 _NC1201 N3970 INVX0
X601 N433 _NC1202 _NC1203 N114 INVX0
X602 S_div_zeros[5] _NC1204 _NC1205 N116 INVX0
X603 N149 _NC1206 _NC1207 N78 NBUFFX2
X604 N149 _NC1208 _NC1209 N77 NBUFFX2
X605 N430 _NC1210 _NC1211 N3830 INVX0
X606 N431 _NC1212 _NC1213 N3790 INVX0
X607 N432 _NC1214 _NC1215 N3750 INVX0
X608 S_div_zeros[5] N619 Dvsor_27_o[17] _NC1216 _NC1217 NOR2X0
X609 N677 N4230 N634 _NC1218 _NC1219 NAND2X1
X610 N675 N4230 N612 _NC1220 _NC1221 NAND2X1
X611 N5510 _NC1222 _NC1223 N146 INVX0
X612 N5420 _NC1224 _NC1225 N144 INVX0
X613 N5340 _NC1226 _NC1227 N141 INVX0
X614 N4660 _NC1228 _NC1229 N110 INVX0
X615 N570 _NC1230 _NC1231 N127 INVX0
X616 N76 N522 Dvdnd_50_o[44] _NC1232 _NC1233 NOR2X0
X617 N75 N5290 Dvdnd_50_o[45] _NC1234 _NC1235 NOR2X0
X618 N75 N5090 Dvdnd_50_o[42] _NC1236 _NC1237 NOR2X0
X619 N133 S_dvd_zeros[3] N569 _NC1238 _NC1239 NOR2X0
X620 N4960 _NC1240 _NC1241 N136 INVX0
X621 N573 N153 N5300 _NC1242 _NC1243 NAND2X1
X622 N571 N153 N5080 _NC1244 _NC1245 NAND2X1
X623 N155 N156 N154 S_dvd_zeros[5] _NC1246 _NC1247 OA21X1
X624 N155 N156 N154 N75 _NC1248 _NC1249 OA21X1
X625 N573 _NC1250 _NC1251 N134 INVX0
X626 S_dvd_zeros[4] _NC1252 _NC1253 N111 INVX0
X627 S_dvd_zeros[3] _NC1254 _NC1255 N153 INVX0
X628 S_dvd_zeros[2] _NC1256 _NC1257 N152 INVX0
X629 N155 N156 N154 N76 _NC1258 _NC1259 OA21X1
X630 N556 _NC1260 _NC1261 N138 INVX0
X631 S_dvd_zeros[5] _NC1262 _NC1263 N105 INVX0
X632 S_dvd_zeros[5] N5150 Dvdnd_50_o[43] _NC1264 _NC1265 NOR2X0
X633 Vdd _NC1266 _NC1267 Dvdnd_50_o[25] INVX0
X634 Vdd _NC1268 _NC1269 Dvdnd_50_o[24] INVX0
X635 Vdd _NC1270 _NC1271 Dvdnd_50_o[23] INVX0
X636 Vdd _NC1272 _NC1273 Dvdnd_50_o[22] INVX0
X637 Vdd _NC1274 _NC1275 Dvdnd_50_o[21] INVX0
X638 Vdd _NC1276 _NC1277 Dvdnd_50_o[20] INVX0
X639 Vdd _NC1278 _NC1279 Dvdnd_50_o[19] INVX0
X640 Vdd _NC1280 _NC1281 Dvdnd_50_o[18] INVX0
X641 Vdd _NC1282 _NC1283 Dvdnd_50_o[17] INVX0
X642 Vdd _NC1284 _NC1285 Dvdnd_50_o[16] INVX0
X643 Vdd _NC1286 _NC1287 Dvdnd_50_o[15] INVX0
X644 Vdd _NC1288 _NC1289 Dvdnd_50_o[14] INVX0
X645 Vdd _NC1290 _NC1291 Dvdnd_50_o[13] INVX0
X646 Vdd _NC1292 _NC1293 Dvdnd_50_o[12] INVX0
X647 Vdd _NC1294 _NC1295 Dvdnd_50_o[11] INVX0
X648 Vdd _NC1296 _NC1297 Dvdnd_50_o[10] INVX0
X649 Vdd _NC1298 _NC1299 Dvdnd_50_o[9] INVX0
X650 Vdd _NC1300 _NC1301 Dvdnd_50_o[8] INVX0
X651 Vdd _NC1302 _NC1303 Dvdnd_50_o[7] INVX0
X652 Vdd _NC1304 _NC1305 Dvdnd_50_o[6] INVX0
X653 Vdd _NC1306 _NC1307 Dvdnd_50_o[5] INVX0
X654 Vdd _NC1308 _NC1309 Dvdnd_50_o[4] INVX0
X655 Vdd _NC1310 _NC1311 Dvdnd_50_o[3] INVX0
X656 Vdd _NC1312 _NC1313 Dvdnd_50_o[2] INVX0
X657 Vdd _NC1314 _NC1315 Dvdnd_50_o[1] INVX0
X658 Vdd _NC1316 _NC1317 Dvdnd_50_o[0] INVX0
X659 Vdd _NC1318 _NC1319 Dvsor_27_o[26] INVX0
X660 Vdd _NC1320 _NC1321 Dvsor_27_o[25] INVX0
X661 Vdd _NC1322 _NC1323 Dvsor_27_o[24] INVX0
X662 N231 Add_90_I5_L07002_C103_carry[2] N241 _NC1324 _NC1325 _NC1326 HADDX1
X663 N230 N229 Add_90_I5_L07002_C103_carry[2] _NC1327 _NC1328 _NC1329 HADDX1
X664 N246 Add_90_I6_L07002_C103_carry[3] N257 _NC1330 _NC1331 _NC1332 HADDX1
X665 N245 Add_90_I6_L07002_C103_carry[2] Add_90_I6_L07002_C103_carry[3] _NC1333 _NC1334 _NC1335 HADDX1
X666 N244 N243 Add_90_I6_L07002_C103_carry[2] _NC1336 _NC1337 _NC1338 HADDX1
X667 N263 Add_90_I7_L07002_C103_carry[2] N275 _NC1339 _NC1340 _NC1341 HADDX1
X668 N262 Add_90_I7_L07002_C103_carry[1] Add_90_I7_L07002_C103_carry[2] _NC1342 _NC1343 _NC1344 HADDX1
X669 N261 Add_90_I7_L07002_C103_carry[0] Add_90_I7_L07002_C103_carry[1] _NC1345 _NC1346 _NC1347 HADDX1
X670 N260 N259 Add_90_I7_L07002_C103_carry[0] _NC1348 _NC1349 _NC1350 HADDX1
X671 N280 Add_90_I8_L07002_C103_carry[2] Add_90_I8_L07002_C103_carry[3] _NC1351 _NC1352 _NC1353 HADDX1
X672 N279 Add_90_I8_L07002_C103_carry[1] Add_90_I8_L07002_C103_carry[2] _NC1354 _NC1355 _NC1356 HADDX1
X673 N278 Add_90_I8_L07002_C103_carry[0] Add_90_I8_L07002_C103_carry[1] _NC1357 _NC1358 _NC1359 HADDX1
X674 N277 N276 Add_90_I8_L07002_C103_carry[0] _NC1360 _NC1361 _NC1362 HADDX1
X675 N297 Add_90_I9_L07002_C103_carry[2] Add_90_I9_L07002_C103_carry[3] _NC1363 _NC1364 _NC1365 HADDX1
X676 N296 Add_90_I9_L07002_C103_carry[1] Add_90_I9_L07002_C103_carry[2] _NC1366 _NC1367 _NC1368 HADDX1
X677 N295 Add_90_I9_L07002_C103_carry[0] Add_90_I9_L07002_C103_carry[1] _NC1369 _NC1370 _NC1371 HADDX1
X678 N294 N293 Add_90_I9_L07002_C103_carry[0] _NC1372 _NC1373 _NC1374 HADDX1
X679 N314 Add_90_I10_L07002_C103_carry[2] Add_90_I10_L07002_C103_carry[3] _NC1375 _NC1376 _NC1377 HADDX1
X680 N313 Add_90_I10_L07002_C103_carry[1] Add_90_I10_L07002_C103_carry[2] _NC1378 _NC1379 _NC1380 HADDX1
X681 N312 Add_90_I10_L07002_C103_carry[0] Add_90_I10_L07002_C103_carry[1] _NC1381 _NC1382 _NC1383 HADDX1
X682 N311 N310 Add_90_I10_L07002_C103_carry[0] _NC1384 _NC1385 _NC1386 HADDX1
X683 N331 Add_90_I11_L07002_C103_carry[2] Add_90_I11_L07002_C103_carry[3] _NC1387 _NC1388 _NC1389 HADDX1
X684 N330 Add_90_I11_L07002_C103_carry[1] Add_90_I11_L07002_C103_carry[2] _NC1390 _NC1391 _NC1392 HADDX1
X685 N329 Add_90_I11_L07002_C103_carry[0] Add_90_I11_L07002_C103_carry[1] _NC1393 _NC1394 _NC1395 HADDX1
X686 N328 N327 Add_90_I11_L07002_C103_carry[0] _NC1396 _NC1397 _NC1398 HADDX1
X687 N348 Add_90_I12_L07002_C103_carry[2] Add_90_I12_L07002_C103_carry[3] _NC1399 _NC1400 _NC1401 HADDX1
X688 N347 Add_90_I12_L07002_C103_carry[1] Add_90_I12_L07002_C103_carry[2] _NC1402 _NC1403 _NC1404 HADDX1
X689 N346 Add_90_I12_L07002_C103_carry[0] Add_90_I12_L07002_C103_carry[1] _NC1405 _NC1406 _NC1407 HADDX1
X690 N345 N344 Add_90_I12_L07002_C103_carry[0] _NC1408 _NC1409 _NC1410 HADDX1
X691 N365 Add_90_I13_L07002_C103_carry[2] Add_90_I13_L07002_C103_carry[3] _NC1411 _NC1412 _NC1413 HADDX1
X692 N364 Add_90_I13_L07002_C103_carry[1] Add_90_I13_L07002_C103_carry[2] _NC1414 _NC1415 _NC1416 HADDX1
X693 N363 Add_90_I13_L07002_C103_carry[0] Add_90_I13_L07002_C103_carry[1] _NC1417 _NC1418 _NC1419 HADDX1
X694 N362 N361 Add_90_I13_L07002_C103_carry[0] _NC1420 _NC1421 _NC1422 HADDX1
X695 N382 Add_90_I14_L07002_C103_carry[2] Add_90_I14_L07002_C103_carry[3] _NC1423 _NC1424 _NC1425 HADDX1
X696 N381 Add_90_I14_L07002_C103_carry[1] Add_90_I14_L07002_C103_carry[2] _NC1426 _NC1427 _NC1428 HADDX1
X697 N380 Add_90_I14_L07002_C103_carry[0] Add_90_I14_L07002_C103_carry[1] _NC1429 _NC1430 _NC1431 HADDX1
X698 N379 N378 Add_90_I14_L07002_C103_carry[0] _NC1432 _NC1433 _NC1434 HADDX1
X699 N399 Add_90_I15_L07002_C103_carry[2] Add_90_I15_L07002_C103_carry[3] _NC1435 _NC1436 _NC1437 HADDX1
X700 N398 Add_90_I15_L07002_C103_carry[1] Add_90_I15_L07002_C103_carry[2] _NC1438 _NC1439 _NC1440 HADDX1
X701 N397 Add_90_I15_L07002_C103_carry[0] Add_90_I15_L07002_C103_carry[1] _NC1441 _NC1442 _NC1443 HADDX1
X702 N396 N395 Add_90_I15_L07002_C103_carry[0] _NC1444 _NC1445 _NC1446 HADDX1
X703 N416 Add_90_I16_L07002_C103_carry[2] Add_90_I16_L07002_C103_carry[3] _NC1447 _NC1448 _NC1449 HADDX1
X704 N415 Add_90_I16_L07002_C103_carry[1] Add_90_I16_L07002_C103_carry[2] _NC1450 _NC1451 _NC1452 HADDX1
X705 N414 Add_90_I16_L07002_C103_carry[0] Add_90_I16_L07002_C103_carry[1] _NC1453 _NC1454 _NC1455 HADDX1
X706 N413 N412 Add_90_I16_L07002_C103_carry[0] _NC1456 _NC1457 _NC1458 HADDX1
X707 N433 Add_90_I17_L07002_C103_carry[2] Add_90_I17_L07002_C103_carry[3] _NC1459 _NC1460 _NC1461 HADDX1
X708 N432 Add_90_I17_L07002_C103_carry[1] Add_90_I17_L07002_C103_carry[2] _NC1462 _NC1463 _NC1464 HADDX1
X709 N431 Add_90_I17_L07002_C103_carry[0] Add_90_I17_L07002_C103_carry[1] _NC1465 _NC1466 _NC1467 HADDX1
X710 N430 N429 Add_90_I17_L07002_C103_carry[0] _NC1468 _NC1469 _NC1470 HADDX1
X711 N450 Add_90_I18_L07002_C103_carry[2] Add_90_I18_L07002_C103_carry[3] _NC1471 _NC1472 _NC1473 HADDX1
X712 N449 Add_90_I18_L07002_C103_carry[1] Add_90_I18_L07002_C103_carry[2] _NC1474 _NC1475 _NC1476 HADDX1
X713 N448 Add_90_I18_L07002_C103_carry[0] Add_90_I18_L07002_C103_carry[1] _NC1477 _NC1478 _NC1479 HADDX1
X714 N447 N446 Add_90_I18_L07002_C103_carry[0] _NC1480 _NC1481 _NC1482 HADDX1
X715 N467 Add_90_I19_L07002_C103_carry[2] Add_90_I19_L07002_C103_carry[3] _NC1483 _NC1484 _NC1485 HADDX1
X716 N466 Add_90_I19_L07002_C103_carry[1] Add_90_I19_L07002_C103_carry[2] _NC1486 _NC1487 _NC1488 HADDX1
X717 N465 Add_90_I19_L07002_C103_carry[0] Add_90_I19_L07002_C103_carry[1] _NC1489 _NC1490 _NC1491 HADDX1
X718 N464 N463 Add_90_I19_L07002_C103_carry[0] _NC1492 _NC1493 _NC1494 HADDX1
X719 N484 Add_90_I20_L07002_C103_carry[2] Add_90_I20_L07002_C103_carry[3] _NC1495 _NC1496 _NC1497 HADDX1
X720 N483 Add_90_I20_L07002_C103_carry[1] Add_90_I20_L07002_C103_carry[2] _NC1498 _NC1499 _NC1500 HADDX1
X721 N482 Add_90_I20_L07002_C103_carry[0] Add_90_I20_L07002_C103_carry[1] _NC1501 _NC1502 _NC1503 HADDX1
X722 N481 N480 Add_90_I20_L07002_C103_carry[0] _NC1504 _NC1505 _NC1506 HADDX1
X723 N501 Add_90_I21_L07002_C103_carry[2] Add_90_I21_L07002_C103_carry[3] _NC1507 _NC1508 _NC1509 HADDX1
X724 N500 Add_90_I21_L07002_C103_carry[1] Add_90_I21_L07002_C103_carry[2] _NC1510 _NC1511 _NC1512 HADDX1
X725 N499 Add_90_I21_L07002_C103_carry[0] Add_90_I21_L07002_C103_carry[1] _NC1513 _NC1514 _NC1515 HADDX1
X726 N498 N497 Add_90_I21_L07002_C103_carry[0] _NC1516 _NC1517 _NC1518 HADDX1
X727 N518 Add_90_I22_L07002_C103_carry[2] Add_90_I22_L07002_C103_carry[3] _NC1519 _NC1520 _NC1521 HADDX1
X728 N517 Add_90_I22_L07002_C103_carry[1] Add_90_I22_L07002_C103_carry[2] _NC1522 _NC1523 _NC1524 HADDX1
X729 N516 Add_90_I22_L07002_C103_carry[0] Add_90_I22_L07002_C103_carry[1] _NC1525 _NC1526 _NC1527 HADDX1
X730 N515 N514 Add_90_I22_L07002_C103_carry[0] _NC1528 _NC1529 _NC1530 HADDX1
X731 N535 Add_90_I23_L07002_C103_carry[2] Add_90_I23_L07002_C103_carry[3] _NC1531 _NC1532 _NC1533 HADDX1
X732 N534 Add_90_I23_L07002_C103_carry[1] Add_90_I23_L07002_C103_carry[2] _NC1534 _NC1535 _NC1536 HADDX1
X733 N533 Add_90_I23_L07002_C103_carry[0] Add_90_I23_L07002_C103_carry[1] _NC1537 _NC1538 _NC1539 HADDX1
X734 N532 N531 Add_90_I23_L07002_C103_carry[0] _NC1540 _NC1541 _NC1542 HADDX1
X735 N552 Add_90_I24_L07002_C103_carry[2] Add_90_I24_L07002_C103_carry[3] _NC1543 _NC1544 _NC1545 HADDX1
X736 N551 Add_90_I24_L07002_C103_carry[1] Add_90_I24_L07002_C103_carry[2] _NC1546 _NC1547 _NC1548 HADDX1
X737 N550 Add_90_I24_L07002_C103_carry[0] Add_90_I24_L07002_C103_carry[1] _NC1549 _NC1550 _NC1551 HADDX1
X738 N549 N548 Add_90_I24_L07002_C103_carry[0] _NC1552 _NC1553 _NC1554 HADDX1
X739 N894 Add_90_I5_L07002_C104_carry[2] N904 _NC1555 _NC1556 _NC1557 HADDX1
X740 N893 N892 Add_90_I5_L07002_C104_carry[2] _NC1558 _NC1559 _NC1560 HADDX1
X741 N909 Add_90_I6_L07002_C104_carry[3] N920 _NC1561 _NC1562 _NC1563 HADDX1
X742 N908 Add_90_I6_L07002_C104_carry[2] Add_90_I6_L07002_C104_carry[3] _NC1564 _NC1565 _NC1566 HADDX1
X743 N907 N906 Add_90_I6_L07002_C104_carry[2] _NC1567 _NC1568 _NC1569 HADDX1
X744 N926 Add_90_I7_L07002_C104_carry[2] N938 _NC1570 _NC1571 _NC1572 HADDX1
X745 N925 Add_90_I7_L07002_C104_carry[1] Add_90_I7_L07002_C104_carry[2] _NC1573 _NC1574 _NC1575 HADDX1
X746 N924 Add_90_I7_L07002_C104_carry[0] Add_90_I7_L07002_C104_carry[1] _NC1576 _NC1577 _NC1578 HADDX1
X747 N923 N922 Add_90_I7_L07002_C104_carry[0] _NC1579 _NC1580 _NC1581 HADDX1
X748 N943 Add_90_I8_L07002_C104_carry[2] Add_90_I8_L07002_C104_carry[3] _NC1582 _NC1583 _NC1584 HADDX1
X749 N942 Add_90_I8_L07002_C104_carry[1] Add_90_I8_L07002_C104_carry[2] _NC1585 _NC1586 _NC1587 HADDX1
X750 N941 Add_90_I8_L07002_C104_carry[0] Add_90_I8_L07002_C104_carry[1] _NC1588 _NC1589 _NC1590 HADDX1
X751 N940 N939 Add_90_I8_L07002_C104_carry[0] _NC1591 _NC1592 _NC1593 HADDX1
X752 N960 Add_90_I9_L07002_C104_carry[2] Add_90_I9_L07002_C104_carry[3] _NC1594 _NC1595 _NC1596 HADDX1
X753 N959 Add_90_I9_L07002_C104_carry[1] Add_90_I9_L07002_C104_carry[2] _NC1597 _NC1598 _NC1599 HADDX1
X754 N958 Add_90_I9_L07002_C104_carry[0] Add_90_I9_L07002_C104_carry[1] _NC1600 _NC1601 _NC1602 HADDX1
X755 N957 N956 Add_90_I9_L07002_C104_carry[0] _NC1603 _NC1604 _NC1605 HADDX1
X756 N977 Add_90_I10_L07002_C104_carry[2] Add_90_I10_L07002_C104_carry[3] _NC1606 _NC1607 _NC1608 HADDX1
X757 N976 Add_90_I10_L07002_C104_carry[1] Add_90_I10_L07002_C104_carry[2] _NC1609 _NC1610 _NC1611 HADDX1
X758 N975 Add_90_I10_L07002_C104_carry[0] Add_90_I10_L07002_C104_carry[1] _NC1612 _NC1613 _NC1614 HADDX1
X759 N974 N973 Add_90_I10_L07002_C104_carry[0] _NC1615 _NC1616 _NC1617 HADDX1
X760 N994 Add_90_I11_L07002_C104_carry[2] Add_90_I11_L07002_C104_carry[3] _NC1618 _NC1619 _NC1620 HADDX1
X761 N993 Add_90_I11_L07002_C104_carry[1] Add_90_I11_L07002_C104_carry[2] _NC1621 _NC1622 _NC1623 HADDX1
X762 N992 Add_90_I11_L07002_C104_carry[0] Add_90_I11_L07002_C104_carry[1] _NC1624 _NC1625 _NC1626 HADDX1
X763 N991 N990 Add_90_I11_L07002_C104_carry[0] _NC1627 _NC1628 _NC1629 HADDX1
X764 N1011 Add_90_I12_L07002_C104_carry[2] Add_90_I12_L07002_C104_carry[3] _NC1630 _NC1631 _NC1632 HADDX1
X765 N1010 Add_90_I12_L07002_C104_carry[1] Add_90_I12_L07002_C104_carry[2] _NC1633 _NC1634 _NC1635 HADDX1
X766 N1009 Add_90_I12_L07002_C104_carry[0] Add_90_I12_L07002_C104_carry[1] _NC1636 _NC1637 _NC1638 HADDX1
X767 N1008 N1007 Add_90_I12_L07002_C104_carry[0] _NC1639 _NC1640 _NC1641 HADDX1
X768 N1028 Add_90_I13_L07002_C104_carry[2] Add_90_I13_L07002_C104_carry[3] _NC1642 _NC1643 _NC1644 HADDX1
X769 N1027 Add_90_I13_L07002_C104_carry[1] Add_90_I13_L07002_C104_carry[2] _NC1645 _NC1646 _NC1647 HADDX1
X770 N1026 Add_90_I13_L07002_C104_carry[0] Add_90_I13_L07002_C104_carry[1] _NC1648 _NC1649 _NC1650 HADDX1
X771 N1025 N1024 Add_90_I13_L07002_C104_carry[0] _NC1651 _NC1652 _NC1653 HADDX1
X772 N1045 Add_90_I14_L07002_C104_carry[2] Add_90_I14_L07002_C104_carry[3] _NC1654 _NC1655 _NC1656 HADDX1
X773 N1044 Add_90_I14_L07002_C104_carry[1] Add_90_I14_L07002_C104_carry[2] _NC1657 _NC1658 _NC1659 HADDX1
X774 N1043 Add_90_I14_L07002_C104_carry[0] Add_90_I14_L07002_C104_carry[1] _NC1660 _NC1661 _NC1662 HADDX1
X775 N1042 N1041 Add_90_I14_L07002_C104_carry[0] _NC1663 _NC1664 _NC1665 HADDX1
X776 N1062 Add_90_I15_L07002_C104_carry[2] Add_90_I15_L07002_C104_carry[3] _NC1666 _NC1667 _NC1668 HADDX1
X777 N1061 Add_90_I15_L07002_C104_carry[1] Add_90_I15_L07002_C104_carry[2] _NC1669 _NC1670 _NC1671 HADDX1
X778 N1060 Add_90_I15_L07002_C104_carry[0] Add_90_I15_L07002_C104_carry[1] _NC1672 _NC1673 _NC1674 HADDX1
X779 N1059 N1058 Add_90_I15_L07002_C104_carry[0] _NC1675 _NC1676 _NC1677 HADDX1
X780 N1079 Add_90_I16_L07002_C104_carry[2] Add_90_I16_L07002_C104_carry[3] _NC1678 _NC1679 _NC1680 HADDX1
X781 N1078 Add_90_I16_L07002_C104_carry[1] Add_90_I16_L07002_C104_carry[2] _NC1681 _NC1682 _NC1683 HADDX1
X782 N1077 Add_90_I16_L07002_C104_carry[0] Add_90_I16_L07002_C104_carry[1] _NC1684 _NC1685 _NC1686 HADDX1
X783 N1076 N1075 Add_90_I16_L07002_C104_carry[0] _NC1687 _NC1688 _NC1689 HADDX1
X784 N1096 Add_90_I17_L07002_C104_carry[2] Add_90_I17_L07002_C104_carry[3] _NC1690 _NC1691 _NC1692 HADDX1
X785 N1095 Add_90_I17_L07002_C104_carry[1] Add_90_I17_L07002_C104_carry[2] _NC1693 _NC1694 _NC1695 HADDX1
X786 N1094 Add_90_I17_L07002_C104_carry[0] Add_90_I17_L07002_C104_carry[1] _NC1696 _NC1697 _NC1698 HADDX1
X787 N1093 N1092 Add_90_I17_L07002_C104_carry[0] _NC1699 _NC1700 _NC1701 HADDX1
X788 N1113 Add_90_I18_L07002_C104_carry[2] Add_90_I18_L07002_C104_carry[3] _NC1702 _NC1703 _NC1704 HADDX1
X789 N1112 Add_90_I18_L07002_C104_carry[1] Add_90_I18_L07002_C104_carry[2] _NC1705 _NC1706 _NC1707 HADDX1
X790 N1111 Add_90_I18_L07002_C104_carry[0] Add_90_I18_L07002_C104_carry[1] _NC1708 _NC1709 _NC1710 HADDX1
X791 N1110 N1109 Add_90_I18_L07002_C104_carry[0] _NC1711 _NC1712 _NC1713 HADDX1
X792 N1130 Add_90_I19_L07002_C104_carry[2] Add_90_I19_L07002_C104_carry[3] _NC1714 _NC1715 _NC1716 HADDX1
X793 N1129 Add_90_I19_L07002_C104_carry[1] Add_90_I19_L07002_C104_carry[2] _NC1717 _NC1718 _NC1719 HADDX1
X794 N1128 Add_90_I19_L07002_C104_carry[0] Add_90_I19_L07002_C104_carry[1] _NC1720 _NC1721 _NC1722 HADDX1
X795 N1127 N1126 Add_90_I19_L07002_C104_carry[0] _NC1723 _NC1724 _NC1725 HADDX1
X796 N1147 Add_90_I20_L07002_C104_carry[2] Add_90_I20_L07002_C104_carry[3] _NC1726 _NC1727 _NC1728 HADDX1
X797 N1146 Add_90_I20_L07002_C104_carry[1] Add_90_I20_L07002_C104_carry[2] _NC1729 _NC1730 _NC1731 HADDX1
X798 N1145 Add_90_I20_L07002_C104_carry[0] Add_90_I20_L07002_C104_carry[1] _NC1732 _NC1733 _NC1734 HADDX1
X799 N1144 N1143 Add_90_I20_L07002_C104_carry[0] _NC1735 _NC1736 _NC1737 HADDX1
X800 N1164 Add_90_I21_L07002_C104_carry[2] Add_90_I21_L07002_C104_carry[3] _NC1738 _NC1739 _NC1740 HADDX1
X801 N1163 Add_90_I21_L07002_C104_carry[1] Add_90_I21_L07002_C104_carry[2] _NC1741 _NC1742 _NC1743 HADDX1
X802 N1162 Add_90_I21_L07002_C104_carry[0] Add_90_I21_L07002_C104_carry[1] _NC1744 _NC1745 _NC1746 HADDX1
X803 N1161 N1160 Add_90_I21_L07002_C104_carry[0] _NC1747 _NC1748 _NC1749 HADDX1
X804 N1181 Add_90_I22_L07002_C104_carry[2] Add_90_I22_L07002_C104_carry[3] _NC1750 _NC1751 _NC1752 HADDX1
X805 N1180 Add_90_I22_L07002_C104_carry[1] Add_90_I22_L07002_C104_carry[2] _NC1753 _NC1754 _NC1755 HADDX1
X806 N1179 Add_90_I22_L07002_C104_carry[0] Add_90_I22_L07002_C104_carry[1] _NC1756 _NC1757 _NC1758 HADDX1
X807 N1178 N1177 Add_90_I22_L07002_C104_carry[0] _NC1759 _NC1760 _NC1761 HADDX1
X808 N1198 Add_90_I23_L07002_C104_carry[2] Add_90_I23_L07002_C104_carry[3] _NC1762 _NC1763 _NC1764 HADDX1
X809 N1197 Add_90_I23_L07002_C104_carry[1] Add_90_I23_L07002_C104_carry[2] _NC1765 _NC1766 _NC1767 HADDX1
X810 N1196 Add_90_I23_L07002_C104_carry[0] Add_90_I23_L07002_C104_carry[1] _NC1768 _NC1769 _NC1770 HADDX1
X811 N1195 N1194 Add_90_I23_L07002_C104_carry[0] _NC1771 _NC1772 _NC1773 HADDX1
X812 N1215 Add_90_I24_L07002_C104_carry[2] Add_90_I24_L07002_C104_carry[3] _NC1774 _NC1775 _NC1776 HADDX1
X813 N1214 Add_90_I24_L07002_C104_carry[1] Add_90_I24_L07002_C104_carry[2] _NC1777 _NC1778 _NC1779 HADDX1
X814 N1213 Add_90_I24_L07002_C104_carry[0] Add_90_I24_L07002_C104_carry[1] _NC1780 _NC1781 _NC1782 HADDX1
X815 N1212 N1211 Add_90_I24_L07002_C104_carry[0] _NC1783 _NC1784 _NC1785 HADDX1
X816 N1564 N1565 N1566 N1567 N1568 N1569 N1570 N1571 N1572 N1573 S_dvd_zeros[0] S_dvd_zeros[1] S_dvd_zeros[2] S_dvd_zeros[3] S_dvd_zeros[4] N76 Vss Vss Vss Vss Vss N1574 N1575 N1576 N1577 N1578 N1579 N1580 N1581 N1582 N1583 _NC1786 pre_norm_div_DW01_sub_0
X817 N1544 N1545 N1546 N1547 N1548 N1549 N1550 N1551 N1552 N1553 S_div_zeros[0] S_div_zeros[1] S_div_zeros[2] S_div_zeros[3] S_div_zeros[4] N74 Vss Vss Vss Vss Vss N1564 N1565 N1566 N1567 N1568 N1569 N1570 N1571 N1572 N1573 _NC1787 pre_norm_div_DW01_add_2
X818 S_expa_in[0] S_expa_in[1] S_expa_in[2] S_expa_in[3] S_expa_in[4] S_expa_in[5] S_expa_in[6] S_expa_in[7] S_expa_in[8] Vss N61 N60 N62 N63 N64 N65 N66 N1561 N1562 N68 Vss N1544 N1545 N1546 N1547 N1548 N1549 N1550 N1551 N1552 N1553 _NC1788 pre_norm_div_DW01_add_3
X819 Opb_i[26] Opb_i[25] Opb_i[24] Opb_i[23] N371 _NC1789 _NC1790 NOR4X0
X820 Opb_i[30] Opb_i[29] Opb_i[28] Opb_i[27] N3720 _NC1791 _NC1792 NOR4X0
X821 N199 Opb_i[22] N3620 _NC1793 _NC1794 XOR2X1
X822 N3620 Opb_i[21] N370 _NC1795 _NC1796 XOR2X1
X823 N370 Opb_i[20] N892 _NC1797 _NC1798 XOR2X1
X824 N901 N4400 N892 Opb_i[19] N906 _NC1799 _NC1800 AO22X1
X825 N916 N4470 N72 N906 N922 _NC1801 _NC1802 AO22X1
X826 N933 N4480 Opb_i[17] N922 N939 _NC1803 _NC1804 AO22X1
X827 N950 N4490 Opb_i[16] N939 N956 _NC1805 _NC1806 AO22X1
X828 N967 N4500 Opb_i[15] N956 N973 _NC1807 _NC1808 AO22X1
X829 N984 N4510 Opb_i[14] N973 N990 _NC1809 _NC1810 AO22X1
X830 N1001 N452 Opb_i[13] N990 N1007 _NC1811 _NC1812 AO22X1
X831 N3620 N439 N3240 N369 _NC1813 _NC1814 AO21X1
X832 N369 N368 N893 _NC1815 _NC1816 XOR2X1
X833 N902 N4400 Opb_i[19] N893 N907 _NC1817 _NC1818 AO22X1
X834 N917 N4470 N72 N907 N923 _NC1819 _NC1820 AO22X1
X835 N934 N4480 Opb_i[17] N923 N940 _NC1821 _NC1822 AO22X1
X836 N951 N4490 Opb_i[16] N940 N957 _NC1823 _NC1824 AO22X1
X837 N968 N4500 Opb_i[15] N957 N974 _NC1825 _NC1826 AO22X1
X838 N985 N4510 Opb_i[14] N974 N991 _NC1827 _NC1828 AO22X1
X839 N1002 N452 Opb_i[13] N991 N1008 _NC1829 _NC1830 AO22X1
X840 N368 N369 N894 _NC1831 _NC1832 AND2X1
X841 N903 N4400 Opb_i[19] N894 N908 _NC1833 _NC1834 AO22X1
X842 N918 N4470 N72 N908 N924 _NC1835 _NC1836 AO22X1
X843 N935 N4480 Opb_i[17] N924 N941 _NC1837 _NC1838 AO22X1
X844 N952 N4490 Opb_i[16] N941 N958 _NC1839 _NC1840 AO22X1
X845 N969 N4500 Opb_i[15] N958 N975 _NC1841 _NC1842 AO22X1
X846 N986 N4510 Opb_i[14] N975 N992 _NC1843 _NC1844 AO22X1
X847 N1003 N452 Opb_i[13] N992 N1009 _NC1845 _NC1846 AO22X1
X848 N904 N4400 N909 _NC1847 _NC1848 AND2X1
X849 N919 N4470 N909 N72 N925 _NC1849 _NC1850 AO22X1
X850 N936 N4480 Opb_i[17] N925 N942 _NC1851 _NC1852 AO22X1
X851 N953 N4490 Opb_i[16] N942 N959 _NC1853 _NC1854 AO22X1
X852 N970 N4500 Opb_i[15] N959 N976 _NC1855 _NC1856 AO22X1
X853 N987 N4510 Opb_i[14] N976 N993 _NC1857 _NC1858 AO22X1
X854 N1004 N452 Opb_i[13] N993 N1010 _NC1859 _NC1860 AO22X1
X855 N937 N4480 Opb_i[17] N926 N943 _NC1861 _NC1862 AO22X1
X856 N954 N4490 Opb_i[16] N943 N960 _NC1863 _NC1864 AO22X1
X857 N971 N4500 Opb_i[15] N960 N977 _NC1865 _NC1866 AO22X1
X858 N988 N4510 Opb_i[14] N977 N994 _NC1867 _NC1868 AO22X1
X859 N1005 N452 Opb_i[13] N994 N1011 _NC1869 _NC1870 AO22X1
X860 N955 N4490 Opb_i[16] N121 N961 _NC1871 _NC1872 AO22X1
X861 N972 N4500 Opb_i[15] N961 N978 _NC1873 _NC1874 AO22X1
X862 N989 N4510 Opb_i[14] N978 N995 _NC1875 _NC1876 AO22X1
X863 N1006 N452 Opb_i[13] N995 N1012 _NC1877 _NC1878 AO22X1
X864 N1018 N453 Opb_i[12] N1007 N1024 _NC1879 _NC1880 AO22X1
X865 N1019 N453 Opb_i[12] N1008 N1025 _NC1881 _NC1882 AO22X1
X866 N1020 N453 Opb_i[12] N1009 N1026 _NC1883 _NC1884 AO22X1
X867 N1021 N453 Opb_i[12] N1010 N1027 _NC1885 _NC1886 AO22X1
X868 N1022 N453 Opb_i[12] N1011 N1028 _NC1887 _NC1888 AO22X1
X869 N1023 N453 Opb_i[12] N1012 N1029 _NC1889 _NC1890 AO22X1
X870 N1035 N454 N70 N1024 N1041 _NC1891 _NC1892 AO22X1
X871 N1036 N454 N70 N1025 N1042 _NC1893 _NC1894 AO22X1
X872 N1037 N454 N70 N1026 N1043 _NC1895 _NC1896 AO22X1
X873 N1038 N454 N70 N1027 N1044 _NC1897 _NC1898 AO22X1
X874 N1039 N454 N70 N1028 N1045 _NC1899 _NC1900 AO22X1
X875 N1040 N454 N70 N1029 N1046 _NC1901 _NC1902 AO22X1
X876 N1052 N456 Opb_i[10] N1041 N1058 _NC1903 _NC1904 AO22X1
X877 N1053 N456 Opb_i[10] N1042 N1059 _NC1905 _NC1906 AO22X1
X878 N1054 N456 Opb_i[10] N1043 N1060 _NC1907 _NC1908 AO22X1
X879 N1055 N456 Opb_i[10] N1044 N1061 _NC1909 _NC1910 AO22X1
X880 N1056 N456 Opb_i[10] N1045 N1062 _NC1911 _NC1912 AO22X1
X881 N1057 N456 Opb_i[10] N1046 N1063 _NC1913 _NC1914 AO22X1
X882 N1069 N4570 Opb_i[9] N1058 N1075 _NC1915 _NC1916 AO22X1
X883 N1070 N4570 Opb_i[9] N1059 N1076 _NC1917 _NC1918 AO22X1
X884 N1071 N4570 Opb_i[9] N1060 N1077 _NC1919 _NC1920 AO22X1
X885 N1072 N4570 Opb_i[9] N1061 N1078 _NC1921 _NC1922 AO22X1
X886 N1073 N4570 Opb_i[9] N1062 N1079 _NC1923 _NC1924 AO22X1
X887 N1074 N4570 Opb_i[9] N1063 N1080 _NC1925 _NC1926 AO22X1
X888 N1086 N4580 Opb_i[8] N1075 N1092 _NC1927 _NC1928 AO22X1
X889 N1087 N4580 Opb_i[8] N1076 N1093 _NC1929 _NC1930 AO22X1
X890 N1088 N4580 Opb_i[8] N1077 N1094 _NC1931 _NC1932 AO22X1
X891 N1089 N4580 Opb_i[8] N1078 N1095 _NC1933 _NC1934 AO22X1
X892 N1090 N4580 Opb_i[8] N1079 N1096 _NC1935 _NC1936 AO22X1
X893 N1091 N4580 Opb_i[8] N1080 N1097 _NC1937 _NC1938 AO22X1
X894 N1103 N4590 Opb_i[7] N1092 N1109 _NC1939 _NC1940 AO22X1
X895 N1104 N4590 Opb_i[7] N1093 N1110 _NC1941 _NC1942 AO22X1
X896 N1105 N4590 Opb_i[7] N1094 N1111 _NC1943 _NC1944 AO22X1
X897 N1106 N4590 Opb_i[7] N1095 N1112 _NC1945 _NC1946 AO22X1
X898 N1107 N4590 Opb_i[7] N1096 N1113 _NC1947 _NC1948 AO22X1
X899 N1108 N4590 Opb_i[7] N1097 N1114 _NC1949 _NC1950 AO22X1
X900 N438 N4600 Opb_i[6] N1109 N1126 _NC1951 _NC1952 AO22X1
X901 N1121 N4600 Opb_i[6] N1110 N1127 _NC1953 _NC1954 AO22X1
X902 N1122 N4600 Opb_i[6] N1111 N1128 _NC1955 _NC1956 AO22X1
X903 N1123 N4600 Opb_i[6] N1112 N1129 _NC1957 _NC1958 AO22X1
X904 N1124 N4600 Opb_i[6] N1113 N1130 _NC1959 _NC1960 AO22X1
X905 N1125 N4600 Opb_i[6] N1114 N1131 _NC1961 _NC1962 AO22X1
X906 N1137 N4610 N69 N1126 N1143 _NC1963 _NC1964 AO22X1
X907 N1138 N4610 N69 N1127 N1144 _NC1965 _NC1966 AO22X1
X908 N1139 N4610 N69 N1128 N1145 _NC1967 _NC1968 AO22X1
X909 N1140 N4610 N69 N1129 N1146 _NC1969 _NC1970 AO22X1
X910 N1141 N4610 N69 N1130 N1147 _NC1971 _NC1972 AO22X1
X911 N1142 N4610 N69 N1131 N1148 _NC1973 _NC1974 AO22X1
X912 N1154 N4620 Opb_i[4] N1143 N1160 _NC1975 _NC1976 AO22X1
X913 N1155 N4620 Opb_i[4] N1144 N1161 _NC1977 _NC1978 AO22X1
X914 N1156 N4620 Opb_i[4] N1145 N1162 _NC1979 _NC1980 AO22X1
X915 N1157 N4620 Opb_i[4] N1146 N1163 _NC1981 _NC1982 AO22X1
X916 N1158 N4620 Opb_i[4] N1147 N1164 _NC1983 _NC1984 AO22X1
X917 N1159 N4620 Opb_i[4] N1148 N1165 _NC1985 _NC1986 AO22X1
X918 N1171 N4630 Opb_i[3] N1160 N1177 _NC1987 _NC1988 AO22X1
X919 N1172 N4630 Opb_i[3] N1161 N1178 _NC1989 _NC1990 AO22X1
X920 N1173 N4630 Opb_i[3] N1162 N1179 _NC1991 _NC1992 AO22X1
X921 N1174 N4630 Opb_i[3] N1163 N1180 _NC1993 _NC1994 AO22X1
X922 N1175 N4630 Opb_i[3] N1164 N1181 _NC1995 _NC1996 AO22X1
X923 N1176 N4630 Opb_i[3] N1165 N1182 _NC1997 _NC1998 AO22X1
X924 N1188 N4640 Opb_i[2] N1177 N1194 _NC1999 _NC2000 AO22X1
X925 N1189 N4640 Opb_i[2] N1178 N1195 _NC2001 _NC2002 AO22X1
X926 N1190 N4640 Opb_i[2] N1179 N1196 _NC2003 _NC2004 AO22X1
X927 N1191 N4640 Opb_i[2] N1180 N1197 _NC2005 _NC2006 AO22X1
X928 N1192 N4640 Opb_i[2] N1181 N1198 _NC2007 _NC2008 AO22X1
X929 N1193 N4640 Opb_i[2] N1182 N1199 _NC2009 _NC2010 AO22X1
X930 N1205 N4650 Opb_i[1] N1194 N1211 _NC2011 _NC2012 AO22X1
X931 N1206 N4650 Opb_i[1] N1195 N1212 _NC2013 _NC2014 AO22X1
X932 N1207 N4650 Opb_i[1] N1196 N1213 _NC2015 _NC2016 AO22X1
X933 N1208 N4650 Opb_i[1] N1197 N1214 _NC2017 _NC2018 AO22X1
X934 N1209 N4650 Opb_i[1] N1198 N1215 _NC2019 _NC2020 AO22X1
X935 N1210 N4650 Opb_i[1] N1199 N1216 _NC2021 _NC2022 AO22X1
X936 Opa_i[26] Opa_i[25] Opa_i[24] Opa_i[23] N3660 _NC2023 _NC2024 NOR4X0
X937 Opa_i[30] Opa_i[29] Opa_i[28] Opa_i[27] N367 _NC2025 _NC2026 NOR4X0
X938 N192 Opa_i[22] N258 _NC2027 _NC2028 XOR2X1
X939 N258 Opa_i[21] N3650 _NC2029 _NC2030 XOR2X1
X940 N3650 Opa_i[20] N229 _NC2031 _NC2032 XOR2X1
X941 N258 N387 N220 N3640 _NC2033 _NC2034 AO21X1
X942 N3640 N3630 N230 _NC2035 _NC2036 XOR2X1
X943 N3630 N3640 N231 _NC2037 _NC2038 AND2X1
X944 N238 N388 N229 Opa_i[19] N243 _NC2039 _NC2040 AO22X1
X945 N239 N388 Opa_i[19] N230 N244 _NC2041 _NC2042 AO22X1
X946 N240 N388 Opa_i[19] N231 N245 _NC2043 _NC2044 AO22X1
X947 N241 N388 N246 _NC2045 _NC2046 AND2X1
X948 N253 N104 N103 N243 N259 _NC2047 _NC2048 AO22X1
X949 N254 N104 N103 N244 N260 _NC2049 _NC2050 AO22X1
X950 N255 N104 N103 N245 N261 _NC2051 _NC2052 AO22X1
X951 N256 N104 N246 N103 N262 _NC2053 _NC2054 AO22X1
X952 N270 N102 Opa_i[17] N259 N276 _NC2055 _NC2056 AO22X1
X953 N271 N102 Opa_i[17] N260 N277 _NC2057 _NC2058 AO22X1
X954 N272 N102 Opa_i[17] N261 N278 _NC2059 _NC2060 AO22X1
X955 N273 N102 Opa_i[17] N262 N279 _NC2061 _NC2062 AO22X1
X956 N274 N102 Opa_i[17] N263 N280 _NC2063 _NC2064 AO22X1
X957 N287 N101 Opa_i[16] N276 N293 _NC2065 _NC2066 AO22X1
X958 N288 N101 Opa_i[16] N277 N294 _NC2067 _NC2068 AO22X1
X959 N289 N101 Opa_i[16] N278 N295 _NC2069 _NC2070 AO22X1
X960 N290 N101 Opa_i[16] N279 N296 _NC2071 _NC2072 AO22X1
X961 N291 N101 Opa_i[16] N280 N297 _NC2073 _NC2074 AO22X1
X962 N292 N101 Opa_i[16] N110 N298 _NC2075 _NC2076 AO22X1
X963 N304 N100 Opa_i[15] N293 N310 _NC2077 _NC2078 AO22X1
X964 N305 N100 Opa_i[15] N294 N311 _NC2079 _NC2080 AO22X1
X965 N306 N100 Opa_i[15] N295 N312 _NC2081 _NC2082 AO22X1
X966 N307 N100 Opa_i[15] N296 N313 _NC2083 _NC2084 AO22X1
X967 N308 N100 Opa_i[15] N297 N314 _NC2085 _NC2086 AO22X1
X968 N309 N100 Opa_i[15] N298 N315 _NC2087 _NC2088 AO22X1
X969 N321 N99 Opa_i[14] N310 N327 _NC2089 _NC2090 AO22X1
X970 N322 N99 Opa_i[14] N311 N328 _NC2091 _NC2092 AO22X1
X971 N323 N99 Opa_i[14] N312 N329 _NC2093 _NC2094 AO22X1
X972 N324 N99 Opa_i[14] N313 N330 _NC2095 _NC2096 AO22X1
X973 N325 N99 Opa_i[14] N314 N331 _NC2097 _NC2098 AO22X1
X974 N326 N99 Opa_i[14] N315 N332 _NC2099 _NC2100 AO22X1
X975 N338 N98 Opa_i[13] N327 N344 _NC2101 _NC2102 AO22X1
X976 N339 N98 Opa_i[13] N328 N345 _NC2103 _NC2104 AO22X1
X977 N340 N98 Opa_i[13] N329 N346 _NC2105 _NC2106 AO22X1
X978 N341 N98 Opa_i[13] N330 N347 _NC2107 _NC2108 AO22X1
X979 N342 N98 Opa_i[13] N331 N348 _NC2109 _NC2110 AO22X1
X980 N343 N98 Opa_i[13] N332 N349 _NC2111 _NC2112 AO22X1
X981 N355 N3950 Opa_i[12] N344 N361 _NC2113 _NC2114 AO22X1
X982 N356 N3950 Opa_i[12] N345 N362 _NC2115 _NC2116 AO22X1
X983 N357 N3950 Opa_i[12] N346 N363 _NC2117 _NC2118 AO22X1
X984 N358 N3950 Opa_i[12] N347 N364 _NC2119 _NC2120 AO22X1
X985 N359 N3950 Opa_i[12] N348 N365 _NC2121 _NC2122 AO22X1
X986 N360 N3950 Opa_i[12] N349 N366 _NC2123 _NC2124 AO22X1
X987 N372 N97 N96 N361 N378 _NC2125 _NC2126 AO22X1
X988 N373 N97 N96 N362 N379 _NC2127 _NC2128 AO22X1
X989 N374 N97 N96 N363 N380 _NC2129 _NC2130 AO22X1
X990 N375 N97 N96 N364 N381 _NC2131 _NC2132 AO22X1
X991 N376 N97 N96 N365 N382 _NC2133 _NC2134 AO22X1
X992 N377 N97 N96 N366 N383 _NC2135 _NC2136 AO22X1
X993 N389 N95 N94 N378 N395 _NC2137 _NC2138 AO22X1
X994 N390 N95 N94 N379 N396 _NC2139 _NC2140 AO22X1
X995 N391 N95 N94 N380 N397 _NC2141 _NC2142 AO22X1
X996 N392 N95 N94 N381 N398 _NC2143 _NC2144 AO22X1
X997 N393 N95 N94 N382 N399 _NC2145 _NC2146 AO22X1
X998 N394 N95 N94 N383 N400 _NC2147 _NC2148 AO22X1
X999 N406 N93 Opa_i[9] N395 N412 _NC2149 _NC2150 AO22X1
X1000 N407 N93 Opa_i[9] N396 N413 _NC2151 _NC2152 AO22X1
X1001 N408 N93 Opa_i[9] N397 N414 _NC2153 _NC2154 AO22X1
X1002 N409 N93 Opa_i[9] N398 N415 _NC2155 _NC2156 AO22X1
X1003 N410 N93 Opa_i[9] N399 N416 _NC2157 _NC2158 AO22X1
X1004 N411 N93 Opa_i[9] N400 N417 _NC2159 _NC2160 AO22X1
X1005 N423 N92 N91 N412 N429 _NC2161 _NC2162 AO22X1
X1006 N424 N92 N91 N413 N430 _NC2163 _NC2164 AO22X1
X1007 N425 N92 N91 N414 N431 _NC2165 _NC2166 AO22X1
X1008 N426 N92 N91 N415 N432 _NC2167 _NC2168 AO22X1
X1009 N427 N92 N91 N416 N433 _NC2169 _NC2170 AO22X1
X1010 N428 N92 N91 N417 N434 _NC2171 _NC2172 AO22X1
X1011 N440 N90 Opa_i[7] N429 N446 _NC2173 _NC2174 AO22X1
X1012 N441 N90 Opa_i[7] N430 N447 _NC2175 _NC2176 AO22X1
X1013 N442 N90 Opa_i[7] N431 N448 _NC2177 _NC2178 AO22X1
X1014 N443 N90 Opa_i[7] N432 N449 _NC2179 _NC2180 AO22X1
X1015 N444 N90 Opa_i[7] N433 N450 _NC2181 _NC2182 AO22X1
X1016 N445 N90 Opa_i[7] N434 N451 _NC2183 _NC2184 AO22X1
X1017 N457 N89 Opa_i[6] N446 N463 _NC2185 _NC2186 AO22X1
X1018 N458 N89 Opa_i[6] N447 N464 _NC2187 _NC2188 AO22X1
X1019 N459 N89 Opa_i[6] N448 N465 _NC2189 _NC2190 AO22X1
X1020 N460 N89 Opa_i[6] N449 N466 _NC2191 _NC2192 AO22X1
X1021 N461 N89 Opa_i[6] N450 N467 _NC2193 _NC2194 AO22X1
X1022 N462 N89 Opa_i[6] N451 N468 _NC2195 _NC2196 AO22X1
X1023 N386 N88 N87 N463 N480 _NC2197 _NC2198 AO22X1
X1024 N475 N88 N87 N464 N481 _NC2199 _NC2200 AO22X1
X1025 N476 N88 N87 N465 N482 _NC2201 _NC2202 AO22X1
X1026 N477 N88 N87 N466 N483 _NC2203 _NC2204 AO22X1
X1027 N478 N88 N87 N467 N484 _NC2205 _NC2206 AO22X1
X1028 N479 N88 N87 N468 N485 _NC2207 _NC2208 AO22X1
X1029 N491 N86 Opa_i[4] N480 N497 _NC2209 _NC2210 AO22X1
X1030 N492 N86 Opa_i[4] N481 N498 _NC2211 _NC2212 AO22X1
X1031 N493 N86 Opa_i[4] N482 N499 _NC2213 _NC2214 AO22X1
X1032 N494 N86 Opa_i[4] N483 N500 _NC2215 _NC2216 AO22X1
X1033 N495 N86 Opa_i[4] N484 N501 _NC2217 _NC2218 AO22X1
X1034 N496 N86 Opa_i[4] N485 N502 _NC2219 _NC2220 AO22X1
X1035 N508 N85 N84 N497 N514 _NC2221 _NC2222 AO22X1
X1036 N509 N85 N84 N498 N515 _NC2223 _NC2224 AO22X1
X1037 N510 N85 N84 N499 N516 _NC2225 _NC2226 AO22X1
X1038 N511 N85 N84 N500 N517 _NC2227 _NC2228 AO22X1
X1039 N512 N85 N84 N501 N518 _NC2229 _NC2230 AO22X1
X1040 N513 N85 N84 N502 N519 _NC2231 _NC2232 AO22X1
X1041 N525 N83 Opa_i[2] N514 N531 _NC2233 _NC2234 AO22X1
X1042 N526 N83 Opa_i[2] N515 N532 _NC2235 _NC2236 AO22X1
X1043 N527 N83 Opa_i[2] N516 N533 _NC2237 _NC2238 AO22X1
X1044 N528 N83 Opa_i[2] N517 N534 _NC2239 _NC2240 AO22X1
X1045 N529 N83 Opa_i[2] N518 N535 _NC2241 _NC2242 AO22X1
X1046 N530 N83 Opa_i[2] N519 N536 _NC2243 _NC2244 AO22X1
X1047 N542 N82 N81 N531 N548 _NC2245 _NC2246 AO22X1
X1048 N543 N82 N81 N532 N549 _NC2247 _NC2248 AO22X1
X1049 N544 N82 N81 N533 N550 _NC2249 _NC2250 AO22X1
X1050 N545 N82 N81 N534 N551 _NC2251 _NC2252 AO22X1
X1051 N546 N82 N81 N535 N552 _NC2253 _NC2254 AO22X1
X1052 N547 N82 N81 N536 N553 _NC2255 _NC2256 AO22X1
X1053 N3610 N3090 N437 N336 _NC2257 _NC2258 OAI21X1
X1054 Opb_i[1] Opb_i[0] N3600 N2800 _NC2259 _NC2260 NOR3X0
X1055 N3590 N3600 N281 _NC2261 _NC2262 AND2X1
X1056 N1222 N2800 N281 N1194 N282 N1211 N3560 _NC2263 _NC2264 AO222X1
X1057 N3580 N4610 N2780 _NC2265 _NC2266 AND2X1
X1058 N2780 N1160 N69 N1143 N2790 N1177 N3570 _NC2267 _NC2268 AO222X1
X1059 N1086 N2720 N1137 N2730 N3550 N2750 N3480 _NC2269 _NC2270 OA222X1
X1060 N352 N353 N284 _NC2271 _NC2272 OR2X1
X1061 N1041 N70 N1058 N283 N350 _NC2273 _NC2274 AOI22X1
X1062 N438 N285 N1103 N284 N350 N3490 _NC2275 _NC2276 OA221X1
X1063 N3480 N3490 N318 N3380 _NC2277 _NC2278 AO21X1
X1064 N990 N268 N1007 N267 N3400 _NC2279 _NC2280 AOI22X1
X1065 N939 N2620 N956 N2610 N3420 _NC2281 _NC2282 AO22X1
X1066 N922 N72 N973 N2630 N3420 N3410 _NC2283 _NC2284 AOI221X1
X1067 N3380 N3390 N3400 N3410 N337 _NC2285 _NC2286 NAND4X0
X1068 N336 N420 N4240 N337 S_div_zeros[0] _NC2287 _NC2288 AO22X1
X1069 N1223 N2800 N281 N1195 N282 N1212 N334 _NC2289 _NC2290 AO222X1
X1070 N2780 N1161 N69 N1144 N2790 N1178 N335 _NC2291 _NC2292 AO222X1
X1071 N436 N2720 N4330 N2730 N333 N2750 N3300 _NC2293 _NC2294 OA222X1
X1072 N1042 N70 N1059 N283 N3320 _NC2295 _NC2296 AOI22X1
X1073 N4340 N285 N435 N284 N3320 N3310 _NC2297 _NC2298 OA221X1
X1074 N3300 N3310 N318 N3250 _NC2299 _NC2300 AO21X1
X1075 N991 N268 N1008 N267 N3270 _NC2301 _NC2302 AOI22X1
X1076 N940 N2620 N957 N2610 N3290 _NC2303 _NC2304 AO22X1
X1077 N923 N72 N974 N2630 N3290 N3280 _NC2305 _NC2306 AOI221X1
X1078 N3250 N3260 N3270 N3280 N3230 _NC2307 _NC2308 NAND4X0
X1079 N4240 N3230 N3240 N893 S_div_zeros[1] _NC2309 _NC2310 AO22X1
X1080 N1224 N2800 N281 N1196 N282 N1213 N3210 _NC2311 _NC2312 AO222X1
X1081 N2780 N1162 N69 N1145 N2790 N1179 N3220 _NC2313 _NC2314 AO222X1
X1082 N4320 N2720 N4290 N2730 N320 N2750 N316 _NC2315 _NC2316 OA222X1
X1083 N1043 N70 N1060 N283 N319 _NC2317 _NC2318 AOI22X1
X1084 N4300 N285 N4310 N284 N319 N317 _NC2319 _NC2320 OA221X1
X1085 N316 N317 N318 N3110 _NC2321 _NC2322 AO21X1
X1086 N992 N268 N1009 N267 N3130 _NC2323 _NC2324 AOI22X1
X1087 N941 N2620 N958 N2610 N3150 _NC2325 _NC2326 AO22X1
X1088 N924 N72 N975 N2630 N3150 N3140 _NC2327 _NC2328 AOI221X1
X1089 N3110 N3120 N3130 N3140 N3080 _NC2329 _NC2330 NAND4X0
X1090 N4240 N3080 N3090 N3100 S_div_zeros[2] _NC2331 _NC2332 AO22X1
X1091 N4270 N284 N4260 N285 N302 _NC2333 _NC2334 OA22X1
X1092 N1044 N70 N1061 N283 N303 _NC2335 _NC2336 AOI22X1
X1093 N1225 N2800 N281 N1197 N282 N1214 N3060 _NC2337 _NC2338 AO222X1
X1094 N2780 N1163 N69 N1146 N2790 N1180 N3070 _NC2339 _NC2340 AO222X1
X1095 N4280 N2720 N4250 N2730 N3050 N2750 N3040 _NC2341 _NC2342 OA222X1
X1096 N302 N303 N3040 N300 _NC2343 _NC2344 NAND3X0
X1097 N267 N1010 N268 N993 N301 _NC2345 _NC2346 AO22X1
X1098 N264 N1027 N4410 N300 N301 N2970 _NC2347 _NC2348 AO221X1
X1099 N2610 N959 N2620 N942 N299 _NC2349 _NC2350 AO22X1
X1100 N2630 N976 N72 N925 N299 N2980 _NC2351 _NC2352 AO221X1
X1101 N125 N284 N124 N285 N2910 _NC2353 _NC2354 OA22X1
X1102 N1045 N70 N1062 N283 N2920 _NC2355 _NC2356 AOI22X1
X1103 N1226 N2800 N281 N1198 N282 N1215 N2950 _NC2357 _NC2358 AO222X1
X1104 N2780 N1164 N69 N1147 N2790 N1181 N2960 _NC2359 _NC2360 AO222X1
X1105 N126 N2720 N123 N2730 N2940 N2750 N2930 _NC2361 _NC2362 OA222X1
X1106 N2910 N2920 N2930 N2890 _NC2363 _NC2364 NAND3X0
X1107 N267 N1011 N268 N994 N2900 _NC2365 _NC2366 AO22X1
X1108 N264 N1028 N4410 N2890 N2900 N286 _NC2367 _NC2368 AO221X1
X1109 N2610 N960 N2620 N943 N2880 _NC2369 _NC2370 AO22X1
X1110 N2630 N977 N72 N926 N2880 N2870 _NC2371 _NC2372 AO221X1
X1111 N119 N284 N118 N285 N269 _NC2373 _NC2374 OA22X1
X1112 N1046 N70 N1063 N283 N2700 _NC2375 _NC2376 AOI22X1
X1113 N1227 N2800 N281 N1199 N282 N1216 N2760 _NC2377 _NC2378 AO222X1
X1114 N2780 N1165 N69 N1148 N2790 N1182 N2770 _NC2379 _NC2380 AO222X1
X1115 N120 N2720 N117 N2730 N2740 N2750 N2710 _NC2381 _NC2382 OA222X1
X1116 N269 N2700 N2710 N265 _NC2383 _NC2384 NAND3X0
X1117 N267 N1012 N268 N995 N266 _NC2385 _NC2386 AO22X1
X1118 N264 N1029 N4410 N265 N266 N2590 _NC2387 _NC2388 AO221X1
X1119 N2610 N961 N2620 N121 N2630 N978 N2600 _NC2389 _NC2390 AO222X1
X1120 N2570 N205 N385 N232 _NC2391 _NC2392 OAI21X1
X1121 N81 Opa_i[0] N2560 N176 _NC2393 _NC2394 NOR3X0
X1122 N2550 N2560 N177 _NC2395 _NC2396 AND2X1
X1123 N559 N176 N177 N531 N178 N548 N252 _NC2397 _NC2398 AO222X1
X1124 N2540 N88 N174 _NC2399 _NC2400 AND2X1
X1125 N174 N497 N87 N480 N175 N514 N2530 _NC2401 _NC2402 AO222X1
X1126 N423 N168 N386 N169 N251 N171 N2440 _NC2403 _NC2404 OA222X1
X1127 N248 N249 N180 _NC2405 _NC2406 OR2X1
X1128 N378 N96 N395 N179 N2460 _NC2407 _NC2408 AOI22X1
X1129 N457 N181 N440 N180 N2460 N2450 _NC2409 _NC2410 OA221X1
X1130 N2440 N2450 N214 N234 _NC2411 _NC2412 AO21X1
X1131 N327 N164 N344 N163 N236 _NC2413 _NC2414 AOI22X1
X1132 N276 N158 N293 N157 N2380 _NC2415 _NC2416 AO22X1
X1133 N259 N103 N310 N159 N2380 N237 _NC2417 _NC2418 AOI221X1
X1134 N234 N235 N236 N237 N233 _NC2419 _NC2420 NAND4X0
X1135 N232 N150 N154 N233 S_dvd_zeros[0] _NC2421 _NC2422 AO22X1
X1136 N560 N176 N177 N532 N178 N549 N2300 _NC2423 _NC2424 AO222X1
X1137 N174 N498 N87 N481 N175 N515 N2310 _NC2425 _NC2426 AO222X1
X1138 N384 N168 N3810 N169 N2290 N171 N226 _NC2427 _NC2428 OA222X1
X1139 N379 N96 N396 N179 N228 _NC2429 _NC2430 AOI22X1
X1140 N3820 N181 N3830 N180 N228 N227 _NC2431 _NC2432 OA221X1
X1141 N226 N227 N214 N221 _NC2433 _NC2434 AO21X1
X1142 N328 N164 N345 N163 N223 _NC2435 _NC2436 AOI22X1
X1143 N277 N158 N294 N157 N225 _NC2437 _NC2438 AO22X1
X1144 N260 N103 N311 N159 N225 N224 _NC2439 _NC2440 AOI221X1
X1145 N221 N222 N223 N224 N219 _NC2441 _NC2442 NAND4X0
X1146 N154 N219 N220 N230 S_dvd_zeros[1] _NC2443 _NC2444 AO22X1
X1147 N561 N176 N177 N533 N178 N550 N217 _NC2445 _NC2446 AO222X1
X1148 N174 N499 N87 N482 N175 N516 N218 _NC2447 _NC2448 AO222X1
X1149 N3800 N168 N3770 N169 N216 N171 N212 _NC2449 _NC2450 OA222X1
X1150 N380 N96 N397 N179 N215 _NC2451 _NC2452 AOI22X1
X1151 N3780 N181 N3790 N180 N215 N213 _NC2453 _NC2454 OA221X1
X1152 N212 N213 N214 N207 _NC2455 _NC2456 AO21X1
X1153 N329 N164 N346 N163 N209 _NC2457 _NC2458 AOI22X1
X1154 N278 N158 N295 N157 N211 _NC2459 _NC2460 AO22X1
X1155 N261 N103 N312 N159 N211 N210 _NC2461 _NC2462 AOI221X1
X1156 N207 N208 N209 N210 N204 _NC2463 _NC2464 NAND4X0
X1157 N154 N204 N205 N206 S_dvd_zeros[2] _NC2465 _NC2466 AO22X1
X1158 N3750 N180 N3740 N181 N198 _NC2467 _NC2468 OA22X1
X1159 N381 N96 N398 N179 N1990 _NC2469 _NC2470 AOI22X1
X1160 N562 N176 N177 N534 N178 N551 N202 _NC2471 _NC2472 AO222X1
X1161 N174 N500 N87 N483 N175 N517 N203 _NC2473 _NC2474 AO222X1
X1162 N3760 N168 N3730 N169 N201 N171 N200 _NC2475 _NC2476 OA222X1
X1163 N198 N1990 N200 N196 _NC2477 _NC2478 NAND3X0
X1164 N163 N347 N164 N330 N197 _NC2479 _NC2480 AO22X1
X1165 N160 N364 N3890 N196 N197 N193 _NC2481 _NC2482 AO221X1
X1166 N157 N296 N158 N279 N195 _NC2483 _NC2484 AO22X1
X1167 N159 N313 N103 N262 N195 N194 _NC2485 _NC2486 AO221X1
X1168 N114 N180 N113 N181 N187 _NC2487 _NC2488 OA22X1
X1169 N382 N96 N399 N179 N188 _NC2489 _NC2490 AOI22X1
X1170 N563 N176 N177 N535 N178 N552 N191 _NC2491 _NC2492 AO222X1
X1171 N174 N501 N87 N484 N175 N518 N1920 _NC2493 _NC2494 AO222X1
X1172 N115 N168 N112 N169 N190 N171 N189 _NC2495 _NC2496 OA222X1
X1173 N187 N188 N189 N185 _NC2497 _NC2498 NAND3X0
X1174 N163 N348 N164 N331 N186 _NC2499 _NC2500 AO22X1
X1175 N160 N365 N3890 N185 N186 N182 _NC2501 _NC2502 AO221X1
X1176 N157 N297 N158 N280 N184 _NC2503 _NC2504 AO22X1
X1177 N159 N314 N103 N263 N184 N183 _NC2505 _NC2506 AO221X1
X1178 N108 N180 N107 N181 N165 _NC2507 _NC2508 OA22X1
X1179 N383 N96 N400 N179 N166 _NC2509 _NC2510 AOI22X1
X1180 N564 N176 N177 N536 N178 N553 N172 _NC2511 _NC2512 AO222X1
X1181 N174 N502 N87 N485 N175 N519 N173 _NC2513 _NC2514 AO222X1
X1182 N109 N168 N106 N169 N170 N171 N167 _NC2515 _NC2516 OA222X1
X1183 N165 N166 N167 N161 _NC2517 _NC2518 NAND3X0
X1184 N163 N349 N164 N332 N162 _NC2519 _NC2520 AO22X1
X1185 N160 N366 N3890 N161 N162 N155 _NC2521 _NC2522 AO221X1
X1186 N157 N298 N158 N110 N159 N315 N156 _NC2523 _NC2524 AO222X1
X1187 Clk_i S_exp_10_o[0] Exp_10_o[0] _NC2525 _NC2526 _NC2527 DFFX1
X1188 Clk_i N1574 S_exp_10_o[0] _NC2528 _NC2529 _NC2530 DFFX1
X1189 Clk_i S_exp_10_o[1] Exp_10_o[1] _NC2531 _NC2532 _NC2533 DFFX1
X1190 Clk_i N1575 S_exp_10_o[1] _NC2534 _NC2535 _NC2536 DFFX1
X1191 Clk_i S_exp_10_o[2] Exp_10_o[2] _NC2537 _NC2538 _NC2539 DFFX1
X1192 Clk_i N1576 S_exp_10_o[2] _NC2540 _NC2541 _NC2542 DFFX1
X1193 Clk_i S_exp_10_o[3] Exp_10_o[3] _NC2543 _NC2544 _NC2545 DFFX1
X1194 Clk_i N1577 S_exp_10_o[3] _NC2546 _NC2547 _NC2548 DFFX1
X1195 Clk_i S_exp_10_o[4] Exp_10_o[4] _NC2549 _NC2550 _NC2551 DFFX1
X1196 Clk_i N1578 S_exp_10_o[4] _NC2552 _NC2553 _NC2554 DFFX1
X1197 Clk_i S_exp_10_o[5] Exp_10_o[5] _NC2555 _NC2556 _NC2557 DFFX1
X1198 Clk_i N1579 S_exp_10_o[5] _NC2558 _NC2559 _NC2560 DFFX1
X1199 Clk_i S_exp_10_o[6] Exp_10_o[6] _NC2561 _NC2562 _NC2563 DFFX1
X1200 Clk_i N1580 S_exp_10_o[6] _NC2564 _NC2565 _NC2566 DFFX1
X1201 Clk_i S_exp_10_o[7] Exp_10_o[7] _NC2567 _NC2568 _NC2569 DFFX1
X1202 Clk_i N1581 S_exp_10_o[7] _NC2570 _NC2571 _NC2572 DFFX1
X1203 Clk_i S_exp_10_o[8] Exp_10_o[8] _NC2573 _NC2574 _NC2575 DFFX1
X1204 Clk_i N1582 S_exp_10_o[8] _NC2576 _NC2577 _NC2578 DFFX1
X1205 Clk_i S_exp_10_o[9] Exp_10_o[9] _NC2579 _NC2580 _NC2581 DFFX1
X1206 Clk_i N1583 S_exp_10_o[9] _NC2582 _NC2583 _NC2584 DFFX1
X1207 Clk_i N1535 _NC2585 N61 _NC2586 _NC2587 DFFX1
X1208 Clk_i N1536 _NC2588 N60 _NC2589 _NC2590 DFFX1
X1209 Clk_i N1537 _NC2591 N62 _NC2592 _NC2593 DFFX1
X1210 Clk_i N1538 _NC2594 N63 _NC2595 _NC2596 DFFX1
X1211 Clk_i N1539 _NC2597 N64 _NC2598 _NC2599 DFFX1
X1212 Clk_i N1540 _NC2600 N65 _NC2601 _NC2602 DFFX1
X1213 Clk_i N1541 _NC2603 N66 _NC2604 _NC2605 DFFX1
X1214 Clk_i N1542 N1561 N59 _NC2606 _NC2607 DFFX1
X1215 Clk_i N1543 _NC2608 N67 _NC2609 _NC2610 DFFX1
X1216 Clk_i N1526 S_expa_in[0] _NC2611 _NC2612 _NC2613 DFFX1
X1217 Clk_i N1527 S_expa_in[1] _NC2614 _NC2615 _NC2616 DFFX1
X1218 Clk_i N1528 S_expa_in[2] _NC2617 _NC2618 _NC2619 DFFX1
X1219 Clk_i N1529 S_expa_in[3] _NC2620 _NC2621 _NC2622 DFFX1
X1220 Clk_i N1530 S_expa_in[4] _NC2623 _NC2624 _NC2625 DFFX1
X1221 Clk_i N1531 S_expa_in[5] _NC2626 _NC2627 _NC2628 DFFX1
X1222 Clk_i N1532 S_expa_in[6] _NC2629 _NC2630 _NC2631 DFFX1
X1223 Clk_i N1533 S_expa_in[7] _NC2632 _NC2633 _NC2634 DFFX1
X1224 Clk_i N1534 S_expa_in[8] _NC2635 _NC2636 _NC2637 DFFX1
.ENDS pre_norm_div

.SUBCKT pre_norm_div_DW01_sub_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] DIFF[9] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 N2 A[8] DIFF[8] _NC2 _NC3 XOR2X1
X2 N1 A[7] DIFF[7] _NC4 _NC5 XOR2X1
X3 N4 A[6] DIFF[6] _NC6 _NC7 XOR2X1
X4 Carry[8] A[9] DIFF[9] _NC8 _NC9 XNOR2X1
X5 A[8] _NC10 _NC11 N6 INVX0
X6 N6 N2 Carry[8] _NC12 _NC13 NAND2X1
X7 N5 N1 N2 _NC14 _NC15 AND2X1
X8 N3 N4 N1 _NC16 _NC17 AND2X1
X9 B[5] _NC18 _NC19 N8 INVX0
X10 B[4] _NC20 _NC21 N9 INVX0
X11 B[3] _NC22 _NC23 N12 INVX0
X12 B[2] _NC24 _NC25 N11 INVX0
X13 A[0] _NC26 _NC27 N7 INVX0
X14 B[1] _NC28 _NC29 N10 INVX0
X15 N7 B[0] Carry[0] _NC30 _NC31 NAND2X1
X16 Carry[5] _NC32 _NC33 N4 INVX0
X17 A[7] _NC34 _NC35 N5 INVX0
X18 A[6] _NC36 _NC37 N3 INVX0
X19 A[1] N10 Carry[0] Carry[1] DIFF[1] _NC38 _NC39 FADDX1
X20 A[2] N11 Carry[1] Carry[2] DIFF[2] _NC40 _NC41 FADDX1
X21 A[3] N12 Carry[2] Carry[3] DIFF[3] _NC42 _NC43 FADDX1
X22 A[4] N9 Carry[3] Carry[4] DIFF[4] _NC44 _NC45 FADDX1
X23 A[5] N8 Carry[4] Carry[5] DIFF[5] _NC46 _NC47 FADDX1
.ENDS pre_norm_div_DW01_sub_0

.SUBCKT pre_norm_div_DW01_add_2 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] CO
X0 A[0] B[0] SUM[0] _NC0 _NC1 XOR2X1
X1 A[6] Carry[4] SUM[6] _NC2 _NC3 XOR2X1
X2 A[7] N3 SUM[7] _NC4 _NC5 XOR2X1
X3 A[8] N2 SUM[8] _NC6 _NC7 XOR2X1
X4 A[9] N4 SUM[9] _NC8 _NC9 XOR2X1
X5 A[8] N2 N4 _NC10 _NC11 AND2X1
X6 A[6] Carry[4] N3 _NC12 _NC13 AND2X1
X7 A[7] N3 N2 _NC14 _NC15 AND2X1
X8 A[0] B[0] N1 _NC16 _NC17 AND2X1
X9 A[1] B[1] N1 Carry[0] SUM[1] _NC18 _NC19 FADDX1
X10 A[2] B[2] Carry[0] Carry[1] SUM[2] _NC20 _NC21 FADDX1
X11 A[3] B[3] Carry[1] Carry[2] SUM[3] _NC22 _NC23 FADDX1
X12 A[4] B[4] Carry[2] Carry[3] SUM[4] _NC24 _NC25 FADDX1
X13 A[5] B[5] Carry[3] Carry[4] SUM[5] _NC26 _NC27 FADDX1
.ENDS pre_norm_div_DW01_add_2

.SUBCKT pre_norm_div_DW01_add_3 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] CO
X0 B[9] Carry[7] SUM[9] _NC0 _NC1 XOR2X1
X1 A[0] B[0] SUM[0] _NC2 _NC3 XOR2X1
X2 A[0] B[0] N1 _NC4 _NC5 AND2X1
X3 A[1] B[1] N1 Carry[0] SUM[1] _NC6 _NC7 FADDX1
X4 A[2] B[2] Carry[0] Carry[1] SUM[2] _NC8 _NC9 FADDX1
X5 A[3] B[3] Carry[1] Carry[2] SUM[3] _NC10 _NC11 FADDX1
X6 A[4] B[4] Carry[2] Carry[3] SUM[4] _NC12 _NC13 FADDX1
X7 A[5] B[5] Carry[3] Carry[4] SUM[5] _NC14 _NC15 FADDX1
X8 A[6] B[6] Carry[4] Carry[5] SUM[6] _NC16 _NC17 FADDX1
X9 A[7] B[7] Carry[5] Carry[6] SUM[7] _NC18 _NC19 FADDX1
X10 A[8] B[8] Carry[6] Carry[7] SUM[8] _NC20 _NC21 FADDX1
.ENDS pre_norm_div_DW01_add_3

.SUBCKT post_norm_mul Clk_i Opa_i[0] Opa_i[1] Opa_i[2] Opa_i[3] Opa_i[4] Opa_i[5] Opa_i[6] Opa_i[7] Opa_i[8] Opa_i[9] Opa_i[10] Opa_i[11] Opa_i[12] Opa_i[13] Opa_i[14] Opa_i[15] Opa_i[16] Opa_i[17] Opa_i[18] Opa_i[19] Opa_i[20] Opa_i[21] Opa_i[22] Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Opa_i[31] Opb_i[0] Opb_i[1] Opb_i[2] Opb_i[3] Opb_i[4] Opb_i[5] Opb_i[6] Opb_i[7] Opb_i[8] Opb_i[9] Opb_i[10] Opb_i[11] Opb_i[12] Opb_i[13] Opb_i[14] Opb_i[15] Opb_i[16] Opb_i[17] Opb_i[18] Opb_i[19] Opb_i[20] Opb_i[21] Opb_i[22] Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Opb_i[31] Exp_10_i[0] Exp_10_i[1] Exp_10_i[2] Exp_10_i[3] Exp_10_i[4] Exp_10_i[5] Exp_10_i[6] Exp_10_i[7] Exp_10_i[8] Exp_10_i[9] Fract_48_i[0] Fract_48_i[1] Fract_48_i[2] Fract_48_i[3] Fract_48_i[4] Fract_48_i[5] Fract_48_i[6] Fract_48_i[7] Fract_48_i[8] Fract_48_i[9] Fract_48_i[10] Fract_48_i[11] Fract_48_i[12] Fract_48_i[13] Fract_48_i[14] Fract_48_i[15] Fract_48_i[16] Fract_48_i[17] Fract_48_i[18] Fract_48_i[19] Fract_48_i[20] Fract_48_i[21] Fract_48_i[22] Fract_48_i[23] Fract_48_i[24] Fract_48_i[25] Fract_48_i[26] Fract_48_i[27] Fract_48_i[28] Fract_48_i[29] Fract_48_i[30] Fract_48_i[31] Fract_48_i[32] Fract_48_i[33] Fract_48_i[34] Fract_48_i[35] Fract_48_i[36] Fract_48_i[37] Fract_48_i[38] Fract_48_i[39] Fract_48_i[40] Fract_48_i[41] Fract_48_i[42] Fract_48_i[43] Fract_48_i[44] Fract_48_i[45] Fract_48_i[46] Fract_48_i[47] Sign_i Rmode_i[0] Rmode_i[1] Output_o[0] Output_o[1] Output_o[2] Output_o[3] Output_o[4] Output_o[5] Output_o[6] Output_o[7] Output_o[8] Output_o[9] Output_o[10] Output_o[11] Output_o[12] Output_o[13] Output_o[14] Output_o[15] Output_o[16] Output_o[17] Output_o[18] Output_o[19] Output_o[20] Output_o[21] Output_o[22] Output_o[23] Output_o[24] Output_o[25] Output_o[26] Output_o[27] Output_o[28] Output_o[29] Output_o[30] Output_o[31] Ine_o
X0 N18480 N18470 N3188 N1137 _NC0 _NC1 MUX21X1
X1 N18460 N1310 N18480 N1131 _NC2 _NC3 MUX21X1
X2 N1844 N1277 N18460 N1127 _NC4 _NC5 MUX21X1
X3 N1842 N18410 N1844 S_shl2[1] _NC6 _NC7 MUX21X1
X4 N18400 N18390 N1842 N1122 _NC8 _NC9 MUX21X1
X5 N2993 N1064 N18400 N11 _NC10 _NC11 MUX21X1
X6 N18380 N18370 N3187 N1137 _NC12 _NC13 MUX21X1
X7 N18360 N1313 N18380 N1132 _NC14 _NC15 MUX21X1
X8 N18340 N1281 N18360 N1129 _NC16 _NC17 MUX21X1
X9 N18320 N18310 N18340 N1125 _NC18 _NC19 MUX21X1
X10 N18300 N1829 N18320 N1122 _NC20 _NC21 MUX21X1
X11 N1064 S_fract_48_i[45] N18300 N11 _NC22 _NC23 MUX21X1
X12 N1828 N1827 N3186 N1137 _NC24 _NC25 MUX21X1
X13 N1826 N1318 N1828 N1132 _NC26 _NC27 MUX21X1
X14 N18240 N1285 N1826 N1130 _NC28 _NC29 MUX21X1
X15 N18220 N18210 N18240 N1125 _NC30 _NC31 MUX21X1
X16 N18390 N18200 N18220 N1122 _NC32 _NC33 MUX21X1
X17 N1062 S_fract_48_i[45] N18390 N40 _NC34 _NC35 MUX21X1
X18 N18190 N18180 N3185 N1137 _NC36 _NC37 MUX21X1
X19 N18170 N1319 N18190 N1132 _NC38 _NC39 MUX21X1
X20 N18150 N1289 N18170 N1130 _NC40 _NC41 MUX21X1
X21 N1813 N1812 N18150 N1125 _NC42 _NC43 MUX21X1
X22 N1829 N1811 N1813 N1122 _NC44 _NC45 MUX21X1
X23 S_fract_48_i[43] N1062 N1829 N40 _NC46 _NC47 MUX21X1
X24 N18090 N18080 N1810 N1137 _NC48 _NC49 MUX21X1
X25 N18070 N18060 N18090 N1132 _NC50 _NC51 MUX21X1
X26 N1253 N18050 N18070 N1130 _NC52 _NC53 MUX21X1
X27 N18410 N18030 N18040 N1125 _NC54 _NC55 MUX21X1
X28 N18200 N18020 N18410 N1122 _NC56 _NC57 MUX21X1
X29 S_fract_48_i[43] N1089 N18200 N11 _NC58 _NC59 MUX21X1
X30 N18000 N17990 N18010 N1137 _NC60 _NC61 MUX21X1
X31 N17980 N1797 N18000 N1132 _NC62 _NC63 MUX21X1
X32 N1257 N1796 N17980 N1130 _NC64 _NC65 MUX21X1
X33 N18310 N1794 N1795 N1125 _NC66 _NC67 MUX21X1
X34 N1811 N17930 N18310 N1122 _NC68 _NC69 MUX21X1
X35 N1091 S_fract_48_i[41] N1811 N11 _NC70 _NC71 MUX21X1
X36 N17910 N18540 N17920 N1137 _NC72 _NC73 MUX21X1
X37 N17900 N1133 N18540 _NC74 _NC75 OR2X1
X38 N17890 N17880 N17910 N1132 _NC76 _NC77 MUX21X1
X39 N1264 N17870 N17890 N1129 _NC78 _NC79 MUX21X1
X40 N18210 N17850 N17860 N1125 _NC80 _NC81 MUX21X1
X41 N18020 N17840 N18210 N1122 _NC82 _NC83 MUX21X1
X42 S_fract_48_i[41] S_fract_48_i[40] N18020 N11 _NC84 _NC85 MUX21X1
X43 N17820 N18530 N17830 N1137 _NC86 _NC87 MUX21X1
X44 N1781 N1133 N18530 _NC88 _NC89 OR2X1
X45 N1780 N1779 N17820 N1132 _NC90 _NC91 MUX21X1
X46 N1271 N1778 N1780 N1129 _NC92 _NC93 MUX21X1
X47 N1812 N17760 N17770 N1125 _NC94 _NC95 MUX21X1
X48 N17930 N17750 N1812 N1122 _NC96 _NC97 MUX21X1
X49 S_fract_48_i[40] S_fract_48_i[39] N17930 N11 _NC98 _NC99 MUX21X1
X50 N17720 N18520 N17730 N1137 _NC100 _NC101 MUX21X1
X51 N17710 N1133 N18520 _NC102 _NC103 OR2X1
X52 N17700 N17690 N17720 N1132 _NC104 _NC105 MUX21X1
X53 N1843 N17680 N17700 N1129 _NC106 _NC107 MUX21X1
X54 N1278 N17670 N1843 N1125 _NC108 _NC109 MUX21X1
X55 N17840 N17660 N18030 N1122 _NC110 _NC111 MUX21X1
X56 S_fract_48_i[39] S_fract_48_i[38] N17840 N11 _NC112 _NC113 MUX21X1
X57 N1764 N18510 N1765 N1137 _NC114 _NC115 MUX21X1
X58 N1763 N1133 N18510 _NC116 _NC117 OR2X1
X59 N1762 N17610 N1764 N1132 _NC118 _NC119 MUX21X1
X60 N18330 N17600 N1762 N1129 _NC120 _NC121 MUX21X1
X61 N1282 N17590 N18330 N1125 _NC122 _NC123 MUX21X1
X62 N17750 N17580 N1794 N1122 _NC124 _NC125 MUX21X1
X63 S_fract_48_i[38] S_fract_48_i[37] N17750 N11 _NC126 _NC127 MUX21X1
X64 N17560 N18500 N17570 N1136 _NC128 _NC129 MUX21X1
X65 N17550 N1133 N18500 _NC130 _NC131 OR2X1
X66 N17540 N17530 N17560 N1132 _NC132 _NC133 MUX21X1
X67 N18230 N17520 N17540 N1129 _NC134 _NC135 MUX21X1
X68 N1286 N17510 N18230 N1125 _NC136 _NC137 MUX21X1
X69 N17660 N17500 N17850 N1122 _NC138 _NC139 MUX21X1
X70 S_fract_48_i[37] S_fract_48_i[36] N17660 N11 _NC140 _NC141 MUX21X1
X71 N1748 N18490 N1749 N1136 _NC142 _NC143 MUX21X1
X72 N1747 N1133 N18490 _NC144 _NC145 OR2X1
X73 N1746 N17450 N1748 N1132 _NC146 _NC147 MUX21X1
X74 N18140 N17440 N1746 N1129 _NC148 _NC149 MUX21X1
X75 N1290 N17430 N18140 N1125 _NC150 _NC151 MUX21X1
X76 N17580 N17420 N17760 N1122 _NC152 _NC153 MUX21X1
X77 S_fract_48_i[36] S_fract_48_i[35] N17580 N1121 _NC154 _NC155 MUX21X1
X78 N17400 N17740 N17410 N1136 _NC156 _NC157 MUX21X1
X79 N17390 N1132 N17740 _NC158 _NC159 OR2X1
X80 N17380 N17370 N17400 N1132 _NC160 _NC161 MUX21X1
X81 N18050 N17360 N17380 N1129 _NC162 _NC163 MUX21X1
X82 N17670 N17350 N18050 N1125 _NC164 _NC165 MUX21X1
X83 N1298 N17340 N17670 N1123 _NC166 _NC167 MUX21X1
X84 S_fract_48_i[35] S_fract_48_i[34] N17500 N1121 _NC168 _NC169 MUX21X1
X85 N1732 N1731 N1733 N1136 _NC170 _NC171 MUX21X1
X86 N1730 N17290 N1732 N1132 _NC172 _NC173 MUX21X1
X87 N1796 N17280 N1730 N1129 _NC174 _NC175 MUX21X1
X88 N17590 N17270 N1796 S_shl2[1] _NC176 _NC177 MUX21X1
X89 N1302 N17260 N17590 N1123 _NC178 _NC179 MUX21X1
X90 S_fract_48_i[34] S_fract_48_i[33] N17420 N1121 _NC180 _NC181 MUX21X1
X91 N17240 N17230 N17250 N1136 _NC182 _NC183 MUX21X1
X92 N17220 N17210 N17240 N1132 _NC184 _NC185 MUX21X1
X93 N17870 N17200 N17220 N1129 _NC186 _NC187 MUX21X1
X94 N17510 N17190 N17870 S_shl2[1] _NC188 _NC189 MUX21X1
X95 N17340 N17180 N17510 N1123 _NC190 _NC191 MUX21X1
X96 N158 N160 N17340 N1121 _NC192 _NC193 MUX21X1
X97 N1716 N1715 N1717 N1136 _NC194 _NC195 MUX21X1
X98 N1714 N1713 N1716 N1132 _NC196 _NC197 MUX21X1
X99 N1778 N17120 N1714 N1129 _NC198 _NC199 MUX21X1
X100 N17430 N17110 N1778 S_shl2[1] _NC200 _NC201 MUX21X1
X101 N17260 N17100 N17430 N1123 _NC202 _NC203 MUX21X1
X102 N160 N162 N17260 N1121 _NC204 _NC205 MUX21X1
X103 N1845 N17080 N17090 N1132 _NC206 _NC207 MUX21X1
X104 N17680 N17070 N1845 N1129 _NC208 _NC209 MUX21X1
X105 N17350 N17060 N17680 S_shl2[1] _NC210 _NC211 MUX21X1
X106 N17180 N17050 N17350 N1123 _NC212 _NC213 MUX21X1
X107 N162 N164 N17180 N1121 _NC214 _NC215 MUX21X1
X108 N18350 N17030 N17040 N1132 _NC216 _NC217 MUX21X1
X109 N17600 N17020 N18350 N1128 _NC218 _NC219 MUX21X1
X110 N17270 N1701 N17600 S_shl2[1] _NC220 _NC221 MUX21X1
X111 N17100 N1700 N17270 N1123 _NC222 _NC223 MUX21X1
X112 N164 N170 N17100 N1121 _NC224 _NC225 MUX21X1
X113 N1699 N1133 N1731 _NC226 _NC227 OR2X1
X114 N18250 N1697 N1698 N1132 _NC228 _NC229 MUX21X1
X115 N17520 N16960 N18250 N1128 _NC230 _NC231 MUX21X1
X116 N17190 N16950 N17520 S_shl2[1] _NC232 _NC233 MUX21X1
X117 N17050 N16940 N17190 N1123 _NC234 _NC235 MUX21X1
X118 N170 N171 N17050 N1121 _NC236 _NC237 MUX21X1
X119 N18160 N16920 N16930 N1132 _NC238 _NC239 MUX21X1
X120 N17440 N1691 N18160 N1128 _NC240 _NC241 MUX21X1
X121 N17110 N16900 N17440 N1126 _NC242 _NC243 MUX21X1
X122 N1700 N16890 N17110 N1123 _NC244 _NC245 MUX21X1
X123 N171 N172 N1700 N1121 _NC246 _NC247 MUX21X1
X124 N18060 N16870 N16880 N1131 _NC248 _NC249 MUX21X1
X125 N17360 N16860 N18060 N1128 _NC250 _NC251 MUX21X1
X126 N17060 N1685 N17360 N1125 _NC252 _NC253 MUX21X1
X127 N16940 N1684 N17060 N1123 _NC254 _NC255 MUX21X1
X128 N172 N173 N16940 N1121 _NC256 _NC257 MUX21X1
X129 N1797 N1682 N1683 N1131 _NC258 _NC259 MUX21X1
X130 N17280 N1681 N1797 N1128 _NC260 _NC261 MUX21X1
X131 N1701 N16800 N17280 N1126 _NC262 _NC263 MUX21X1
X132 N16890 N16790 N1701 N1123 _NC264 _NC265 MUX21X1
X133 N173 N174 N16890 N1121 _NC266 _NC267 MUX21X1
X134 N17880 N17900 N16780 N1131 _NC268 _NC269 MUX21X1
X135 N16770 N1676 N17900 N1128 _NC270 _NC271 MUX21X1
X136 N17200 N16750 N17880 N1128 _NC272 _NC273 MUX21X1
X137 N16950 N16740 N17200 N1125 _NC274 _NC275 MUX21X1
X138 N1684 N16730 N16950 N1123 _NC276 _NC277 MUX21X1
X139 N174 N177 N1684 N1121 _NC278 _NC279 MUX21X1
X140 N1779 N1781 N16720 N1131 _NC280 _NC281 MUX21X1
X141 N1671 N1670 N1781 N1128 _NC282 _NC283 MUX21X1
X142 N17120 N1669 N1779 N1128 _NC284 _NC285 MUX21X1
X143 N16900 N1668 N17120 N1125 _NC286 _NC287 MUX21X1
X144 N16790 N1667 N16900 N1123 _NC288 _NC289 MUX21X1
X145 N177 N182 N16790 N1120 _NC290 _NC291 MUX21X1
X146 N17690 N17710 N16660 N1131 _NC292 _NC293 MUX21X1
X147 N1355 N1130 N17710 _NC294 _NC295 OR2X1
X148 N17070 N16650 N17690 N1128 _NC296 _NC297 MUX21X1
X149 N1685 N16640 N17070 S_shl2[1] _NC298 _NC299 MUX21X1
X150 N16730 N1663 N1685 N1124 _NC300 _NC301 MUX21X1
X151 N182 N189 N16730 N1120 _NC302 _NC303 MUX21X1
X152 N17610 N1763 N1662 N1131 _NC304 _NC305 MUX21X1
X153 N1661 N1130 N1763 _NC306 _NC307 OR2X1
X154 N17020 N1660 N17610 N1128 _NC308 _NC309 MUX21X1
X155 N16800 N1659 N17020 N1126 _NC310 _NC311 MUX21X1
X156 N1667 N1658 N16800 N1124 _NC312 _NC313 MUX21X1
X157 N189 N196 N1667 N1120 _NC314 _NC315 MUX21X1
X158 N17530 N17550 N1657 N1131 _NC316 _NC317 MUX21X1
X159 N1656 N1130 N17550 _NC318 _NC319 OR2X1
X160 N16960 N1655 N17530 N1127 _NC320 _NC321 MUX21X1
X161 N16740 N1654 N16960 N1125 _NC322 _NC323 MUX21X1
X162 N1663 N1653 N16740 N1124 _NC324 _NC325 MUX21X1
X163 N196 N197 N1663 N1120 _NC326 _NC327 MUX21X1
X164 N17450 N1747 N1652 N1131 _NC328 _NC329 MUX21X1
X165 N1651 N1130 N1747 _NC330 _NC331 OR2X1
X166 N1691 N1650 N17450 N1127 _NC332 _NC333 MUX21X1
X167 N1668 N1649 N1691 S_shl2[1] _NC334 _NC335 MUX21X1
X168 N1658 N1648 N1668 N1124 _NC336 _NC337 MUX21X1
X169 N197 N198 N1658 N1120 _NC338 _NC339 MUX21X1
X170 N1647 N1133 N17230 _NC340 _NC341 OR2X1
X171 N17370 N17390 N1646 N1131 _NC342 _NC343 MUX21X1
X172 N1645 N1130 N17390 _NC344 _NC345 OR2X1
X173 N16860 N1349 N17370 N1128 _NC346 _NC347 MUX21X1
X174 N16640 N1644 N16860 S_shl2[1] _NC348 _NC349 MUX21X1
X175 N1653 N1643 N16640 N1124 _NC350 _NC351 MUX21X1
X176 N198 N204 N1653 N1120 _NC352 _NC353 MUX21X1
X177 N17290 N1699 N1642 N1131 _NC354 _NC355 MUX21X1
X178 N1641 N1130 N1699 _NC356 _NC357 OR2X1
X179 N1681 N1640 N17290 N1127 _NC358 _NC359 MUX21X1
X180 N1659 N1639 N1681 S_shl2[1] _NC360 _NC361 MUX21X1
X181 N1648 N1638 N1659 N1124 _NC362 _NC363 MUX21X1
X182 N204 N206 N1648 N1120 _NC364 _NC365 MUX21X1
X183 N17210 N1647 N16370 N1131 _NC366 _NC367 MUX21X1
X184 N1676 N1130 N1647 _NC368 _NC369 OR2X1
X185 N16360 N1126 N1676 _NC370 _NC371 OR2X1
X186 N16750 N16770 N17210 N1127 _NC372 _NC373 MUX21X1
X187 N1353 N1357 N16770 S_shl2[1] _NC374 _NC375 MUX21X1
X188 N1654 N16350 N16750 S_shl2[1] _NC376 _NC377 MUX21X1
X189 N1643 N16340 N1654 N1124 _NC378 _NC379 MUX21X1
X190 N206 N208 N1643 N1120 _NC380 _NC381 MUX21X1
X191 N1713 N16320 N16330 N1131 _NC382 _NC383 MUX21X1
X192 N1669 N1671 N1713 N1127 _NC384 _NC385 MUX21X1
X193 N1631 N1630 N1671 S_shl2[1] _NC386 _NC387 MUX21X1
X194 N1649 N1629 N1669 S_shl2[1] _NC388 _NC389 MUX21X1
X195 N1638 N1628 N1649 N1124 _NC390 _NC391 MUX21X1
X196 N208 N210 N1638 N1120 _NC392 _NC393 MUX21X1
X197 N16650 N1355 N17080 N1127 _NC394 _NC395 MUX21X1
X198 N1626 N1625 N1627 S_shl2[1] _NC396 _NC397 MUX21X1
X199 N1644 N1350 N16650 N1126 _NC398 _NC399 MUX21X1
X200 N16340 N1623 N1644 N1124 _NC400 _NC401 MUX21X1
X201 N210 N212 N16340 N1120 _NC402 _NC403 MUX21X1
X202 N1660 N1661 N17030 N1127 _NC404 _NC405 MUX21X1
X203 N1622 N1621 N1661 N1126 _NC406 _NC407 MUX21X1
X204 N1639 N1620 N1660 S_shl2[1] _NC408 _NC409 MUX21X1
X205 N1628 N1344 N1639 N1124 _NC410 _NC411 MUX21X1
X206 N212 N214 N1628 N1120 _NC412 _NC413 MUX21X1
X207 N1655 N1656 N1697 N1127 _NC414 _NC415 MUX21X1
X208 N1357 N16360 N1656 N1126 _NC416 _NC417 MUX21X1
X209 N1617 N1616 N1618 N1124 _NC418 _NC419 MUX21X1
X210 N16350 N1353 N1655 N1126 _NC420 _NC421 MUX21X1
X211 N1614 N1613 N1615 N1124 _NC422 _NC423 MUX21X1
X212 N1623 N1351 N16350 S_shl2[0] _NC424 _NC425 MUX21X1
X213 N214 N215 N1623 N1120 _NC426 _NC427 MUX21X1
X214 N1650 N1651 N16920 N1127 _NC428 _NC429 MUX21X1
X215 N1630 N1611 N1651 N1126 _NC430 _NC431 MUX21X1
X216 N1358 N1359 N1630 S_shl2[0] _NC432 _NC433 MUX21X1
X217 N1629 N1631 N1650 N1126 _NC434 _NC435 MUX21X1
X218 N1354 N1356 N1631 S_shl2[0] _NC436 _NC437 MUX21X1
X219 N1344 N1352 N1629 S_shl2[0] _NC438 _NC439 MUX21X1
X220 N1071 S_fract_48_i[11] N1610 N1119 _NC440 _NC441 MUX21X1
X221 N16870 N1133 N18080 _NC442 _NC443 OR2X1
X222 N1349 N1645 N16870 N1127 _NC444 _NC445 MUX21X1
X223 N1616 N1619 N1625 S_shl2[0] _NC446 _NC447 MUX21X1
X224 S_fract_48_i[3] N1063 N1616 N1119 _NC448 _NC449 MUX21X1
X225 N1624 N1626 N1609 N1126 _NC450 _NC451 MUX21X1
X226 N1613 N1617 N1626 S_shl2[0] _NC452 _NC453 MUX21X1
X227 N1083 S_fract_48_i[4] N1617 N1119 _NC454 _NC455 MUX21X1
X228 S_fract_48_i[7] N1086 N1613 N1119 _NC456 _NC457 MUX21X1
X229 N1612 N1614 N1624 N1122 _NC458 _NC459 MUX21X1
X230 S_fract_48_i[9] S_fract_48_i[8] N1614 N1119 _NC460 _NC461 MUX21X1
X231 S_fract_48_i[11] S_fract_48_i[10] N1612 N1119 _NC462 _NC463 MUX21X1
X232 N1682 N1133 N17990 _NC464 _NC465 OR2X1
X233 N1640 N1641 N1682 N1127 _NC466 _NC467 MUX21X1
X234 N1621 N1126 N1641 _NC468 _NC469 OR2X1
X235 N1359 N1608 N1621 N1123 _NC470 _NC471 MUX21X1
X236 N1620 N1622 N1640 N1126 _NC472 _NC473 MUX21X1
X237 N1356 N1358 N1622 S_shl2[0] _NC474 _NC475 MUX21X1
X238 S_fract_48_i[4] S_fract_48_i[3] N1606 N1119 _NC476 _NC477 MUX21X1
X239 N1088 N1081 N1605 N1119 _NC478 _NC479 MUX21X1
X240 N1352 N1354 N1620 S_shl2[0] _NC480 _NC481 MUX21X1
X241 S_fract_48_i[8] S_fract_48_i[7] N1604 N1119 _NC482 _NC483 MUX21X1
X242 S_fract_48_i[10] S_fract_48_i[9] N1603 N1119 _NC484 _NC485 MUX21X1
X243 N16320 N1133 N1715 _NC486 _NC487 OR2X1
X244 N1670 N1130 N16320 _NC488 _NC489 OR2X1
X245 N1611 N1126 N1670 _NC490 _NC491 OR2X1
X246 N1608 N1123 N1611 _NC492 _NC493 OR2X1
X247 N1602 N1601 N3102 N1145 _NC494 _NC495 MUX21X1
X248 N1600 N1599 N1602 N1139 _NC496 _NC497 MUX21X1
X249 N1598 N1597 N1600 S_shr2[3] _NC498 _NC499 MUX21X1
X250 N1596 N1595 N3101 N1145 _NC500 _NC501 MUX21X1
X251 N1594 N1593 N1596 N1139 _NC502 _NC503 MUX21X1
X252 N1592 N1591 N1594 S_shr2[3] _NC504 _NC505 MUX21X1
X253 N1590 N1589 N3100 N1145 _NC506 _NC507 MUX21X1
X254 N1588 N1587 N1590 N1139 _NC508 _NC509 MUX21X1
X255 N1586 N1585 N1588 N1093 _NC510 _NC511 MUX21X1
X256 N1584 N1583 N1585 N1096 _NC512 _NC513 MUX21X1
X257 N1582 N1581 N3099 N1145 _NC514 _NC515 MUX21X1
X258 N1580 N1579 N1582 N1139 _NC516 _NC517 MUX21X1
X259 N1578 N1577 N1580 N1093 _NC518 _NC519 MUX21X1
X260 N1576 N1575 N1577 N1096 _NC520 _NC521 MUX21X1
X261 N1574 N1573 N3098 N1145 _NC522 _NC523 MUX21X1
X262 N1572 N1571 N1574 N1139 _NC524 _NC525 MUX21X1
X263 N1570 N1569 N1572 N1093 _NC526 _NC527 MUX21X1
X264 N1568 N1567 N1569 N1096 _NC528 _NC529 MUX21X1
X265 N1566 N1565 N3097 N1145 _NC530 _NC531 MUX21X1
X266 N1564 N1563 N1566 N1139 _NC532 _NC533 MUX21X1
X267 N1562 N1561 N1564 N1093 _NC534 _NC535 MUX21X1
X268 N1560 N1559 N1561 N1096 _NC536 _NC537 MUX21X1
X269 N1550 N1549 N3096 N1145 _NC538 _NC539 MUX21X1
X270 N1548 N1547 N1550 N1139 _NC540 _NC541 MUX21X1
X271 N1546 N1545 N1548 N1093 _NC542 _NC543 MUX21X1
X272 N1544 N1583 N1545 S_shr2[2] _NC544 _NC545 MUX21X1
X273 N1543 N1542 N1583 N1098 _NC546 _NC547 MUX21X1
X274 N1541 N1540 N1544 N1098 _NC548 _NC549 MUX21X1
X275 N1530 N1213 N1531 N1141 _NC550 _NC551 MUX21X1
X276 N1527 N1243 N1528 N1141 _NC552 _NC553 MUX21X1
X277 N1525 N1534 N3095 N1145 _NC554 _NC555 MUX21X1
X278 N1523 N1522 N1525 N43 _NC556 _NC557 MUX21X1
X279 N1521 N1520 N1522 N1093 _NC558 _NC559 MUX21X1
X280 N1519 N1575 N1520 S_shr2[2] _NC560 _NC561 MUX21X1
X281 N1518 N1517 N1575 N1098 _NC562 _NC563 MUX21X1
X282 N1516 N1515 N1519 N1098 _NC564 _NC565 MUX21X1
X283 N1513 N1245 N1514 N43 _NC566 _NC567 MUX21X1
X284 N1510 N1250 N1511 N43 _NC568 _NC569 MUX21X1
X285 N1507 N1254 N1508 N43 _NC570 _NC571 MUX21X1
X286 N1504 N1261 N1505 N43 _NC572 _NC573 MUX21X1
X287 N1552 N1269 N1502 N43 _NC574 _NC575 MUX21X1
X288 N1501 N1500 N1599 S_shr2[3] _NC576 _NC577 MUX21X1
X289 N1499 S_shr2[3] N1552 _NC578 _NC579 OR2X1
X290 N1551 N1275 N1498 N1140 _NC580 _NC581 MUX21X1
X291 N1497 N1496 N1593 S_shr2[3] _NC582 _NC583 MUX21X1
X292 N1539 N1279 N1494 N1140 _NC584 _NC585 MUX21X1
X293 N1493 N1492 N1587 N1093 _NC586 _NC587 MUX21X1
X294 N1491 N1214 N1539 N1093 _NC588 _NC589 MUX21X1
X295 N1538 N1283 N1489 N1140 _NC590 _NC591 MUX21X1
X296 N1488 N1487 N1579 N1093 _NC592 _NC593 MUX21X1
X297 N1486 N1244 N1538 N1093 _NC594 _NC595 MUX21X1
X298 N1537 N1287 N1484 N1140 _NC596 _NC597 MUX21X1
X299 N1483 N1482 N1571 N1093 _NC598 _NC599 MUX21X1
X300 N1481 N1246 N1537 N1093 _NC600 _NC601 MUX21X1
X301 N1536 N1296 N1479 N1140 _NC602 _NC603 MUX21X1
X302 N1478 N1477 N1563 N1093 _NC604 _NC605 MUX21X1
X303 N1476 N1251 N1536 N1093 _NC606 _NC607 MUX21X1
X304 N1474 N1533 N3094 N1145 _NC608 _NC609 MUX21X1
X305 N1472 N1471 N1474 N1140 _NC610 _NC611 MUX21X1
X306 N1598 N1470 N1471 N1093 _NC612 _NC613 MUX21X1
X307 N1469 N1567 N1470 S_shr2[2] _NC614 _NC615 MUX21X1
X308 N1542 N1541 N1567 N1098 _NC616 _NC617 MUX21X1
X309 N1087 N1084 N1541 N1101 _NC618 _NC619 MUX21X1
X310 S_fract_48_i[8] S_fract_48_i[7] N1542 N1101 _NC620 _NC621 MUX21X1
X311 N1540 N1468 N1469 N1098 _NC622 _NC623 MUX21X1
X312 S_fract_48_i[3] S_fract_48_i[4] N1540 S_shr2[0] _NC624 _NC625 MUX21X1
X313 N1467 N1568 N1598 N1096 _NC626 _NC627 MUX21X1
X314 N1466 N1543 N1568 N1098 _NC628 _NC629 MUX21X1
X315 S_fract_48_i[10] S_fract_48_i[9] N1543 N1101 _NC630 _NC631 MUX21X1
X316 N1535 N1300 N1465 N1140 _NC632 _NC633 MUX21X1
X317 N1464 N1463 N1547 N1093 _NC634 _NC635 MUX21X1
X318 N1462 N1255 N1535 N1094 _NC636 _NC637 MUX21X1
X319 N1524 N1304 N1460 N1140 _NC638 _NC639 MUX21X1
X320 N1459 N1458 N1523 N1094 _NC640 _NC641 MUX21X1
X321 N1457 N1262 N1524 N1094 _NC642 _NC643 MUX21X1
X322 N1473 N1307 N1455 N43 _NC644 _NC645 MUX21X1
X323 N1501 N1597 N1472 N1094 _NC646 _NC647 MUX21X1
X324 N1454 N1453 N1597 N1096 _NC648 _NC649 MUX21X1
X325 N1452 N1451 N1501 N1096 _NC650 _NC651 MUX21X1
X326 N1499 N1268 N1473 N1094 _NC652 _NC653 MUX21X1
X327 N1450 N1449 N1500 N1096 _NC654 _NC655 MUX21X1
X328 N1448 N1247 N1499 N1096 _NC656 _NC657 MUX21X1
X329 N1445 N1444 N1446 N43 _NC658 _NC659 MUX21X1
X330 N1443 N1558 N3108 N1144 _NC660 _NC661 MUX21X1
X331 N1491 S_shr2[3] N1530 _NC662 _NC663 OR2X1
X332 N1442 S_shr2[2] N1491 _NC664 _NC665 OR2X1
X333 N1529 N1441 N1443 N1140 _NC666 _NC667 MUX21X1
X334 N1492 N1586 N1441 N1094 _NC668 _NC669 MUX21X1
X335 N1440 N1439 N1586 N1096 _NC670 _NC671 MUX21X1
X336 N1438 N1437 N1492 N1096 _NC672 _NC673 MUX21X1
X337 N1490 N1493 N1529 N1094 _NC674 _NC675 MUX21X1
X338 N1436 N1435 N1493 N1096 _NC676 _NC677 MUX21X1
X339 N1434 N1433 N1490 N1096 _NC678 _NC679 MUX21X1
X340 N1432 N1557 N3107 N1145 _NC680 _NC681 MUX21X1
X341 N1486 S_shr2[3] N1527 _NC682 _NC683 OR2X1
X342 N1431 S_shr2[2] N1486 _NC684 _NC685 OR2X1
X343 N1526 N1430 N1432 N43 _NC686 _NC687 MUX21X1
X344 N1487 N1578 N1430 N1094 _NC688 _NC689 MUX21X1
X345 N1429 N1428 N1578 N1096 _NC690 _NC691 MUX21X1
X346 N1427 N1426 N1487 N1096 _NC692 _NC693 MUX21X1
X347 N1485 N1488 N1526 N1094 _NC694 _NC695 MUX21X1
X348 N1425 N1424 N1488 N1096 _NC696 _NC697 MUX21X1
X349 N1423 N1422 N1485 N1097 _NC698 _NC699 MUX21X1
X350 N1421 N1556 N3106 N1144 _NC700 _NC701 MUX21X1
X351 N1481 S_shr2[3] N1513 _NC702 _NC703 OR2X1
X352 N1448 S_shr2[2] N1481 _NC704 _NC705 OR2X1
X353 N1420 N1215 N1448 N1098 _NC706 _NC707 MUX21X1
X354 N1512 N1418 N1421 N1140 _NC708 _NC709 MUX21X1
X355 N1482 N1570 N1418 N1094 _NC710 _NC711 MUX21X1
X356 N1453 N1467 N1570 N1097 _NC712 _NC713 MUX21X1
X357 N1417 N1416 N1467 N1098 _NC714 _NC715 MUX21X1
X358 N1415 N1414 N1453 N1098 _NC716 _NC717 MUX21X1
X359 N1451 N1454 N1482 N1097 _NC718 _NC719 MUX21X1
X360 N1413 N1412 N1454 N1098 _NC720 _NC721 MUX21X1
X361 N1411 N1410 N1451 N1098 _NC722 _NC723 MUX21X1
X362 N1480 N1483 N1512 N1094 _NC724 _NC725 MUX21X1
X363 N1449 N1452 N1483 N1097 _NC726 _NC727 MUX21X1
X364 N1409 N1408 N1452 N1098 _NC728 _NC729 MUX21X1
X365 N1407 N1406 N1449 N1098 _NC730 _NC731 MUX21X1
X366 N1447 N1450 N1480 N1097 _NC732 _NC733 MUX21X1
X367 N1405 N1404 N1450 N1098 _NC734 _NC735 MUX21X1
X368 N1403 N1402 N1447 N1098 _NC736 _NC737 MUX21X1
X369 N1401 N1555 N3105 N1144 _NC738 _NC739 MUX21X1
X370 N1476 S_shr2[3] N1510 _NC740 _NC741 OR2X1
X371 N1509 N1399 N1401 N43 _NC742 _NC743 MUX21X1
X372 N1477 N1562 N1399 N1094 _NC744 _NC745 MUX21X1
X373 N1398 N1397 N1562 N1097 _NC746 _NC747 MUX21X1
X374 N1396 N1395 N1477 N1097 _NC748 _NC749 MUX21X1
X375 N1475 N1478 N1509 N1094 _NC750 _NC751 MUX21X1
X376 N1394 N1393 N1478 N1097 _NC752 _NC753 MUX21X1
X377 N1392 N1391 N1475 N1097 _NC754 _NC755 MUX21X1
X378 N1390 N1554 N3104 N1144 _NC756 _NC757 MUX21X1
X379 N1462 S_shr2[3] N1507 _NC758 _NC759 OR2X1
X380 N1212 N1442 N1462 S_shr2[2] _NC760 _NC761 MUX21X1
X381 N1420 S_shr2[1] N1442 _NC762 _NC763 OR2X1
X382 N1419 N1403 N1434 N1099 _NC764 _NC765 MUX21X1
X383 N1062 S_fract_48_i[43] N1403 N1101 _NC766 _NC767 MUX21X1
X384 N1064 S_fract_48_i[45] N1419 N1101 _NC768 _NC769 MUX21X1
X385 N1506 N1389 N1390 N43 _NC770 _NC771 MUX21X1
X386 N1463 N1546 N1389 N1094 _NC772 _NC773 MUX21X1
X387 N1584 N1439 N1546 S_shr2[2] _NC774 _NC775 MUX21X1
X388 N1414 N1417 N1439 N1099 _NC776 _NC777 MUX21X1
X389 S_fract_48_i[16] S_fract_48_i[15] N1417 N1101 _NC778 _NC779 MUX21X1
X390 N1074 S_fract_48_i[17] N1414 N1101 _NC780 _NC781 MUX21X1
X391 N1416 N1466 N1584 N1099 _NC782 _NC783 MUX21X1
X392 N1072 S_fract_48_i[11] N1466 N1101 _NC784 _NC785 MUX21X1
X393 S_fract_48_i[14] S_fract_48_i[13] N1416 N1101 _NC786 _NC787 MUX21X1
X394 N1440 N1437 N1463 S_shr2[2] _NC788 _NC789 MUX21X1
X395 N1410 N1413 N1437 N1099 _NC790 _NC791 MUX21X1
X396 N1146 S_fract_48_i[23] N1413 N1101 _NC792 _NC793 MUX21X1
X397 S_fract_48_i[26] S_fract_48_i[25] N1410 N1101 _NC794 _NC795 MUX21X1
X398 N1412 N1415 N1440 N1099 _NC796 _NC797 MUX21X1
X399 S_fract_48_i[20] S_fract_48_i[19] N1415 N1101 _NC798 _NC799 MUX21X1
X400 S_fract_48_i[22] S_fract_48_i[21] N1412 N1101 _NC800 _NC801 MUX21X1
X401 N1461 N1464 N1506 N1094 _NC802 _NC803 MUX21X1
X402 N1438 N1435 N1464 S_shr2[2] _NC804 _NC805 MUX21X1
X403 N1406 N1409 N1435 N1099 _NC806 _NC807 MUX21X1
X404 S_fract_48_i[32] S_fract_48_i[31] N1409 N1101 _NC808 _NC809 MUX21X1
X405 S_fract_48_i[34] S_fract_48_i[33] N1406 N1101 _NC810 _NC811 MUX21X1
X406 N1408 N1411 N1438 N1099 _NC812 _NC813 MUX21X1
X407 S_fract_48_i[28] S_fract_48_i[27] N1411 N1102 _NC814 _NC815 MUX21X1
X408 N1077 S_fract_48_i[29] N1408 N1102 _NC816 _NC817 MUX21X1
X409 N1436 N1433 N1461 S_shr2[2] _NC818 _NC819 MUX21X1
X410 N1402 N1405 N1433 N1099 _NC820 _NC821 MUX21X1
X411 S_fract_48_i[40] S_fract_48_i[39] N1405 N1102 _NC822 _NC823 MUX21X1
X412 N1091 S_fract_48_i[41] N1402 N1102 _NC824 _NC825 MUX21X1
X413 N1404 N1407 N1436 N1099 _NC826 _NC827 MUX21X1
X414 S_fract_48_i[36] S_fract_48_i[35] N1407 N1102 _NC828 _NC829 MUX21X1
X415 S_fract_48_i[38] S_fract_48_i[37] N1404 N1102 _NC830 _NC831 MUX21X1
X416 N1388 N1553 N3103 N1145 _NC832 _NC833 MUX21X1
X417 N1457 S_shr2[3] N1504 _NC834 _NC835 OR2X1
X418 N1242 N1431 N1457 S_shr2[2] _NC836 _NC837 MUX21X1
X419 N1386 N1385 N1423 N1099 _NC838 _NC839 MUX21X1
X420 N1503 N1384 N1388 N43 _NC840 _NC841 MUX21X1
X421 N1458 N1521 N1384 N1094 _NC842 _NC843 MUX21X1
X422 N1576 N1428 N1521 S_shr2[2] _NC844 _NC845 MUX21X1
X423 N1383 N1382 N1428 N1099 _NC846 _NC847 MUX21X1
X424 N1381 N1380 N1576 N1099 _NC848 _NC849 MUX21X1
X425 N1429 N1426 N1458 S_shr2[2] _NC850 _NC851 MUX21X1
X426 N1379 N1378 N1426 N1099 _NC852 _NC853 MUX21X1
X427 N1377 N1376 N1429 N1099 _NC854 _NC855 MUX21X1
X428 N1456 N1459 N1503 N1094 _NC856 _NC857 MUX21X1
X429 N1427 N1424 N1459 S_shr2[2] _NC858 _NC859 MUX21X1
X430 N1375 N1374 N1424 N1099 _NC860 _NC861 MUX21X1
X431 N1373 N1372 N1427 N1099 _NC862 _NC863 MUX21X1
X432 N1425 N1422 N1456 S_shr2[2] _NC864 _NC865 MUX21X1
X433 N1371 N1370 N1422 N1099 _NC866 _NC867 MUX21X1
X434 N1369 N1368 N1425 N1099 _NC868 _NC869 MUX21X1
X435 N1367 N1195 N3093 N1144 _NC870 _NC871 MUX21X1
X436 N1495 N1496 N1445 N1094 _NC872 _NC873 MUX21X1
X437 N1391 N1394 N1496 N1097 _NC874 _NC875 MUX21X1
X438 N1368 N1375 N1394 N1100 _NC876 _NC877 MUX21X1
X439 S_fract_48_i[33] S_fract_48_i[32] N1375 N1102 _NC878 _NC879 MUX21X1
X440 S_fract_48_i[35] S_fract_48_i[34] N1368 N1102 _NC880 _NC881 MUX21X1
X441 N1370 N1369 N1391 N1100 _NC882 _NC883 MUX21X1
X442 S_fract_48_i[37] S_fract_48_i[36] N1369 N1102 _NC884 _NC885 MUX21X1
X443 S_fract_48_i[39] S_fract_48_i[38] N1370 N1102 _NC886 _NC887 MUX21X1
X444 N1400 N1392 N1495 N1097 _NC888 _NC889 MUX21X1
X445 N1385 N1371 N1392 N1100 _NC890 _NC891 MUX21X1
X446 S_fract_48_i[41] S_fract_48_i[40] N1371 N1102 _NC892 _NC893 MUX21X1
X447 S_fract_48_i[43] N1092 N1385 N1102 _NC894 _NC895 MUX21X1
X448 N1387 N1386 N1400 N1100 _NC896 _NC897 MUX21X1
X449 S_fract_48_i[45] N1062 N1386 N1102 _NC898 _NC899 MUX21X1
X450 N2993 N1064 N1387 N1102 _NC900 _NC901 MUX21X1
X451 N1444 N1366 N1367 N1140 _NC902 _NC903 MUX21X1
X452 N1592 N1365 N1366 N1095 _NC904 _NC905 MUX21X1
X453 N1364 N1559 N1365 S_shr2[2] _NC906 _NC907 MUX21X1
X454 N1517 N1516 N1559 N1100 _NC908 _NC909 MUX21X1
X455 N1082 S_fract_48_i[4] N1516 N1102 _NC910 _NC911 MUX21X1
X456 S_fract_48_i[7] N1088 N1517 N1102 _NC912 _NC913 MUX21X1
X457 N1515 N1363 N1364 N1100 _NC914 _NC915 MUX21X1
X458 N1063 S_fract_48_i[3] N1515 S_shr2[0] _NC916 _NC917 MUX21X1
X459 N1397 N1560 N1592 N1097 _NC918 _NC919 MUX21X1
X460 N1380 N1518 N1560 N1100 _NC920 _NC921 MUX21X1
X461 S_fract_48_i[9] S_fract_48_i[8] N1518 N1102 _NC922 _NC923 MUX21X1
X462 S_fract_48_i[11] S_fract_48_i[10] N1380 N1103 _NC924 _NC925 MUX21X1
X463 N1382 N1381 N1397 N1100 _NC926 _NC927 MUX21X1
X464 S_fract_48_i[13] N1071 N1381 N1103 _NC928 _NC929 MUX21X1
X465 S_fract_48_i[15] S_fract_48_i[14] N1382 N1103 _NC930 _NC931 MUX21X1
X466 N1497 N1591 N1444 N1095 _NC932 _NC933 MUX21X1
X467 N1395 N1398 N1591 N1097 _NC934 _NC935 MUX21X1
X468 N1376 N1383 N1398 N1100 _NC936 _NC937 MUX21X1
X469 S_fract_48_i[17] S_fract_48_i[16] N1383 N1103 _NC938 _NC939 MUX21X1
X470 S_fract_48_i[19] N1075 N1376 N1103 _NC940 _NC941 MUX21X1
X471 N1378 N1377 N1395 N1100 _NC942 _NC943 MUX21X1
X472 S_fract_48_i[21] S_fract_48_i[20] N1377 N1103 _NC944 _NC945 MUX21X1
X473 S_fract_48_i[23] S_fract_48_i[22] N1378 N1103 _NC946 _NC947 MUX21X1
X474 N1393 N1396 N1497 N1097 _NC948 _NC949 MUX21X1
X475 N1372 N1379 N1396 N1100 _NC950 _NC951 MUX21X1
X476 S_fract_48_i[25] N1146 N1379 N1103 _NC952 _NC953 MUX21X1
X477 S_fract_48_i[27] S_fract_48_i[26] N1372 N1103 _NC954 _NC955 MUX21X1
X478 N1374 N1373 N1393 N1100 _NC956 _NC957 MUX21X1
X479 S_fract_48_i[29] S_fract_48_i[28] N1373 N1103 _NC958 _NC959 MUX21X1
X480 S_fract_48_i[31] N1078 N1374 N1103 _NC960 _NC961 MUX21X1
X481 N360 N130 N366 _NC962 _NC963 AND2X1
X482 N1163 N1162 N1161 N1160 N3244 _NC964 _NC965 AO22X1
X483 N3242 N42 N1162 N1160 _NC966 _NC967 OA21X1
X484 N1159 N1158 N1157 N1161 _NC968 _NC969 OA21X1
X485 N3239 N39 N1156 N3238 N1158 N1157 _NC970 _NC971 AO221X1
X486 S_r_zeros[0] N1155 N1156 _NC972 _NC973 NOR2X0
X487 N3239 N39 N1155 _NC974 _NC975 NOR2X0
X488 N3241 N35 N1154 N3240 N1158 _NC976 _NC977 AO22X1
X489 S_r_zeros[2] N1153 N1154 _NC978 _NC979 NOR2X0
X490 N1164 S_r_zeros[2] N1153 N1159 _NC980 _NC981 AOI21X1
X491 N35 N3241 N1153 _NC982 _NC983 NOR2X0
X492 N10 N3243 N1162 _NC984 _NC985 OR2X1
X493 N3243 N10 N3242 N42 N1163 _NC986 _NC987 AO22X1
X494 Sub_192_aco_carry[7] _NC988 _NC989 S_expo2b[8] INVX0
X495 N2348 _NC990 _NC991 N2358 INVX0
X496 N2332 _NC992 _NC993 N2342 INVX0
X497 N2316 _NC994 _NC995 N2326 INVX0
X498 N2300 _NC996 _NC997 N2310 INVX0
X499 N2284 _NC998 _NC999 N2294 INVX0
X500 N2268 _NC1000 _NC1001 N2278 INVX0
X501 N2252 _NC1002 _NC1003 N2262 INVX0
X502 N2236 _NC1004 _NC1005 N2246 INVX0
X503 N2220 _NC1006 _NC1007 N2230 INVX0
X504 N2204 _NC1008 _NC1009 N2214 INVX0
X505 Add_105_I38_L07002_C136_carry[3] N572 N2203 _NC1010 _NC1011 XOR2X1
X506 N2188 _NC1012 _NC1013 N2198 INVX0
X507 Add_105_I37_L07002_C136_carry[3] N2177 N2187 _NC1014 _NC1015 XOR2X1
X508 N2172 _NC1016 _NC1017 N2182 INVX0
X509 Add_105_I36_L07002_C136_carry[3] N2161 N2171 _NC1018 _NC1019 XOR2X1
X510 N2156 _NC1020 _NC1021 N2166 INVX0
X511 N2140 _NC1022 _NC1023 N2150 INVX0
X512 N2124 _NC1024 _NC1025 N2134 INVX0
X513 Add_105_I33_L07002_C136_carry[3] N2113 N2123 _NC1026 _NC1027 XOR2X1
X514 N2108 _NC1028 _NC1029 N2118 INVX0
X515 N2092 _NC1030 _NC1031 N2102 INVX0
X516 N2076 _NC1032 _NC1033 N2086 INVX0
X517 Add_105_I30_L07002_C136_carry[3] N2065 N2075 _NC1034 _NC1035 XOR2X1
X518 N2060 _NC1036 _NC1037 N2070 INVX0
X519 N2044 _NC1038 _NC1039 N2054 INVX0
X520 Add_105_I28_L07002_C136_carry[3] N2033 N2043 _NC1040 _NC1041 XOR2X1
X521 N2028 _NC1042 _NC1043 N2038 INVX0
X522 Add_105_I27_L07002_C136_carry[3] N2017 N2027 _NC1044 _NC1045 XOR2X1
X523 N2012 _NC1046 _NC1047 N2022 INVX0
X524 Add_105_I26_L07002_C136_carry[3] N2001 N2011 _NC1048 _NC1049 XOR2X1
X525 N1996 _NC1050 _NC1051 N2006 INVX0
X526 Add_105_I25_L07002_C136_carry[3] N1985 N1995 _NC1052 _NC1053 XOR2X1
X527 N1980 _NC1054 _NC1055 N1990 INVX0
X528 N1948 _NC1056 _NC1057 N1958 INVX0
X529 N1932 _NC1058 _NC1059 N1942 INVX0
X530 Add_105_I21_L07002_C136_carry[3] N1921 N1931 _NC1060 _NC1061 XOR2X1
X531 N1916 _NC1062 _NC1063 N1926 INVX0
X532 N1900 _NC1064 _NC1065 N1910 INVX0
X533 N1884 _NC1066 _NC1067 N1894 INVX0
X534 N1868 _NC1068 _NC1069 N1878 INVX0
X535 N1852 _NC1070 _NC1071 N1862 INVX0
X536 Add_105_I16_L07002_C136_carry[3] N1841 N1851 _NC1072 _NC1073 XOR2X1
X537 N1836 _NC1074 _NC1075 N1846 INVX0
X538 Add_105_I15_L07002_C136_carry[3] N1825 N1835 _NC1076 _NC1077 XOR2X1
X539 N1820 _NC1078 _NC1079 N1830 INVX0
X540 Add_105_I14_L07002_C136_carry[3] N1809 N1819 _NC1080 _NC1081 XOR2X1
X541 N1804 _NC1082 _NC1083 N1814 INVX0
X542 Add_105_I13_L07002_C136_carry[3] N1793 N1803 _NC1084 _NC1085 XOR2X1
X543 N1788 _NC1086 _NC1087 N1798 INVX0
X544 Add_105_I12_L07002_C136_carry[3] N1777 N1787 _NC1088 _NC1089 XOR2X1
X545 N1772 _NC1090 _NC1091 N1782 INVX0
X546 Add_105_I11_L07002_C136_carry[3] N1761 N1771 _NC1092 _NC1093 XOR2X1
X547 N1756 _NC1094 _NC1095 N1766 INVX0
X548 Add_105_I10_L07002_C136_carry[3] N1745 N1755 _NC1096 _NC1097 XOR2X1
X549 N1740 _NC1098 _NC1099 N1750 INVX0
X550 N1724 _NC1100 _NC1101 N1734 INVX0
X551 N1708 _NC1102 _NC1103 N1718 INVX0
X552 N1692 _NC1104 _NC1105 N1702 INVX0
X553 N1677 _NC1106 _NC1107 N1686 INVX0
X554 N1664 _NC1108 _NC1109 N1672 INVX0
X555 N1025 _NC1110 _NC1111 N1036 INVX0
X556 Add_90_I45_L07002_C132_carry[3] N1013 N1024 _NC1112 _NC1113 XOR2X1
X557 N1008 _NC1114 _NC1115 N1019 INVX0
X558 Add_90_I44_L07002_C132_carry[3] N996 N1007 _NC1116 _NC1117 XOR2X1
X559 N991 _NC1118 _NC1119 N1002 INVX0
X560 Add_90_I43_L07002_C132_carry[3] N979 N990 _NC1120 _NC1121 XOR2X1
X561 N974 _NC1122 _NC1123 N985 INVX0
X562 N957 _NC1124 _NC1125 N968 INVX0
X563 N940 _NC1126 _NC1127 N951 INVX0
X564 N923 _NC1128 _NC1129 N934 INVX0
X565 N889 _NC1130 _NC1131 N900 INVX0
X566 N872 _NC1132 _NC1133 N883 INVX0
X567 N855 _NC1134 _NC1135 N866 INVX0
X568 N838 _NC1136 _NC1137 N849 INVX0
X569 N821 _NC1138 _NC1139 N832 INVX0
X570 N804 _NC1140 _NC1141 N815 INVX0
X571 N787 _NC1142 _NC1143 N798 INVX0
X572 N770 _NC1144 _NC1145 N781 INVX0
X573 N753 _NC1146 _NC1147 N764 INVX0
X574 Add_90_I29_L07002_C132_carry[3] N741 N752 _NC1148 _NC1149 XOR2X1
X575 N736 _NC1150 _NC1151 N747 INVX0
X576 Add_90_I28_L07002_C132_carry[3] N724 N735 _NC1152 _NC1153 XOR2X1
X577 N719 _NC1154 _NC1155 N730 INVX0
X578 Add_90_I27_L07002_C132_carry[3] N707 N718 _NC1156 _NC1157 XOR2X1
X579 N702 _NC1158 _NC1159 N713 INVX0
X580 Add_90_I26_L07002_C132_carry[3] N690 N701 _NC1160 _NC1161 XOR2X1
X581 N685 _NC1162 _NC1163 N696 INVX0
X582 N668 _NC1164 _NC1165 N679 INVX0
X583 N651 _NC1166 _NC1167 N662 INVX0
X584 Add_90_I23_L07002_C132_carry[3] N639 N650 _NC1168 _NC1169 XOR2X1
X585 N634 _NC1170 _NC1171 N645 INVX0
X586 Add_90_I22_L07002_C132_carry[3] N622 N633 _NC1172 _NC1173 XOR2X1
X587 Add_90_I21_L07002_C132_carry[3] N605 N616 _NC1174 _NC1175 XOR2X1
X588 N600 _NC1176 _NC1177 N611 INVX0
X589 Add_90_I20_L07002_C132_carry[3] N588 N599 _NC1178 _NC1179 XOR2X1
X590 N583 _NC1180 _NC1181 N594 INVX0
X591 Add_90_I19_L07002_C132_carry[3] N571 N582 _NC1182 _NC1183 XOR2X1
X592 N566 _NC1184 _NC1185 N577 INVX0
X593 Add_90_I18_L07002_C132_carry[3] N554 N565 _NC1186 _NC1187 XOR2X1
X594 N549 _NC1188 _NC1189 N560 INVX0
X595 Add_90_I17_L07002_C132_carry[3] N537 N548 _NC1190 _NC1191 XOR2X1
X596 N532 _NC1192 _NC1193 N543 INVX0
X597 Add_90_I16_L07002_C132_carry[3] N520 N531 _NC1194 _NC1195 XOR2X1
X598 N515 _NC1196 _NC1197 N526 INVX0
X599 Add_90_I15_L07002_C132_carry[3] N503 N514 _NC1198 _NC1199 XOR2X1
X600 N498 _NC1200 _NC1201 N509 INVX0
X601 Add_90_I14_L07002_C132_carry[3] N486 N497 _NC1202 _NC1203 XOR2X1
X602 N481 _NC1204 _NC1205 N492 INVX0
X603 Add_90_I13_L07002_C132_carry[3] N469 N480 _NC1206 _NC1207 XOR2X1
X604 N464 _NC1208 _NC1209 N475 INVX0
X605 Add_90_I12_L07002_C132_carry[3] N452 N463 _NC1210 _NC1211 XOR2X1
X606 N447 _NC1212 _NC1213 N458 INVX0
X607 Add_90_I11_L07002_C132_carry[3] N435 N446 _NC1214 _NC1215 XOR2X1
X608 N430 _NC1216 _NC1217 N441 INVX0
X609 Add_90_I10_L07002_C132_carry[3] N418 N429 _NC1218 _NC1219 XOR2X1
X610 N413 _NC1220 _NC1221 N424 INVX0
X611 N396 _NC1222 _NC1223 N407 INVX0
X612 N379 _NC1224 _NC1225 N390 INVX0
X613 N362 _NC1226 _NC1227 N373 INVX0
X614 N346 _NC1228 _NC1229 N356 INVX0
X615 N332 _NC1230 _NC1231 N341 INVX0
X616 S_exp_10_i[0] N2993 S_exp_10a[0] _NC1232 _NC1233 XOR2X1
X617 S_exp_10_i[0] N2993 Add_140_carry[0] _NC1234 _NC1235 AND2X1
X618 S_exp_10_i[1] Add_140_carry[0] S_exp_10a[1] _NC1236 _NC1237 XOR2X1
X619 S_exp_10_i[1] Add_140_carry[0] Add_140_carry[1] _NC1238 _NC1239 AND2X1
X620 S_exp_10_i[2] Add_140_carry[1] S_exp_10a[2] _NC1240 _NC1241 XOR2X1
X621 S_exp_10_i[2] Add_140_carry[1] Add_140_carry[2] _NC1242 _NC1243 AND2X1
X622 S_exp_10_i[3] Add_140_carry[2] S_exp_10a[3] _NC1244 _NC1245 XOR2X1
X623 S_exp_10_i[3] Add_140_carry[2] Add_140_carry[3] _NC1246 _NC1247 AND2X1
X624 S_exp_10_i[4] Add_140_carry[3] S_exp_10a[4] _NC1248 _NC1249 XOR2X1
X625 S_exp_10_i[4] Add_140_carry[3] Add_140_carry[4] _NC1250 _NC1251 AND2X1
X626 S_exp_10_i[5] Add_140_carry[4] S_exp_10a[5] _NC1252 _NC1253 XOR2X1
X627 S_exp_10_i[5] Add_140_carry[4] Add_140_carry[5] _NC1254 _NC1255 AND2X1
X628 S_exp_10_i[6] Add_140_carry[5] S_exp_10a[6] _NC1256 _NC1257 XOR2X1
X629 S_exp_10_i[6] Add_140_carry[5] Add_140_carry[6] _NC1258 _NC1259 AND2X1
X630 S_exp_10_i[7] Add_140_carry[6] S_exp_10a[7] _NC1260 _NC1261 XOR2X1
X631 S_exp_10_i[7] Add_140_carry[6] Add_140_carry[7] _NC1262 _NC1263 AND2X1
X632 S_exp_10_i[8] Add_140_carry[7] S_exp_10a[8] _NC1264 _NC1265 XOR2X1
X633 S_exp_10_i[8] Add_140_carry[7] Add_140_carry[8] _NC1266 _NC1267 AND2X1
X634 S_exp_10_i[9] Add_140_carry[8] S_exp_10a[9] _NC1268 _NC1269 XOR2X1
X635 N1147 N68 N2999 _NC1270 _NC1271 XNOR2X1
X636 N68 N1147 Sub_0_root_add_0_root_add_148_carry[0] _NC1272 _NC1273 OR2X1
X637 N1149 Sub_0_root_add_0_root_add_148_carry[1] N3001 _NC1274 _NC1275 XOR2X1
X638 Sub_0_root_add_0_root_add_148_carry[1] N1149 Sub_0_root_add_0_root_add_148_carry[2] _NC1276 _NC1277 AND2X1
X639 N1150 Sub_0_root_add_0_root_add_148_carry[2] N3002 _NC1278 _NC1279 XOR2X1
X640 Sub_0_root_add_0_root_add_148_carry[2] N1150 Sub_0_root_add_0_root_add_148_carry[3] _NC1280 _NC1281 AND2X1
X641 N1151 Sub_0_root_add_0_root_add_148_carry[3] N3003 _NC1282 _NC1283 XOR2X1
X642 Sub_0_root_add_0_root_add_148_carry[3] N1151 Sub_0_root_add_0_root_add_148_carry[4] _NC1284 _NC1285 AND2X1
X643 N1152 Sub_0_root_add_0_root_add_148_carry[4] N3004 _NC1286 _NC1287 XOR2X1
X644 S_shr2[0] S_frac_rnd[24] N3238 _NC1288 _NC1289 XOR2X1
X645 S_frac_rnd[24] S_shr2[0] Add_197_carry[0] _NC1290 _NC1291 AND2X1
X646 S_shr2[1] Add_197_carry[0] N3239 _NC1292 _NC1293 XOR2X1
X647 Add_197_carry[0] S_shr2[1] Add_197_carry[1] _NC1294 _NC1295 AND2X1
X648 S_shr2[2] Add_197_carry[1] N3240 _NC1296 _NC1297 XOR2X1
X649 Add_197_carry[1] S_shr2[2] Add_197_carry[2] _NC1298 _NC1299 AND2X1
X650 S_shr2[3] Add_197_carry[2] N3241 _NC1300 _NC1301 XOR2X1
X651 Add_197_carry[2] S_shr2[3] Add_197_carry[3] _NC1302 _NC1303 AND2X1
X652 N1139 Add_197_carry[3] N3242 _NC1304 _NC1305 XOR2X1
X653 Add_197_carry[3] N1139 Add_197_carry[4] _NC1306 _NC1307 AND2X1
X654 N1144 Add_197_carry[4] N3243 _NC1308 _NC1309 XOR2X1
X655 S_frac2a[46] S_expo1[0] S_expo2b[0] _NC1310 _NC1311 XNOR2X1
X656 S_expo1[0] S_frac2a[46] Sub_192_aco_carry[0] _NC1312 _NC1313 OR2X1
X657 Sub_192_aco_carry[0] S_expo1[1] S_expo2b[1] _NC1314 _NC1315 XNOR2X1
X658 S_expo1[1] Sub_192_aco_carry[0] Sub_192_aco_carry[1] _NC1316 _NC1317 OR2X1
X659 Sub_192_aco_carry[1] S_expo1[2] S_expo2b[2] _NC1318 _NC1319 XNOR2X1
X660 S_expo1[2] Sub_192_aco_carry[1] Sub_192_aco_carry[2] _NC1320 _NC1321 OR2X1
X661 Sub_192_aco_carry[2] S_expo1[3] S_expo2b[3] _NC1322 _NC1323 XNOR2X1
X662 S_expo1[3] Sub_192_aco_carry[2] Sub_192_aco_carry[3] _NC1324 _NC1325 OR2X1
X663 Sub_192_aco_carry[3] S_expo1[4] S_expo2b[4] _NC1326 _NC1327 XNOR2X1
X664 S_expo1[4] Sub_192_aco_carry[3] Sub_192_aco_carry[4] _NC1328 _NC1329 OR2X1
X665 Sub_192_aco_carry[4] S_expo1[5] S_expo2b[5] _NC1330 _NC1331 XNOR2X1
X666 S_expo1[5] Sub_192_aco_carry[4] Sub_192_aco_carry[5] _NC1332 _NC1333 OR2X1
X667 Sub_192_aco_carry[5] S_expo1[6] S_expo2b[6] _NC1334 _NC1335 XNOR2X1
X668 S_expo1[6] Sub_192_aco_carry[5] Sub_192_aco_carry[6] _NC1336 _NC1337 OR2X1
X669 Sub_192_aco_carry[6] S_expo1[7] S_expo2b[7] _NC1338 _NC1339 XNOR2X1
X670 S_expo1[7] Sub_192_aco_carry[6] Sub_192_aco_carry[7] _NC1340 _NC1341 OR2X1
X671 N177 _NC1342 _NC1343 N1146 INVX0
X672 N1141 _NC1344 _NC1345 N1139 INVX0
X673 N1141 _NC1346 _NC1347 N1138 INVX0
X674 N12 _NC1348 _NC1349 N1126 INVX0
X675 N12 _NC1350 _NC1351 N1125 INVX0
X676 N9 _NC1352 _NC1353 N1124 INVX0
X677 N9 _NC1354 _NC1355 N1123 INVX0
X678 N9 _NC1356 _NC1357 N1122 INVX0
X679 N40 _NC1358 _NC1359 N1121 INVX0
X680 N40 _NC1360 _NC1361 N1120 INVX0
X681 N40 _NC1362 _NC1363 N1119 INVX0
X682 N1118 _NC1364 _NC1365 N1116 INVX0
X683 N1108 _NC1366 _NC1367 N1107 INVX0
X684 N1108 _NC1368 _NC1369 N1106 INVX0
X685 N1108 _NC1370 _NC1371 N1105 INVX0
X686 N1108 _NC1372 _NC1373 N1104 INVX0
X687 S_fract_48_i[42] _NC1374 _NC1375 N1092 NBUFFX2
X688 S_fract_48_i[42] _NC1376 _NC1377 N1091 NBUFFX2
X689 S_fract_48_i[42] _NC1378 _NC1379 N1090 NBUFFX2
X690 S_fract_48_i[42] _NC1380 _NC1381 N1089 NBUFFX2
X691 S_fract_48_i[6] _NC1382 _NC1383 N1088 NBUFFX2
X692 S_fract_48_i[6] _NC1384 _NC1385 N1087 NBUFFX2
X693 S_fract_48_i[6] _NC1386 _NC1387 N1086 NBUFFX2
X694 S_fract_48_i[6] _NC1388 _NC1389 N1085 NBUFFX2
X695 S_fract_48_i[5] _NC1390 _NC1391 N1084 NBUFFX2
X696 S_fract_48_i[5] _NC1392 _NC1393 N1083 NBUFFX2
X697 S_fract_48_i[5] _NC1394 _NC1395 N1082 NBUFFX2
X698 S_fract_48_i[5] _NC1396 _NC1397 N1081 NBUFFX2
X699 S_fract_48_i[0] S_fract_48_i[1] N4810 _NC1398 _NC1399 NOR2X0
X700 N5710 S_fract_48_i[3] N5690 _NC1400 _NC1401 NOR2X0
X701 N372 N8880 N4090 _NC1402 _NC1403 NAND2X0
X702 N1044 N9680 N4920 _NC1404 _NC1405 NAND2X0
X703 N442 N152 S_fract_48_i[36] N8840 N448 _NC1406 _NC1407 AO22X2
X704 N127 S_fract_48_i[43] N8010 _NC1408 _NC1409 NOR2X0
X705 S_fract_48_i[45] S_fract_48_i[46] N8000 _NC1410 _NC1411 NOR2X0
X706 N4780 N4790 N4770 _NC1412 _NC1413 NOR2X0
X707 N402 N351 N1185 N352 N403 N1069 _NC1414 _NC1415 OAI221X1
X708 N9760 N389 N831 N1075 N981 N3900 N1068 _NC1416 _NC1417 AO222X1
X709 N1068 N1069 N4290 N3960 _NC1418 _NC1419 OAI21X1
X710 N3910 N3920 N331 N2978 _NC1420 _NC1421 OA21X1
X711 N1055 S_fract_48_i[3] N1067 _NC1422 _NC1423 NOR2X0
X712 N10370 _NC1424 _NC1425 N1066 INVX0
X713 N69 _NC1426 _NC1427 N1064 INVX0
X714 N232 _NC1428 _NC1429 N1063 INVX0
X715 N4160 N4170 N4140 _NC1430 _NC1431 NOR2X0
X716 N507 N508 N506 _NC1432 _NC1433 NOR2X0
X717 N1044 N184 N4630 _NC1434 _NC1435 NAND2X0
X718 N4580 N4590 N457 _NC1436 _NC1437 NOR2X0
X719 N1061 _NC1438 _NC1439 N1062 INVX0
X720 S_fract_48_i[44] _NC1440 _NC1441 N1061 INVX0
X721 N372 N104 N437 _NC1442 _NC1443 NAND2X0
X722 N3470 N8200 N4240 _NC1444 _NC1445 NAND2X0
X723 N4450 N4460 N4430 _NC1446 _NC1447 NOR2X0
X724 S_shl2[4] _NC1448 _NC1449 N1137 NBUFFX2
X725 S_shr2[4] _NC1450 _NC1451 N1140 INVX0
X726 N244 N1360 N249 _NC1452 _NC1453 NOR2X0
X727 N1360 S_frac_rnd[24] N248 _NC1454 _NC1455 NOR2X0
X728 S_shl2[3] _NC1456 _NC1457 N1133 NBUFFX2
X729 S_shl2[2] _NC1458 _NC1459 N1130 NBUFFX2
X730 S_rmode_i[1] N236 N304 _NC1460 _NC1461 NAND2X1
X731 N573 N122 N7180 _NC1462 _NC1463 NOR2X0
X732 N5670 N231 N4520 _NC1464 _NC1465 NAND2X0
X733 N573 S_fract_48_i[43] N661 _NC1466 _NC1467 NOR2X0
X734 N7160 N119 N573 _NC1468 _NC1469 NAND2X0
X735 N4520 S_fract_48_i[4] N331 _NC1470 _NC1471 NOR2X0
X736 S_shl2[2] _NC1472 _NC1473 N1129 NBUFFX2
X737 S_shl2[2] _NC1474 _NC1475 N1128 NBUFFX2
X738 S_shl2[3] _NC1476 _NC1477 N1132 NBUFFX4
X739 S_shr2[5] _NC1478 _NC1479 N1145 NBUFFX2
X740 S_shl2[2] _NC1480 _NC1481 N1127 NBUFFX2
X741 S_shl2[3] _NC1482 _NC1483 N1131 NBUFFX4
X742 S_exp_10a[1] _NC1484 _NC1485 N1148 INVX0
X743 S_shr2[2] S_shr2[1] S_shr2[0] N315 N1060 _NC1486 _NC1487 OR4X1
X744 N1066 S_fract_48_i[0] N1363 N1102 _NC1488 _NC1489 MUX21X1
X745 S_fract_48_i[0] N40 N1608 _NC1490 _NC1491 NAND2X0
X746 N1063 N1066 N1468 N1101 _NC1492 _NC1493 MUX21X1
X747 N1603 _NC1494 _NC1495 N1352 INVX0
X748 N1604 _NC1496 _NC1497 N1354 INVX0
X749 N1606 _NC1498 _NC1499 N1358 INVX0
X750 N1066 S_fract_48_i[0] N1619 N1119 _NC1500 _NC1501 MUX21X1
X751 N1434 _NC1502 _NC1503 N1212 INVX0
X752 N1423 _NC1504 _NC1505 N1242 INVX0
X753 S_output_o[31] N304 N305 N300 _NC1506 _NC1507 OA21X1
X754 N287 N300 N301 N299 _NC1508 _NC1509 OA21X1
X755 N2993 N1101 N1420 _NC1510 _NC1511 NAND2X1
X756 S_shr2[4] _NC1512 _NC1513 N1141 INVX0
X757 N1610 _NC1514 _NC1515 N1344 INVX0
X758 N263 N244 N1080 _NC1516 _NC1517 AND2X1
X759 N263 N244 N247 _NC1518 _NC1519 AND2X1
X760 N263 N244 N1079 _NC1520 _NC1521 AND2X1
X761 N123 N122 N6870 _NC1522 _NC1523 NAND2X0
X762 N7990 N144 N7980 _NC1524 _NC1525 NAND2X0
X763 N5640 N223 N5630 _NC1526 _NC1527 NAND2X1
X764 N5650 N225 N5660 _NC1528 _NC1529 NAND2X0
X765 N6870 S_fract_48_i[41] N7520 _NC1530 _NC1531 NOR2X0
X766 N5620 N221 N4490 _NC1532 _NC1533 NAND2X1
X767 N1249 S_fract_48_i[40] N7990 _NC1534 _NC1535 NOR2X0
X768 N7980 S_fract_48_i[38] N7500 _NC1536 _NC1537 NOR2X0
X769 N5660 S_fract_48_i[8] N5640 _NC1538 _NC1539 NOR2X0
X770 N5630 S_fract_48_i[10] N5620 _NC1540 _NC1541 NOR2X0
X771 N263 S_frac_rnd[24] N246 _NC1542 _NC1543 AND2X1
X772 N177 N174 N5610 _NC1544 _NC1545 NAND2X1
X773 N538 N172 N5360 _NC1546 _NC1547 NAND2X1
X774 N5370 N170 N4470 _NC1548 _NC1549 NAND2X1
X775 N5610 S_fract_48_i[26] N538 _NC1550 _NC1551 NOR2X0
X776 N5360 S_fract_48_i[28] N5370 _NC1552 _NC1553 NOR2X0
X777 N170 N164 N7680 _NC1554 _NC1555 NAND2X1
X778 N182 N177 N7730 _NC1556 _NC1557 NAND2X1
X779 N555 N119 N556 _NC1558 _NC1559 NAND2X0
X780 N556 S_fract_48_i[45] N557 _NC1560 _NC1561 NOR2X0
X781 N7740 N198 N7140 _NC1562 _NC1563 NAND2X1
X782 N204 N198 N5280 _NC1564 _NC1565 NAND2X1
X783 N797 N196 N796 _NC1566 _NC1567 NAND2X1
X784 N5290 N196 N5300 _NC1568 _NC1569 NAND2X1
X785 N7670 N172 N7650 _NC1570 _NC1571 NAND2X1
X786 N7660 N174 N592 _NC1572 _NC1573 NAND2X1
X787 N1090 S_fract_48_i[43] N555 _NC1574 _NC1575 NOR2X0
X788 N5310 N182 N351 _NC1576 _NC1577 NAND2X1
X789 N7730 S_fract_48_i[22] N797 _NC1578 _NC1579 NOR2X0
X790 N7650 S_fract_48_i[26] N7660 _NC1580 _NC1581 NOR2X0
X791 N5300 S_fract_48_i[22] N5310 _NC1582 _NC1583 NOR2X0
X792 N7680 S_fract_48_i[28] N7670 _NC1584 _NC1585 NOR2X0
X793 N5280 S_fract_48_i[20] N5290 _NC1586 _NC1587 NOR2X0
X794 N796 S_fract_48_i[20] N7740 _NC1588 _NC1589 NOR2X0
X795 N221 N215 N7890 _NC1590 _NC1591 NAND2X1
X796 N794 N231 N795 _NC1592 _NC1593 NAND2X0
X797 N227 N226 N793 _NC1594 _NC1595 NAND2X0
X798 N152 N146 N5500 _NC1596 _NC1597 NAND2X1
X799 N5510 N144 N5600 _NC1598 _NC1599 NAND2X0
X800 N7880 N223 N7860 _NC1600 _NC1601 NAND2X1
X801 N559 N130 N3760 _NC1602 _NC1603 NAND2X0
X802 N7870 N225 N6160 _NC1604 _NC1605 NAND2X0
X803 N793 S_fract_48_i[4] N794 _NC1606 _NC1607 NOR2X0
X804 N5600 S_fract_48_i[40] N559 _NC1608 _NC1609 NOR2X0
X805 N7860 S_fract_48_i[8] N7870 _NC1610 _NC1611 NOR2X0
X806 N7890 S_fract_48_i[10] N7880 _NC1612 _NC1613 NOR2X0
X807 N5500 S_fract_48_i[38] N5510 _NC1614 _NC1615 NOR2X0
X808 N1070 S_fract_48_i[13] N5190 _NC1616 _NC1617 NOR2X0
X809 N1338 S_fract_48_i[16] N523 _NC1618 _NC1619 NOR2X0
X810 N1340 S_fract_48_i[15] N522 _NC1620 _NC1621 NOR2X0
X811 N1342 S_fract_48_i[14] N5180 _NC1622 _NC1623 NOR2X0
X812 N1336 S_fract_48_i[17] N4290 _NC1624 _NC1625 NOR2X0
X813 S_fract_48_i[35] S_fract_48_i[36] N760 _NC1626 _NC1627 NOR2X0
X814 N1293 S_fract_48_i[32] N7570 _NC1628 _NC1629 NOR2X0
X815 N1295 S_fract_48_i[34] N7550 _NC1630 _NC1631 NOR2X0
X816 N1294 S_fract_48_i[33] N7560 _NC1632 _NC1633 NOR2X0
X817 N1292 S_fract_48_i[31] N6960 _NC1634 _NC1635 NOR2X0
X818 N1076 S_fract_48_i[31] N542 _NC1636 _NC1637 NOR2X0
X819 N1311 S_fract_48_i[32] N541 _NC1638 _NC1639 NOR2X0
X820 N1306 S_fract_48_i[34] N5460 _NC1640 _NC1641 NOR2X0
X821 N1309 S_fract_48_i[33] N5450 _NC1642 _NC1643 NOR2X0
X822 N1303 S_fract_48_i[35] N4420 _NC1644 _NC1645 NOR2X0
X823 S_fract_48_i[17] N1073 N7820 _NC1646 _NC1647 NOR2X0
X824 N1332 S_fract_48_i[14] N779 _NC1648 _NC1649 NOR2X0
X825 N1333 S_fract_48_i[15] N778 _NC1650 _NC1651 NOR2X0
X826 N1334 S_fract_48_i[16] N777 _NC1652 _NC1653 NOR2X0
X827 N1331 S_fract_48_i[13] N709 _NC1654 _NC1655 NOR2X0
X828 N7470 N7480 N746 _NC1656 _NC1657 NAND2X1
X829 N2993 N1064 N744 _NC1658 _NC1659 NOR2X0
X830 N5670 N4520 N1054 N5090 _NC1660 _NC1661 AO21X1
X831 Add_90_I8_L07002_C132_carry[3] N1361 N395 _NC1662 _NC1663 XNOR2X1
X832 N378 N137 N1361 _NC1664 _NC1665 NAND2X0
X833 N1707 N226 N1362 _NC1666 _NC1667 NAND2X0
X834 Add_105_I8_L07002_C136_carry[3] N1362 N1723 _NC1668 _NC1669 XNOR2X1
X835 N259 _NC1670 _NC1671 N1191 INVX0
X836 N41 _NC1672 _NC1673 N1095 NBUFFX2
X837 N5650 N1081 N3330 _NC1674 _NC1675 NOR2X0
X838 N257 _NC1676 _NC1677 N1360 INVX0
X839 S_exp_10a[5] _NC1678 _NC1679 N1152 INVX0
X840 S_exp_10a[3] _NC1680 _NC1681 N1150 INVX0
X841 S_exp_10a[4] _NC1682 _NC1683 N1151 INVX0
X842 S_exp_10a[2] _NC1684 _NC1685 N1149 INVX0
X843 N1060 _NC1686 _NC1687 N1115 NBUFFX2
X844 N6870 N7520 N6350 _NC1688 _NC1689 NOR2X0
X845 N1060 _NC1690 _NC1691 N1109 NBUFFX2
X846 N1060 _NC1692 _NC1693 N1110 NBUFFX2
X847 N1060 _NC1694 _NC1695 N1111 NBUFFX2
X848 N1060 _NC1696 _NC1697 N1112 NBUFFX2
X849 N1060 _NC1698 _NC1699 N1113 NBUFFX2
X850 N1060 _NC1700 _NC1701 N1114 NBUFFX2
X851 N18040 _NC1702 _NC1703 N1253 INVX0
X852 S_exp_10a[0] _NC1704 _NC1705 N1147 INVX0
X853 N1060 _NC1706 _NC1707 N1108 NBUFFX2
X854 Sub_0_root_add_0_root_add_148_carry[4] N1152 N1059 _NC1708 _NC1709 NAND2X1
X855 S_exp_10a[6] N1059 N3005 _NC1710 _NC1711 XOR2X1
X856 N37 _NC1712 _NC1713 N1103 NBUFFX2
X857 N1843 _NC1714 _NC1715 N1277 INVX0
X858 N18330 _NC1716 _NC1717 N1281 INVX0
X859 N18230 _NC1718 _NC1719 N1285 INVX0
X860 N18140 _NC1720 _NC1721 N1289 INVX0
X861 N1134 N18540 N3150 _NC1722 _NC1723 NOR2X0
X862 N1134 N18530 N3149 _NC1724 _NC1725 NOR2X0
X863 N1136 N18080 N3152 _NC1726 _NC1727 NOR2X0
X864 N1136 N17990 N3151 _NC1728 _NC1729 NOR2X0
X865 N1134 N18510 N3147 _NC1730 _NC1731 NOR2X0
X866 N1134 N18500 N3146 _NC1732 _NC1733 NOR2X0
X867 N1134 N17740 N3144 _NC1734 _NC1735 NOR2X0
X868 N1134 N1731 N3143 _NC1736 _NC1737 NOR2X0
X869 N1136 N1715 N3141 _NC1738 _NC1739 NOR2X0
X870 N254 N252 N265 _NC1740 _NC1741 NAND2X1
X871 N17860 _NC1742 _NC1743 N1264 INVX0
X872 N1625 N12 N1645 _NC1744 _NC1745 NAND2X1
X873 N17500 _NC1746 _NC1747 N1298 INVX0
X874 N17420 _NC1748 _NC1749 N1302 INVX0
X875 N1445 N43 N1532 _NC1750 _NC1751 NAND2X1
X876 N5660 N5640 N3340 _NC1752 _NC1753 NOR2X0
X877 N38 _NC1754 _NC1755 N1100 NBUFFX2
X878 N41 _NC1756 _NC1757 N1094 NBUFFX4
X879 N1529 _NC1758 _NC1759 N1213 INVX0
X880 N1612 _NC1760 _NC1761 N1351 INVX0
X881 N1191 N254 N255 N253 _NC1762 _NC1763 OA21X1
X882 N261 N262 N251 _NC1764 _NC1765 NOR2X0
X883 N260 _NC1766 _NC1767 N1192 INVX0
X884 N1618 _NC1768 _NC1769 N1357 INVX0
X885 N1615 _NC1770 _NC1771 N1353 INVX0
X886 N1063 N1066 N1607 N1119 _NC1772 _NC1773 MUX21X1
X887 N1607 _NC1774 _NC1775 N1359 INVX0
X888 N1134 N18520 N3148 _NC1776 _NC1777 NOR2X0
X889 N1136 N1337 N3156 _NC1778 _NC1779 NOR2X0
X890 N1136 N1341 N3154 _NC1780 _NC1781 NOR2X0
X891 N1134 N18490 N3145 _NC1782 _NC1783 NOR2X0
X892 N1135 N17230 N3142 _NC1784 _NC1785 NOR2X0
X893 N1534 _NC1786 _NC1787 N1201 INVX0
X894 N1733 _NC1788 _NC1789 N1301 INVX0
X895 N1143 N1201 N3127 _NC1790 _NC1791 NOR2X0
X896 N1717 _NC1792 _NC1793 N1308 INVX0
X897 N1143 N1532 N3125 _NC1794 _NC1795 NOR2X0
X898 N17770 _NC1796 _NC1797 N1271 INVX0
X899 N1619 N9 N16360 _NC1798 _NC1799 NAND2X1
X900 N1605 _NC1800 _NC1801 N1356 INVX0
X901 N1143 N1531 N3124 _NC1802 _NC1803 NOR2X0
X902 N1134 N17090 N3172 _NC1804 _NC1805 NOR2X0
X903 N1456 _NC1806 _NC1807 N1262 INVX0
X904 N299 _NC1808 _NC1809 N1117 INVX0
X905 N299 _NC1810 _NC1811 N1118 INVX0
X906 N5280 N5290 N389 _NC1812 _NC1813 NOR2X0
X907 N1249 N7990 N574 _NC1814 _NC1815 NOR2X0
X908 N17080 N1131 N18470 _NC1816 _NC1817 NOR2X0
X909 N1697 N1131 N1827 _NC1818 _NC1819 NOR2X0
X910 N5190 N1070 N3440 _NC1820 _NC1821 NOR2X0
X911 N38 _NC1822 _NC1823 N1098 NBUFFX4
X912 N41 _NC1824 _NC1825 N1093 NBUFFX4
X913 N38 _NC1826 _NC1827 N1099 NBUFFX4
X914 N3240 _NC1828 _NC1829 N1164 INVX0
X915 N1526 _NC1830 _NC1831 N1243 INVX0
X916 N1512 _NC1832 _NC1833 N1245 INVX0
X917 N1509 _NC1834 _NC1835 N1250 INVX0
X918 N1506 _NC1836 _NC1837 N1254 INVX0
X919 N1503 _NC1838 _NC1839 N1261 INVX0
X920 N1523 _NC1840 _NC1841 N1304 INVX0
X921 N1472 _NC1842 _NC1843 N1307 INVX0
X922 N1587 _NC1844 _NC1845 N1279 INVX0
X923 N1579 _NC1846 _NC1847 N1283 INVX0
X924 N1571 _NC1848 _NC1849 N1287 INVX0
X925 N1563 _NC1850 _NC1851 N1296 INVX0
X926 N1547 _NC1852 _NC1853 N1300 INVX0
X927 N1593 _NC1854 _NC1855 N1275 INVX0
X928 N1446 _NC1856 _NC1857 N1196 INVX0
X929 N1143 N1197 N3133 _NC1858 _NC1859 NOR2X0
X930 N17830 _NC1860 _NC1861 N1270 INVX0
X931 N1143 N1203 N3131 _NC1862 _NC1863 NOR2X0
X932 N1765 _NC1864 _NC1865 N1280 INVX0
X933 N1143 N1209 N3130 _NC1866 _NC1867 NOR2X0
X934 N17570 _NC1868 _NC1869 N1284 INVX0
X935 N1143 N1199 N3129 _NC1870 _NC1871 NOR2X0
X936 N1749 _NC1872 _NC1873 N1288 INVX0
X937 N1143 N1205 N3128 _NC1874 _NC1875 NOR2X0
X938 N17410 _NC1876 _NC1877 N1297 INVX0
X939 N1142 N1505 N3119 _NC1878 _NC1879 NOR2X0
X940 N1135 N1683 N3167 _NC1880 _NC1881 NOR2X0
X941 N1142 N1455 N3110 _NC1882 _NC1883 NOR2X0
X942 N1135 N16370 N3158 _NC1884 _NC1885 NOR2X0
X943 N1144 N1206 N3140 _NC1886 _NC1887 NOR2X0
X944 N1144 N1208 N3138 _NC1888 _NC1889 NOR2X0
X945 N1144 N1211 N3134 _NC1890 _NC1891 NOR2X0
X946 N17920 _NC1892 _NC1893 N1263 INVX0
X947 N1795 _NC1894 _NC1895 N1257 INVX0
X948 N1419 _NC1896 _NC1897 N1215 INVX0
X949 N1599 _NC1898 _NC1899 N1269 INVX0
X950 N1143 N1210 N3126 _NC1900 _NC1901 NOR2X0
X951 N17250 _NC1902 _NC1903 N1305 INVX0
X952 N1143 N1528 N3123 _NC1904 _NC1905 NOR2X0
X953 N1134 N17040 N3171 _NC1906 _NC1907 NOR2X0
X954 N1143 N1514 N3122 _NC1908 _NC1909 NOR2X0
X955 N1134 N1698 N3170 _NC1910 _NC1911 NOR2X0
X956 N1143 N1511 N3121 _NC1912 _NC1913 NOR2X0
X957 N1134 N16930 N3169 _NC1914 _NC1915 NOR2X0
X958 N1142 N1508 N3120 _NC1916 _NC1917 NOR2X0
X959 N1135 N16880 N3168 _NC1918 _NC1919 NOR2X0
X960 N1142 N1502 N3118 _NC1920 _NC1921 NOR2X0
X961 N1135 N16780 N3166 _NC1922 _NC1923 NOR2X0
X962 N1142 N1498 N3117 _NC1924 _NC1925 NOR2X0
X963 N1135 N16720 N3165 _NC1926 _NC1927 NOR2X0
X964 N1142 N1494 N3116 _NC1928 _NC1929 NOR2X0
X965 N1135 N16660 N3164 _NC1930 _NC1931 NOR2X0
X966 N1142 N1489 N3115 _NC1932 _NC1933 NOR2X0
X967 N1135 N1662 N3163 _NC1934 _NC1935 NOR2X0
X968 N1142 N1484 N3114 _NC1936 _NC1937 NOR2X0
X969 N1135 N1657 N3162 _NC1938 _NC1939 NOR2X0
X970 N1142 N1479 N3113 _NC1940 _NC1941 NOR2X0
X971 N1135 N1652 N3161 _NC1942 _NC1943 NOR2X0
X972 N1142 N1465 N3112 _NC1944 _NC1945 NOR2X0
X973 N1135 N1646 N3160 _NC1946 _NC1947 NOR2X0
X974 N1142 N1460 N3111 _NC1948 _NC1949 NOR2X0
X975 N1135 N1642 N3159 _NC1950 _NC1951 NOR2X0
X976 N1142 N1196 N3109 _NC1952 _NC1953 NOR2X0
X977 N1136 N16330 N3157 _NC1954 _NC1955 NOR2X0
X978 N7670 N7650 N6310 _NC1956 _NC1957 NAND2X1
X979 N1144 N1202 N3139 _NC1958 _NC1959 NOR2X0
X980 N1144 N1204 N3136 _NC1960 _NC1961 NOR2X0
X981 N1810 _NC1962 _NC1963 N1252 INVX0
X982 N1144 N1200 N3135 _NC1964 _NC1965 NOR2X0
X983 N18010 _NC1966 _NC1967 N1256 INVX0
X984 N1144 N1207 N3132 _NC1968 _NC1969 NOR2X0
X985 N17730 _NC1970 _NC1971 N1276 INVX0
X986 N1490 _NC1972 _NC1973 N1214 INVX0
X987 N1485 _NC1974 _NC1975 N1244 INVX0
X988 N1480 _NC1976 _NC1977 N1246 INVX0
X989 N1461 _NC1978 _NC1979 N1255 INVX0
X990 N1387 N1098 N1431 _NC1980 _NC1981 NAND2X1
X991 N5290 N5300 N354 _NC1982 _NC1983 NAND2X1
X992 N5610 N538 N3590 _NC1984 _NC1985 NOR2X0
X993 N7730 N797 N6000 _NC1986 _NC1987 NOR2X0
X994 N326 N327 S_exp_10a[9] N316 _NC1988 _NC1989 AO21X1
X995 N36 _NC1990 _NC1991 N1097 NBUFFX4
X996 N1552 N1139 N1601 _NC1992 _NC1993 NOR2X0
X997 N37 _NC1994 _NC1995 N1101 NBUFFX4
X998 N37 _NC1996 _NC1997 N1102 NBUFFX4
X999 N1530 N1138 N1558 _NC1998 _NC1999 NOR2X0
X1000 N1527 N1138 N1557 _NC2000 _NC2001 NOR2X0
X1001 N1513 N1138 N1556 _NC2002 _NC2003 NOR2X0
X1002 N1507 N1138 N1554 _NC2004 _NC2005 NOR2X0
X1003 N1504 N1138 N1553 _NC2006 _NC2007 NOR2X0
X1004 N1136 N1339 N3155 _NC2008 _NC2009 NOR2X0
X1005 N1136 N1343 N3153 _NC2010 _NC2011 NOR2X0
X1006 N4490 _NC2012 _NC2013 N1345 INVX0
X1007 N1144 N1198 N3137 _NC2014 _NC2015 NOR2X0
X1008 N5630 N5620 N337 _NC2016 _NC2017 NOR2X0
X1009 N7980 N7500 N575 _NC2018 _NC2019 NOR2X0
X1010 N17030 N1131 N18370 _NC2020 _NC2021 NOR2X0
X1011 N16920 N1131 N18180 _NC2022 _NC2023 NOR2X0
X1012 N760 S_fract_48_i[36] N5870 _NC2024 _NC2025 NOR2X0
X1013 N36 _NC2026 _NC2027 N1096 NBUFFX4
X1014 N1510 N1138 N1555 _NC2028 _NC2029 NOR2X0
X1015 N7510 _NC2030 _NC2031 N1248 INVX0
X1016 N5620 N4490 N4500 _NC2032 _NC2033 NAND2X1
X1017 N7520 _NC2034 _NC2035 N1249 INVX0
X1018 N5500 N5510 N387 _NC2036 _NC2037 NOR2X0
X1019 N1342 N5180 N3430 _NC2038 _NC2039 NOR2X0
X1020 N1082 N1085 N5650 _NC2040 _NC2041 NOR2X0
X1021 N555 N1089 N3830 _NC2042 _NC2043 NOR2X0
X1022 N542 N1076 N369 _NC2044 _NC2045 NOR2X0
X1023 N4470 _NC2046 _NC2047 N1314 INVX0
X1024 N7880 N7860 N628 _NC2048 _NC2049 NAND2X1
X1025 N5510 N5600 N3790 _NC2050 _NC2051 NAND2X1
X1026 N1295 N7550 N5840 _NC2052 _NC2053 NOR2X0
X1027 N5360 N5370 N3620 _NC2054 _NC2055 NOR2X0
X1028 N796 N7740 N5980 _NC2056 _NC2057 NOR2X0
X1029 N7820 N1073 N6110 _NC2058 _NC2059 NOR2X0
X1030 N1193 N258 N250 _NC2060 _NC2061 NAND2X1
X1031 N3349 N3348 N298 _NC2062 _NC2063 NAND2X1
X1032 N3347 _NC2064 _NC2065 N1190 INVX0
X1033 N7140 _NC2066 _NC2067 N1320 INVX0
X1034 N5370 N4470 N4480 _NC2068 _NC2069 NAND2X1
X1035 N1340 N522 N345 _NC2070 _NC2071 NOR2X0
X1036 N793 N794 N623 _NC2072 _NC2073 NOR2X0
X1037 N7740 N7140 N7150 _NC2074 _NC2075 NAND2X1
X1038 N5310 N351 N352 _NC2076 _NC2077 NAND2X1
X1039 N7660 N592 N593 _NC2078 _NC2079 NAND2X1
X1040 N558 _NC2080 _NC2081 N1194 INVX0
X1041 N1334 N777 N608 _NC2082 _NC2083 NOR2X0
X1042 N1311 N541 N368 _NC2084 _NC2085 NOR2X0
X1043 N1294 N7560 N5850 _NC2086 _NC2087 NOR2X0
X1044 N556 N557 N385 _NC2088 _NC2089 NOR2X0
X1045 N4290 _NC2090 _NC2091 N1335 INVX0
X1046 N7870 N6160 N6170 _NC2092 _NC2093 NAND2X1
X1047 N559 N3760 N3770 _NC2094 _NC2095 NAND2X1
X1048 N1338 N523 N3460 _NC2096 _NC2097 NOR2X0
X1049 N795 N624 N626 _NC2098 _NC2099 NOR2X0
X1050 N1309 N5450 N370 _NC2100 _NC2101 NOR2X0
X1051 N1293 N7570 N5860 _NC2102 _NC2103 NOR2X0
X1052 N1333 N778 N609 _NC2104 _NC2105 NOR2X0
X1053 N5190 _NC2106 _NC2107 N1342 INVX0
X1054 N523 _NC2108 _NC2109 N1336 INVX0
X1055 N522 _NC2110 _NC2111 N1338 INVX0
X1056 N5180 _NC2112 _NC2113 N1340 INVX0
X1057 N1336 N4290 N3470 _NC2114 _NC2115 NOR2X0
X1058 N4420 _NC2116 _NC2117 N1299 INVX0
X1059 N6960 _NC2118 _NC2119 N1291 INVX0
X1060 N1306 N5460 N371 _NC2120 _NC2121 NOR2X0
X1061 N1332 N779 N610 _NC2122 _NC2123 NOR2X0
X1062 N709 _NC2124 _NC2125 N1330 INVX0
X1063 N760 _NC2126 _NC2127 N1295 INVX0
X1064 N7570 _NC2128 _NC2129 N1292 INVX0
X1065 N7550 _NC2130 _NC2131 N1294 INVX0
X1066 N7560 _NC2132 _NC2133 N1293 INVX0
X1067 N1292 N6960 N5880 _NC2134 _NC2135 NOR2X0
X1068 N542 _NC2136 _NC2137 N1311 INVX0
X1069 N541 _NC2138 _NC2139 N1309 INVX0
X1070 N5460 _NC2140 _NC2141 N1303 INVX0
X1071 N5450 _NC2142 _NC2143 N1306 INVX0
X1072 N1303 N4420 N372 _NC2144 _NC2145 NOR2X0
X1073 N617 _NC2146 _NC2147 N1241 INVX0
X1074 N5880 N949 N6640 _NC2148 _NC2149 NAND2X0
X1075 N7820 _NC2150 _NC2151 N1334 INVX0
X1076 N779 _NC2152 _NC2153 N1331 INVX0
X1077 N778 _NC2154 _NC2155 N1332 INVX0
X1078 N777 _NC2156 _NC2157 N1333 INVX0
X1079 N1331 N709 N6120 _NC2158 _NC2159 NOR2X0
X1080 N1964 _NC2160 _NC2161 N1326 INVX0
X1081 N1044 N1980 N525 _NC2162 _NC2163 NAND2X0
X1082 N5880 N6340 N5810 _NC2164 _NC2165 NAND2X0
X1083 N143 _NC2166 _NC2167 N1239 INVX0
X1084 N8580 _NC2168 _NC2169 N1230 INVX0
X1085 N8550 _NC2170 _NC2171 N1222 INVX0
X1086 N846 _NC2172 _NC2173 N1238 INVX0
X1087 N1015 _NC2174 _NC2175 N1221 INVX0
X1088 N10130 _NC2176 _NC2177 N1229 INVX0
X1089 N9560 _NC2178 _NC2179 N1169 INVX0
X1090 N65 _NC2180 _NC2181 N1237 INVX0
X1091 N10100 _NC2182 _NC2183 N1228 INVX0
X1092 N1014 _NC2184 _NC2185 N1175 INVX0
X1093 N10090 _NC2186 _NC2187 N1220 INVX0
X1094 N8170 _NC2188 _NC2189 N1187 INVX0
X1095 N9060 _NC2190 _NC2191 N1327 INVX0
X1096 N8920 _NC2192 _NC2193 N1168 INVX0
X1097 N5940 _NC2194 _NC2195 N1323 INVX0
X1098 N998 _NC2196 _NC2197 N1180 INVX0
X1099 N827 _NC2198 _NC2199 N1324 INVX0
X1100 N9250 _NC2200 _NC2201 N1328 INVX0
X1101 N8210 _NC2202 _NC2203 N1325 INVX0
X1102 N9260 _NC2204 _NC2205 N1329 INVX0
X1103 N9620 _NC2206 _NC2207 N1179 INVX0
X1104 N914 _NC2208 _NC2209 N1322 INVX0
X1105 N878 _NC2210 _NC2211 N1186 INVX0
X1106 N194 _NC2212 _NC2213 N1185 INVX0
X1107 N150 _NC2214 _NC2215 N1236 INVX0
X1108 N906 _NC2216 _NC2217 N1240 INVX0
X1109 N8390 _NC2218 _NC2219 N1316 INVX0
X1110 N3810 _NC2220 _NC2221 N1317 INVX0
X1111 N7750 N776 N7710 _NC2222 _NC2223 NOR2X0
X1112 N7910 N7920 N7900 _NC2224 _NC2225 NOR2X0
X1113 N1312 N634 N762 _NC2226 _NC2227 NAND2X0
X1114 N5160 N5170 N5150 _NC2228 _NC2229 NOR2X0
X1115 N539 N540 N5340 _NC2230 _NC2231 NOR2X0
X1116 N5530 N5540 N5520 _NC2232 _NC2233 NOR2X0
X1117 N9270 _NC2234 _NC2235 N1235 INVX0
X1118 N8070 _NC2236 _NC2237 N1226 INVX0
X1119 N8060 _NC2238 _NC2239 N1218 INVX0
X1120 N185 _NC2240 _NC2241 N1234 INVX0
X1121 N80 _NC2242 _NC2243 N1217 INVX0
X1122 N9440 _NC2244 _NC2245 N1225 INVX0
X1123 N9950 _NC2246 _NC2247 N1166 INVX0
X1124 N997 _NC2248 _NC2249 N1173 INVX0
X1125 N9430 _NC2250 _NC2251 N1233 INVX0
X1126 N89 _NC2252 _NC2253 N1224 INVX0
X1127 N9180 _NC2254 _NC2255 N1165 INVX0
X1128 N8040 _NC2256 _NC2257 N1172 INVX0
X1129 N86 _NC2258 _NC2259 N1216 INVX0
X1130 N109 _NC2260 _NC2261 N1266 INVX0
X1131 N100 _NC2262 _NC2263 N1267 INVX0
X1132 N131 _NC2264 _NC2265 N1265 INVX0
X1133 N10050 _NC2266 _NC2267 N1178 INVX0
X1134 N8150 _NC2268 _NC2269 N1184 INVX0
X1135 N8570 _NC2270 _NC2271 N1272 INVX0
X1136 N83 _NC2272 _NC2273 N1232 INVX0
X1137 N8410 _NC2274 _NC2275 N1273 INVX0
X1138 N843 _NC2276 _NC2277 N1274 INVX0
X1139 N85 _NC2278 _NC2279 N1258 INVX0
X1140 N826 _NC2280 _NC2281 N1177 INVX0
X1141 N10030 _NC2282 _NC2283 N1183 INVX0
X1142 N2270 _NC2284 _NC2285 N1259 INVX0
X1143 N2269 _NC2286 _NC2287 N1260 INVX0
X1144 N9910 _NC2288 _NC2289 N1176 INVX0
X1145 N879 _NC2290 _NC2291 N1182 INVX0
X1146 N6850 N6860 N661 N1634 _NC2292 _NC2293 OA21X1
X1147 N8250 _NC2294 _NC2295 N1231 INVX0
X1148 N9530 _NC2296 _NC2297 N1227 INVX0
X1149 N6990 N7000 N6970 _NC2298 _NC2299 NOR2X0
X1150 N712 N7130 N710 _NC2300 _NC2301 NOR2X0
X1151 N5880 N8050 N691 _NC2302 _NC2303 NAND2X0
X1152 N6120 N110 N7040 _NC2304 _NC2305 NAND2X0
X1153 N1361 _NC2306 _NC2307 N1171 INVX0
X1154 N1362 _NC2308 _NC2309 N1181 INVX0
X1155 N575 N9520 N5770 N4510 N574 N15 N1058 _NC2310 _NC2311 AOI222X1
X1156 N5780 N828 N6350 N366 N1248 N6360 N1057 _NC2312 _NC2313 AOI222X1
X1157 N1057 N1058 N573 N1636 _NC2314 _NC2315 AOI21X1
X1158 N659 N660 N661 N1635 _NC2316 _NC2317 OA21X1
X1159 N9880 _NC2318 _NC2319 N1223 INVX0
X1160 N180 _NC2320 _NC2321 N1219 INVX0
X1161 N211 _NC2322 _NC2323 N1174 INVX0
X1162 N7340 N7350 N7320 _NC2324 _NC2325 NOR2X0
X1163 N6710 N6720 N6690 _NC2326 _NC2327 NOR2X0
X1164 N6450 N6460 N643 _NC2328 _NC2329 NOR2X0
X1165 N6830 N6840 N6810 _NC2330 _NC2331 NOR2X0
X1166 N657 N658 N6550 _NC2332 _NC2333 NOR2X0
X1167 N742 N743 N7410 _NC2334 _NC2335 NOR2X0
X1168 N7190 N7200 N7170 _NC2336 _NC2337 NAND2X0
X1169 N5880 N24 N6380 _NC2338 _NC2339 NAND2X0
X1170 N6120 N916 N676 _NC2340 _NC2341 NAND2X0
X1171 N6120 N9740 N6500 _NC2342 _NC2343 NAND2X0
X1172 N1312 N635 N727 _NC2344 _NC2345 NAND2X0
X1173 N1017 _NC2346 _NC2347 N1347 INVX0
X1174 N487 N488 N4860 _NC2348 _NC2349 NOR2X0
X1175 N9230 _NC2350 _NC2351 N1348 INVX0
X1176 N4180 N419 N331 N2977 _NC2352 _NC2353 OA21X1
X1177 N9360 _NC2354 _NC2355 N1170 INVX0
X1178 N140 _NC2356 _NC2357 N1167 INVX0
X1179 N453 N454 N455 N456 N1056 _NC2358 _NC2359 AND4X1
X1180 N10400 N1056 N4520 N331 N2976 _NC2360 _NC2361 OAI22X1
X1181 N404 N405 N402 _NC2362 _NC2363 NOR2X0
X1182 N4320 N4330 N4300 _NC2364 _NC2365 NOR2X0
X1183 N470 N471 N4680 _NC2366 _NC2367 NOR2X0
X1184 N4990 N5000 N4970 _NC2368 _NC2369 NOR2X0
X1185 N3460 N169 N345 N999 N490 _NC2370 _NC2371 AO22X1
X1186 N3470 N8750 N340 _NC2372 _NC2373 NAND2X0
X1187 N372 N8910 N3650 _NC2374 _NC2375 NAND2X0
X1188 N3470 N9090 N3970 _NC2376 _NC2377 NAND2X0
X1189 N6120 N5970 N6050 _NC2378 _NC2379 NAND2X0
X1190 N1845 _NC2380 _NC2381 N1310 INVX0
X1191 N18350 _NC2382 _NC2383 N1313 INVX0
X1192 N18250 _NC2384 _NC2385 N1318 INVX0
X1193 N18160 _NC2386 _NC2387 N1319 INVX0
X1194 N1532 _NC2388 _NC2389 N1195 INVX0
X1195 N1609 _NC2390 _NC2391 N1349 INVX0
X1196 N265 _NC2392 _NC2393 N1193 INVX0
X1197 N18030 _NC2394 _NC2395 N1278 INVX0
X1198 N1794 _NC2396 _NC2397 N1282 INVX0
X1199 N17850 _NC2398 _NC2399 N1286 INVX0
X1200 N17760 _NC2400 _NC2401 N1290 INVX0
X1201 N1627 _NC2402 _NC2403 N1355 INVX0
X1202 N18470 _NC2404 _NC2405 N1337 INVX0
X1203 N1827 _NC2406 _NC2407 N1341 INVX0
X1204 N1624 _NC2408 _NC2409 N1350 INVX0
X1205 N1524 N1138 N1534 _NC2410 _NC2411 NOR2X0
X1206 N1500 _NC2412 _NC2413 N1268 INVX0
X1207 N1447 _NC2414 _NC2415 N1247 INVX0
X1208 N1475 _NC2416 _NC2417 N1251 INVX0
X1209 N1601 _NC2418 _NC2419 N1211 INVX0
X1210 N1558 _NC2420 _NC2421 N1206 INVX0
X1211 N1557 _NC2422 _NC2423 N1202 INVX0
X1212 N1556 _NC2424 _NC2425 N1208 INVX0
X1213 N1554 _NC2426 _NC2427 N1204 INVX0
X1214 N1553 _NC2428 _NC2429 N1200 INVX0
X1215 N1495 N1093 N1551 _NC2430 _NC2431 NAND2X1
X1216 N316 N322 N321 _NC2432 _NC2433 NOR2X0
X1217 N1551 N1139 N1595 _NC2434 _NC2435 NOR2X0
X1218 N1539 N1139 N1589 _NC2436 _NC2437 NOR2X0
X1219 N1538 N1138 N1581 _NC2438 _NC2439 NOR2X0
X1220 N1537 N1138 N1573 _NC2440 _NC2441 NOR2X0
X1221 N1536 N1138 N1565 _NC2442 _NC2443 NOR2X0
X1222 N1535 N1138 N1549 _NC2444 _NC2445 NOR2X0
X1223 N1473 N1138 N1533 _NC2446 _NC2447 NOR2X0
X1224 N18370 _NC2448 _NC2449 N1339 INVX0
X1225 N18180 _NC2450 _NC2451 N1343 INVX0
X1226 N1400 N1096 N1476 _NC2452 _NC2453 NAND2X1
X1227 N1555 _NC2454 _NC2455 N1198 INVX0
X1228 N4500 _NC2456 _NC2457 N1346 INVX0
X1229 N250 N1360 N263 _NC2458 _NC2459 NOR2X0
X1230 N4480 _NC2460 _NC2461 N1315 INVX0
X1231 N319 _NC2462 _NC2463 N1188 INVX0
X1232 N1188 S_exp_10b[8] N318 _NC2464 _NC2465 NOR2X0
X1233 N322 _NC2466 _NC2467 N1189 INVX0
X1234 N316 N1189 N319 _NC2468 _NC2469 NOR2X0
X1235 N7150 _NC2470 _NC2471 N1321 INVX0
X1236 N593 _NC2472 _NC2473 N1312 INVX0
X1237 S_fract_48_i[12] _NC2474 _NC2475 N1070 NBUFFX2
X1238 S_fract_48_i[30] _NC2476 _NC2477 N1076 NBUFFX2
X1239 S_fract_48_i[18] _NC2478 _NC2479 N1073 NBUFFX2
X1240 S_fract_48_i[18] _NC2480 _NC2481 N1074 NBUFFX2
X1241 S_fract_48_i[18] _NC2482 _NC2483 N1075 NBUFFX2
X1242 S_fract_48_i[30] _NC2484 _NC2485 N1077 NBUFFX2
X1243 S_fract_48_i[30] _NC2486 _NC2487 N1078 NBUFFX2
X1244 S_fract_48_i[12] _NC2488 _NC2489 N1072 DELLN1X2
X1245 S_fract_48_i[12] _NC2490 _NC2491 N1071 DELLN1X2
X1246 N1595 _NC2492 _NC2493 N1197 INVX0
X1247 N1589 _NC2494 _NC2495 N1207 INVX0
X1248 N1581 _NC2496 _NC2497 N1203 INVX0
X1249 N1573 _NC2498 _NC2499 N1209 INVX0
X1250 N1565 _NC2500 _NC2501 N1199 INVX0
X1251 N1549 _NC2502 _NC2503 N1205 INVX0
X1252 N1533 _NC2504 _NC2505 N1210 INVX0
X1253 N33 N339 N335 _NC2506 _NC2507 NAND2X0
X1254 N30 N3640 N3600 _NC2508 _NC2509 NAND2X0
X1255 N32 N6040 N6010 _NC2510 _NC2511 NAND2X0
X1256 S_shr2[5] _NC2512 _NC2513 N1143 NBUFFX2
X1257 S_shl2[4] _NC2514 _NC2515 N1134 NBUFFX2
X1258 S_shl2[4] _NC2516 _NC2517 N1135 NBUFFX2
X1259 S_shr2[5] _NC2518 _NC2519 N1142 NBUFFX2
X1260 S_shl2[4] _NC2520 _NC2521 N1136 NBUFFX2
X1261 S_shr2[5] _NC2522 _NC2523 N1144 NBUFFX2
X1262 N452 S_fract_48_i[36] N813 N5870 N5820 _NC2524 _NC2525 AOI22X1
X1263 Add_90_I46_L07002_C132_carry[3] N1030 N1041 _NC2526 _NC2527 XOR2X2
X1264 N1054 N232 N1055 _NC2528 _NC2529 XNOR2X2
X1265 S_fract_48_i[1] N233 N1054 _NC2530 _NC2531 XNOR2X1
X1266 N745 N1061 N8030 _NC2532 _NC2533 XNOR2X2
X1267 N8030 S_fract_48_i[43] N1053 _NC2534 _NC2535 NOR2X0
X1268 N745 _NC2536 _NC2537 N1052 DELLN1X2
X1269 Add_105_I44_L07002_C136_carry[2] N2288 Add_105_I44_L07002_C136_carry[3] _NC2538 _NC2539 _NC2540 HADDX2
X1270 Add_105_I46_L07002_C136_carry[2] N2320 Add_105_I46_L07002_C136_carry[3] _NC2541 _NC2542 _NC2543 HADDX2
X1271 Add_105_I32_L07002_C136_carry[0] N2094 Add_105_I32_L07002_C136_carry[1] _NC2544 _NC2545 _NC2546 HADDX2
X1272 N3580 N915 N1146 N2001 N3590 N8350 N1051 _NC2547 _NC2548 AOI222X2
X1273 N1666 Add_105_I5_L07002_C136_carry[2] N1675 _NC2549 _NC2550 _NC2551 HADDX2
X1274 N1673 N229 S_fract_48_i[4] N847 N1678 _NC2552 _NC2553 AO22X1
X1275 Add_105_I39_L07002_C136_carry[0] N2206 Add_105_I39_L07002_C136_carry[1] _NC2554 _NC2555 _NC2556 HADDX2
X1276 Add_105_I28_L07002_C136_carry[0] N2030 Add_105_I28_L07002_C136_carry[1] _NC2557 _NC2558 _NC2559 HADDX2
X1277 Add_105_I28_L07002_C136_carry[2] N2032 Add_105_I28_L07002_C136_carry[3] _NC2560 _NC2561 _NC2562 HADDX2
X1278 Add_105_I13_L07002_C136_carry[0] N1790 Add_105_I13_L07002_C136_carry[1] _NC2563 _NC2564 _NC2565 HADDX2
X1279 N1840 Add_105_I16_L07002_C136_carry[2] Add_105_I16_L07002_C136_carry[3] _NC2566 _NC2567 _NC2568 HADDX2
X1280 Add_105_I35_L07002_C136_carry[0] N2142 Add_105_I35_L07002_C136_carry[1] _NC2569 _NC2570 _NC2571 HADDX2
X1281 N233 N1065 N1049 _NC2572 _NC2573 XNOR2X1
X1282 Add_105_I33_L07002_C136_carry[2] N2112 Add_105_I33_L07002_C136_carry[3] _NC2574 _NC2575 _NC2576 HADDX2
X1283 N1775 Add_105_I12_L07002_C136_carry[1] Add_105_I12_L07002_C136_carry[2] _NC2577 _NC2578 _NC2579 HADDX2
X1284 Add_105_I16_L07002_C136_carry[0] N1838 Add_105_I16_L07002_C136_carry[1] _NC2580 _NC2581 _NC2582 HADDX2
X1285 N1806 Add_105_I14_L07002_C136_carry[0] Add_105_I14_L07002_C136_carry[1] _NC2583 _NC2584 _NC2585 HADDX2
X1286 Add_105_I21_L07002_C136_carry[2] N1920 Add_105_I21_L07002_C136_carry[3] _NC2586 _NC2587 _NC2588 HADDX2
X1287 Add_105_I29_L07002_C136_carry[2] N2048 Add_105_I29_L07002_C136_carry[3] _NC2589 _NC2590 _NC2591 HADDX2
X1288 N1792 Add_105_I13_L07002_C136_carry[2] Add_105_I13_L07002_C136_carry[3] _NC2592 _NC2593 _NC2594 HADDX2
X1289 N3830 N234 N1089 N945 N384 N10210 N1048 _NC2595 _NC2596 AOI222X1
X1290 N2363 N1194 N385 N67 N386 N330 N1047 _NC2597 _NC2598 AOI222X2
X1291 N1047 N1048 N3750 _NC2599 _NC2600 AND2X1
X1292 N1180 N354 N1179 N355 N1046 _NC2601 _NC2602 OAI22X1
X1293 N1051 N1050 N1045 _NC2603 _NC2604 NAND2X0
X1294 N1043 N1045 N195 N1044 N1046 N3490 _NC2605 _NC2606 AOI221X1
X1295 N1346 N895 N1345 N335 N336 N10410 _NC2607 _NC2608 AOI221X2
X1296 N1042 N10410 N10400 N2979 _NC2609 _NC2610 AOI21X1
X1297 N3760 N3750 N1176 N3770 N3780 N10390 _NC2611 _NC2612 OAI221X1
X1298 N29 N387 N1018 S_fract_48_i[36] N861 N388 N10380 _NC2613 _NC2614 AO222X1
X1299 N10380 N10390 N4420 N3640 _NC2615 _NC2616 OAI21X1
X1300 Add_105_I39_L07002_C136_carry[1] N2207 Add_105_I39_L07002_C136_carry[2] _NC2617 _NC2618 _NC2619 HADDX2
X1301 Add_105_I32_L07002_C136_carry[1] N2095 Add_105_I32_L07002_C136_carry[2] _NC2620 _NC2621 _NC2622 HADDX2
X1302 N1695 Add_105_I7_L07002_C136_carry[1] Add_105_I7_L07002_C136_carry[2] _NC2623 _NC2624 _NC2625 HADDX2
X1303 S_fract_48_i[1] _NC2626 _NC2627 N10370 INVX0
X1304 N1680 Add_105_I6_L07002_C136_carry[3] N1690 _NC2628 _NC2629 _NC2630 HADDX2
X1305 N1776 Add_105_I12_L07002_C136_carry[2] Add_105_I12_L07002_C136_carry[3] _NC2631 _NC2632 _NC2633 HADDX2
X1306 N2351 Add_105_I48_L07002_C136_carry[1] Add_105_I48_L07002_C136_carry[2] _NC2634 _NC2635 _NC2636 HADDX1
X1307 N1315 N9020 N3600 N1314 N361 N1050 _NC2637 _NC2638 AOI221X1
X1308 Add_105_I43_L07002_C136_carry[2] N2272 Add_105_I43_L07002_C136_carry[3] _NC2639 _NC2640 _NC2641 HADDX2
X1309 Add_105_I40_L07002_C136_carry[2] N2224 Add_105_I40_L07002_C136_carry[3] _NC2642 _NC2643 _NC2644 HADDX2
X1310 N1696 Add_105_I7_L07002_C136_carry[2] N1707 _NC2645 _NC2646 _NC2647 HADDX2
X1311 N1727 Add_105_I9_L07002_C136_carry[1] Add_105_I9_L07002_C136_carry[2] _NC2648 _NC2649 _NC2650 HADDX2
X1312 N4140 N3760 N1182 N3770 N4150 N10360 _NC2651 _NC2652 OAI221X1
X1313 N10020 N387 N1032 S_fract_48_i[36] N9100 N388 N1035 _NC2653 _NC2654 AO222X1
X1314 N1035 N10360 N4420 N4080 _NC2655 _NC2656 OAI21X1
X1315 Add_105_I21_L07002_C136_carry[1] N1919 Add_105_I21_L07002_C136_carry[2] _NC2657 _NC2658 _NC2659 HADDX2
X1316 N9210 N3340 N984 N1083 N453 _NC2660 _NC2661 AOI22X1
X1317 N1674 N229 N1666 S_fract_48_i[4] N1034 _NC2662 _NC2663 AO22X1
X1318 N1808 Add_105_I14_L07002_C136_carry[2] Add_105_I14_L07002_C136_carry[3] _NC2664 _NC2665 _NC2666 HADDX2
X1319 Add_105_I26_L07002_C136_carry[1] N1999 Add_105_I26_L07002_C136_carry[2] _NC2667 _NC2668 _NC2669 HADDX2
X1320 Add_105_I19_L07002_C136_carry[2] N1888 Add_105_I19_L07002_C136_carry[3] _NC2670 _NC2671 _NC2672 HADDX2
X1321 N1823 _NC2673 _NC2674 N1033 DELLN1X2
X1322 Add_105_I18_L07002_C136_carry[2] N1872 Add_105_I18_L07002_C136_carry[3] _NC2675 _NC2676 _NC2677 HADDX2
X1323 N2282 N123 N1090 N879 N2288 _NC2678 _NC2679 AO22X1
X1324 N2128 Add_105_I34_L07002_C136_carry[2] Add_105_I34_L07002_C136_carry[3] _NC2680 _NC2681 _NC2682 HADDX2
X1325 Add_105_I31_L07002_C136_carry[2] N2080 Add_105_I31_L07002_C136_carry[3] _NC2683 _NC2684 _NC2685 HADDX2
X1326 N2192 _NC2686 _NC2687 N1032 DELLN1X2
X1327 N2032 _NC2688 _NC2689 N1031 DELLN1X2
X1328 N1171 N574 N844 N575 N576 N10300 _NC2690 _NC2691 AO221X1
X1329 N10300 N10290 N1637 _NC2692 _NC2693 AND2X1
X1330 N655 Add_90_I24_L07002_C132_carry[2] Add_90_I24_L07002_C132_carry[3] _NC2694 _NC2695 _NC2696 HADDX2
X1331 N689 Add_90_I26_L07002_C132_carry[2] Add_90_I26_L07002_C132_carry[3] _NC2697 _NC2698 _NC2699 HADDX2
X1332 N672 Add_90_I25_L07002_C132_carry[2] Add_90_I25_L07002_C132_carry[3] _NC2700 _NC2701 _NC2702 HADDX2
X1333 N704 _NC2703 _NC2704 N10280 DELLN1X2
X1334 Add_90_I39_L07002_C132_carry[2] N910 Add_90_I39_L07002_C132_carry[3] _NC2705 _NC2706 _NC2707 HADDX2
X1335 N604 Add_90_I21_L07002_C132_carry[2] Add_90_I21_L07002_C132_carry[3] _NC2708 _NC2709 _NC2710 HADDX2
X1336 Add_90_I42_L07002_C132_carry[2] N134 Add_90_I42_L07002_C132_carry[3] _NC2711 _NC2712 _NC2713 HADDX2
X1337 N8900 _NC2714 _NC2715 N10270 INVX0
X1338 N398 Add_90_I9_L07002_C132_carry[0] Add_90_I9_L07002_C132_carry[1] _NC2716 _NC2717 _NC2718 HADDX2
X1339 N896 _NC2719 _NC2720 N10260 INVX0
X1340 N995 _NC2721 _NC2722 N10250 DELLN1X2
X1341 N1006 N231 S_fract_48_i[3] N10250 N1012 _NC2723 _NC2724 AO22X2
X1342 N10230 _NC2725 _NC2726 N10240 INVX0
X1343 N1012 _NC2727 _NC2728 N10230 INVX0
X1344 N961 _NC2729 _NC2730 N10220 DELLN1X2
X1345 Add_105_I45_L07002_C136_carry[3] N2305 N2315 _NC2731 _NC2732 XOR2X1
X1346 N2315 N119 N1062 N234 N10210 _NC2733 _NC2734 AO22X1
X1347 N863 _NC2735 _NC2736 N10200 INVX0
X1348 N365 Add_90_I7_L07002_C132_carry[1] Add_90_I7_L07002_C132_carry[2] _NC2737 _NC2738 _NC2739 HADDX2
X1349 N2193 _NC2740 _NC2741 N1018 DELLN1X2
X1350 N2080 _NC2742 _NC2743 N1016 DELLN1X2
X1351 Add_90_I21_L07002_C132_carry[1] N603 Add_90_I21_L07002_C132_carry[2] _NC2744 _NC2745 _NC2746 HADDX1
X1352 N614 N173 S_fract_48_i[26] N8550 N1015 _NC2747 _NC2748 AO22X1
X1353 N619 _NC2749 _NC2750 N10130 DELLN1X2
X1354 N2047 _NC2751 _NC2752 N10120 DELLN1X2
X1355 N1816 N214 S_fract_48_i[13] N10190 N10110 _NC2753 _NC2754 AO22X1
X1356 N630 N174 S_fract_48_i[25] N10130 N10100 _NC2755 _NC2756 AO22X1
X1357 N631 N174 S_fract_48_i[25] N1015 N10090 _NC2757 _NC2758 AO22X1
X1358 N377 N137 S_fract_48_i[40] N366 N383 _NC2759 _NC2760 AO22X2
X1359 N2043 N172 S_fract_48_i[27] N8350 N10080 _NC2761 _NC2762 AO22X1
X1360 N1706 N226 N1087 N1696 N1712 _NC2763 _NC2764 AO22X2
X1361 N2235 N144 S_fract_48_i[39] N29 N10050 _NC2765 _NC2766 AO22X1
X1362 N687 _NC2767 _NC2768 N10040 DELLN1X2
X1363 N2256 _NC2769 _NC2770 N10030 DELLN1X2
X1364 N2224 _NC2771 _NC2772 N10020 DELLN1X2
X1365 N1832 N212 S_fract_48_i[14] N10110 N1001 _NC2773 _NC2774 AO22X1
X1366 N2097 _NC2775 _NC2776 N1000 DELLN1X2
X1367 N1853 _NC2777 _NC2778 N999 DELLN1X2
X1368 N1947 N196 S_fract_48_i[21] N9780 N998 _NC2779 _NC2780 AO22X1
X1369 N2107 N162 S_fract_48_i[31] N1000 N9960 _NC2781 _NC2782 AO22X1
X1370 N905 N223 S_fract_48_i[9] N140 N9950 _NC2783 _NC2784 AO22X1
X1371 N962 _NC2785 _NC2786 N9940 DELLN1X2
X1372 N1721 N225 S_fract_48_i[7] N239 N9930 _NC2787 _NC2788 AO22X1
X1373 N8720 _NC2789 _NC2790 N9920 INVX0
X1374 N2267 N130 S_fract_48_i[41] N826 N9910 _NC2791 _NC2792 AO22X1
X1375 N364 _NC2793 _NC2794 N9900 DELLN1X2
X1376 N1994 N177 S_fract_48_i[24] N194 N9870 _NC2795 _NC2796 AO22X1
X1377 N738 _NC2797 _NC2798 N9860 DELLN1X2
X1378 N2013 _NC2799 _NC2800 N9850 DELLN1X2
X1379 N1694 _NC2801 _NC2802 N984 DELLN1X2
X1380 N1914 N198 S_fract_48_i[19] N831 N981 _NC2803 _NC2804 AO22X1
X1381 N669 _NC2805 _NC2806 N980 DELLN1X2
X1382 N1773 _NC2807 _NC2808 N9790 DELLN1X2
X1383 N1817 N214 S_fract_48_i[13] N9770 N1823 _NC2809 _NC2810 AO22X1
X1384 N1931 N197 S_fract_48_i[20] N3820 N9780 _NC2811 _NC2812 AO22X1
X1385 N1791 Add_105_I13_L07002_C136_carry[1] Add_105_I13_L07002_C136_carry[2] _NC2813 _NC2814 _NC2815 HADDX1
X1386 N1801 N215 N1072 N8220 N9770 _NC2816 _NC2817 AO22X1
X1387 N665 N182 S_fract_48_i[23] N864 N9750 _NC2818 _NC2819 AO22X1
X1388 N836 N214 S_fract_48_i[13] N3570 N9740 _NC2820 _NC2821 AO22X1
X1389 N656 _NC2822 _NC2823 N9730 DELLN1X2
X1390 N1802 N215 N1072 N933 N9720 _NC2824 _NC2825 AO22X1
X1391 N664 N182 S_fract_48_i[23] N87 N9710 _NC2826 _NC2827 AO22X1
X1392 N1825 _NC2828 _NC2829 N9690 DELLN1X2
X1393 N1981 _NC2830 _NC2831 N9680 DELLN1X2
X1394 N1864 N208 S_fract_48_i[16] N10070 N967 _NC2832 _NC2833 AO22X1
X1395 N399 Add_90_I9_L07002_C132_carry[1] Add_90_I9_L07002_C132_carry[2] _NC2834 _NC2835 _NC2836 HADDX2
X1396 N785 N208 S_fract_48_i[16] N6150 N965 _NC2837 _NC2838 AO22X1
X1397 N2122 N160 S_fract_48_i[32] N9590 N964 _NC2839 _NC2840 AO22X1
X1398 N707 _NC2841 _NC2842 N963 DELLN1X2
X1399 N527 N162 S_fract_48_i[31] N9400 N533 _NC2843 _NC2844 AO22X2
X1400 N784 N208 S_fract_48_i[16] N5960 N9600 _NC2845 _NC2846 AO22X1
X1401 N2112 _NC2847 _NC2848 N9590 DELLN1X2
X1402 N741 _NC2849 _NC2850 N9580 DELLN1X2
X1403 N2127 _NC2851 _NC2852 N9570 DELLN1X2
X1404 N599 N172 S_fract_48_i[27] N9360 N9560 _NC2853 _NC2854 AO22X1
X1405 Add_105_I29_L07002_C136_carry[1] N2047 Add_105_I29_L07002_C136_carry[2] _NC2855 _NC2856 _NC2857 HADDX1
X1406 N2298 N122 S_fract_48_i[43] N220 N2304 _NC2858 _NC2859 AO22X2
X1407 N2304 _NC2860 _NC2861 N9540 DELLN1X2
X1408 N891 _NC2862 _NC2863 N9530 DELLN1X2
X1409 N477 N156 S_fract_48_i[34] N166 N9510 _NC2864 _NC2865 AO22X1
X1410 N467 Add_90_I13_L07002_C132_carry[1] Add_90_I13_L07002_C132_carry[2] _NC2866 _NC2867 _NC2868 HADDX2
X1411 N972 N227 N1081 N10220 N947 _NC2869 _NC2870 AO22X1
X1412 N1999 _NC2871 _NC2872 N946 DELLN1X2
X1413 N2283 N123 N1089 N9910 N945 _NC2873 _NC2874 AO22X1
X1414 N451 Add_90_I12_L07002_C132_carry[2] Add_90_I12_L07002_C132_carry[3] _NC2875 _NC2876 _NC2877 HADDX2
X1415 N462 N154 S_fract_48_i[35] N25 N468 _NC2878 _NC2879 AO22X1
X1416 N461 N154 S_fract_48_i[35] N9410 N467 _NC2880 _NC2881 AO22X1
X1417 N925 _NC2882 _NC2883 N9440 DELLN1X2
X1418 N924 _NC2884 _NC2885 N9430 DELLN1X2
X1419 N516 _NC2886 _NC2887 N9400 DELLN1X2
X1420 N2014 _NC2888 _NC2889 N9390 DELLN1X2
X1421 N2093 _NC2890 _NC2891 N9380 DELLN1X2
X1422 N588 _NC2892 _NC2893 N9360 DELLN1X2
X1423 N1917 _NC2894 _NC2895 N9350 DELLN1X2
X1424 N1918 _NC2896 _NC2897 N9340 DELLN1X2
X1425 N1786 N221 S_fract_48_i[11] N9370 N933 _NC2898 _NC2899 AO22X1
X1426 N2123 N160 S_fract_48_i[32] N9960 N932 _NC2900 _NC2901 AO22X1
X1427 N2040 N172 S_fract_48_i[27] N929 N930 _NC2902 _NC2903 AO22X1
X1428 N2030 _NC2904 _NC2905 N929 DELLN1X2
X1429 N2138 N158 S_fract_48_i[33] N964 N928 _NC2906 _NC2907 AO22X1
X1430 N890 _NC2908 _NC2909 N9270 DELLN1X2
X1431 N1949 _NC2910 _NC2911 N9260 DELLN1X2
X1432 N1950 _NC2912 _NC2913 N9250 DELLN1X2
X1433 N1783 N221 S_fract_48_i[11] N9790 N9230 _NC2914 _NC2915 AO22X1
X1434 N667 N182 S_fract_48_i[23] N9730 N9220 _NC2916 _NC2917 AO22X1
X1435 N1736 N224 S_fract_48_i[8] N814 N9210 _NC2918 _NC2919 AO22X1
X1436 N715 N197 S_fract_48_i[20] N10280 N9190 _NC2920 _NC2921 AO22X1
X1437 N922 N224 S_fract_48_i[8] N9950 N9180 _NC2922 _NC2923 AO22X1
X1438 N1755 N223 S_fract_48_i[9] N191 N917 _NC2924 _NC2925 AO22X1
X1439 N2017 _NC2926 _NC2927 N915 DELLN1X2
X1440 N1983 _NC2928 _NC2929 N914 DELLN1X2
X1441 N6220 N97 N1085 N9940 N623 N996 N913 _NC2930 _NC2931 AOI222X1
X1442 N1041 N624 N625 N1013 N626 N1030 N912 _NC2932 _NC2933 AOI222X2
X1443 N2042 N172 S_fract_48_i[27] N1031 N911 _NC2934 _NC2935 AO22X1
X1444 Add_105_I38_L07002_C136_carry[2] N2192 Add_105_I38_L07002_C136_carry[3] _NC2936 _NC2937 _NC2938 HADDX1
X1445 N2191 _NC2939 _NC2940 N9080 DELLN1X2
X1446 N1982 Add_105_I25_L07002_C136_carry[0] Add_105_I25_L07002_C136_carry[1] _NC2941 _NC2942 _NC2943 HADDX1
X1447 N1992 N177 S_fract_48_i[24] N184 N9070 _NC2944 _NC2945 AO22X1
X1448 N1951 _NC2946 _NC2947 N9060 DELLN1X2
X1449 N1835 N212 S_fract_48_i[14] N9690 N9050 _NC2948 _NC2949 AO22X1
X1450 N1991 N177 S_fract_48_i[24] N9680 N9040 _NC2950 _NC2951 AO22X1
X1451 N1725 _NC2952 _NC2953 N9030 DELLN1X2
X1452 N2075 N170 S_fract_48_i[29] N950 N9020 _NC2954 _NC2955 AO22X1
X1453 N5980 N133 N5990 N963 N6000 N8510 N9010 _NC2956 _NC2957 AOI222X2
X1454 N1321 N9580 N6010 N1320 N6020 N9000 _NC2958 _NC2959 AOI221X1
X1455 N2137 N158 S_fract_48_i[33] N9570 N899 _NC2960 _NC2961 AO22X1
X1456 N1850 N210 S_fract_48_i[15] N9890 N898 _NC2962 _NC2963 AO22X1
X1457 N2009 N174 S_fract_48_i[25] N946 N897 _NC2964 _NC2965 AO22X1
X1458 N1793 _NC2966 _NC2967 N895 DELLN1X2
X1459 N482 _NC2968 _NC2969 N894 DELLN1X2
X1460 N2095 _NC2970 _NC2971 N8930 DELLN1X2
X1461 N622 _NC2972 _NC2973 N8920 DELLN1X2
X1462 N1912 N198 S_fract_48_i[19] N591 N1918 _NC2974 _NC2975 AO22X1
X1463 N2171 N154 S_fract_48_i[35] N353 N8910 _NC2976 _NC2977 AO22X1
X1464 N977 _NC2978 _NC2979 N8890 DELLN1X2
X1465 N2176 _NC2980 _NC2981 N8880 DELLN1X2
X1466 N2126 _NC2982 _NC2983 N8860 DELLN1X2
X1467 N2199 N146 S_fract_48_i[37] N2189 N2205 _NC2984 _NC2985 AO22X2
X1468 N2205 _NC2986 _NC2987 N8850 DELLN1X2
X1469 N425 N146 S_fract_48_i[37] N414 N431 _NC2988 _NC2989 AO22X2
X1470 N431 _NC2990 _NC2991 N8840 DELLN1X2
X1471 N2125 _NC2992 _NC2993 N8830 DELLN1X2
X1472 N494 N158 S_fract_48_i[33] N9510 N882 _NC2994 _NC2995 AO22X1
X1473 Add_105_I27_L07002_C136_carry[1] N2015 Add_105_I27_L07002_C136_carry[2] _NC2996 _NC2997 _NC2998 HADDX1
X1474 N750 N204 N1075 N155 N880 _NC2999 _NC3000 AO22X1
X1475 Add_105_I42_L07002_C136_carry[2] N2256 Add_105_I42_L07002_C136_carry[3] _NC3001 _NC3002 _NC3003 HADDX1
X1476 N1803 N215 N1071 N895 N877 _NC3004 _NC3005 AO22X1
X1477 N2206 _NC3006 _NC3007 N8760 DELLN1X2
X1478 N1788 N1789 Add_105_I13_L07002_C136_carry[0] _NC3008 _NC3009 _NC3010 HADDX2
X1479 N1799 N215 N1071 N9230 N8740 _NC3011 _NC3012 AO22X1
X1480 N749 N204 N1074 N9860 N8730 _NC3013 _NC3014 AO22X1
X1481 N1880 N206 S_fract_48_i[17] N967 N8710 _NC3015 _NC3016 AO22X1
X1482 N435 _NC3017 _NC3018 N8700 DELLN1X2
X1483 N493 N158 S_fract_48_i[33] N894 N8680 _NC3019 _NC3020 AO22X1
X1484 N852 N215 N1071 N916 N8670 _NC3021 _NC3022 AO22X1
X1485 N2010 N174 S_fract_48_i[25] N9870 N8660 _NC3023 _NC3024 AO22X1
X1486 N503 _NC3025 _NC3026 N865 DELLN1X2
X1487 N733 N198 S_fract_48_i[19] N9700 N739 _NC3027 _NC3028 AO22X1
X1488 N349 Add_90_I6_L07002_C132_carry[3] N360 _NC3029 _NC3030 _NC3031 HADDX2
X1489 N637 Add_90_I23_L07002_C132_carry[1] Add_90_I23_L07002_C132_carry[2] _NC3032 _NC3033 _NC3034 HADDX2
X1490 N648 N177 S_fract_48_i[24] N10090 N864 _NC3035 _NC3036 AO22X1
X1491 N514 N160 S_fract_48_i[32] N865 N862 _NC3037 _NC3038 AO22X1
X1492 N1728 Add_105_I9_L07002_C136_carry[2] Add_105_I9_L07002_C136_carry[3] _NC3039 _NC3040 _NC3041 HADDX1
X1493 N2124 N2125 Add_105_I34_L07002_C136_carry[0] _NC3042 _NC3043 _NC3044 HADDX2
X1494 N2135 N158 S_fract_48_i[33] N8830 N2141 _NC3045 _NC3046 AO22X2
X1495 N602 _NC3047 _NC3048 N8580 DELLN1X2
X1496 N2239 _NC3049 _NC3050 N8570 DELLN1X2
X1497 N2105 N162 S_fract_48_i[31] N8930 N8560 _NC3051 _NC3052 AO22X1
X1498 N586 Add_90_I20_L07002_C132_carry[1] Add_90_I20_L07002_C132_carry[2] _NC3053 _NC3054 _NC3055 HADDX2
X1499 N597 N172 S_fract_48_i[27] N9880 N8550 _NC3056 _NC3057 AO22X1
X1500 N1752 N223 S_fract_48_i[9] N9210 N8540 _NC3058 _NC3059 AO22X1
X1501 N1837 _NC3060 _NC3061 N8530 DELLN1X2
X1502 N684 N189 S_fract_48_i[22] N9220 N8510 _NC3062 _NC3063 AO22X1
X1503 N2320 _NC3064 _NC3065 N8500 DELLN1X2
X1504 N680 N189 S_fract_48_i[22] N980 N8490 _NC3066 _NC3067 AO22X1
X1505 N357 N130 S_fract_48_i[41] N107 N363 _NC3068 _NC3069 AO22X2
X1506 N2090 N164 N1078 N1016 N848 _NC3070 _NC3071 AO22X1
X1507 N1665 _NC3072 _NC3073 N847 DELLN1X2
X1508 N601 _NC3074 _NC3075 N846 DELLN1X2
X1509 N535 Add_90_I17_L07002_C132_carry[1] Add_90_I17_L07002_C132_carry[2] _NC3076 _NC3077 _NC3078 HADDX2
X1510 N1753 N223 S_fract_48_i[9] N9200 N845 _NC3079 _NC3080 AO22X1
X1511 N412 N145 S_fract_48_i[38] N401 N844 _NC3081 _NC3082 AO22X1
X1512 N1712 Add_105_I8_L07002_C136_carry[2] Add_105_I8_L07002_C136_carry[3] _NC3083 _NC3084 _NC3085 HADDX1
X1513 N2237 _NC3086 _NC3087 N843 DELLN1X2
X1514 N544 N164 N1078 N9610 N8420 _NC3088 _NC3089 AO22X1
X1515 N2238 _NC3090 _NC3091 N8410 DELLN1X2
X1516 N1901 _NC3092 _NC3093 N8400 DELLN1X2
X1517 N2078 _NC3094 _NC3095 N8390 DELLN1X2
X1518 N568 _NC3096 _NC3097 N8380 DELLN1X2
X1519 N1744 Add_105_I10_L07002_C136_carry[2] Add_105_I10_L07002_C136_carry[3] _NC3098 _NC3099 _NC3100 HADDX1
X1520 N1693 _NC3101 _NC3102 N8360 DELLN1X2
X1521 N415 Add_90_I10_L07002_C132_carry[0] Add_90_I10_L07002_C132_carry[1] _NC3103 _NC3104 _NC3105 HADDX2
X1522 N426 N146 S_fract_48_i[37] N983 N8340 _NC3106 _NC3107 AO22X1
X1523 N366 Add_90_I7_L07002_C132_carry[2] N378 _NC3108 _NC3109 _NC3110 HADDX2
X1524 N397 _NC3111 _NC3112 N8330 DELLN1X2
X1525 N2153 N156 S_fract_48_i[34] N899 N8320 _NC3113 _NC3114 AO22X1
X1526 N1898 N204 N1074 N9090 N831 _NC3115 _NC3116 AO22X1
X1527 N427 N146 S_fract_48_i[37] N966 N830 _NC3117 _NC3118 AO22X1
X1528 N417 Add_90_I10_L07002_C132_carry[2] Add_90_I10_L07002_C132_carry[3] _NC3119 _NC3120 _NC3121 HADDX2
X1529 N428 N146 S_fract_48_i[37] N9520 N828 _NC3122 _NC3123 AO22X1
X1530 Add_105_I23_L07002_C136_carry[0] N52 Add_105_I23_L07002_C136_carry[1] _NC3124 _NC3125 _NC3126 HADDX2
X1531 Add_90_I19_L07002_C132_carry[0] N568 Add_90_I19_L07002_C132_carry[1] _NC3127 _NC3128 _NC3129 HADDX2
X1532 N671 Add_90_I25_L07002_C132_carry[1] Add_90_I25_L07002_C132_carry[2] _NC3130 _NC3131 _NC3132 HADDX2
X1533 N666 N182 S_fract_48_i[23] N5 N982 _NC3133 _NC3134 AO22X1
X1534 N1959 N189 S_fract_48_i[22] N9260 N8210 _NC3135 _NC3136 AO22X1
X1535 N561 N170 S_fract_48_i[29] N8420 N8180 _NC3137 _NC3138 AO22X1
X1536 N1946 N196 S_fract_48_i[21] N9760 N8170 _NC3139 _NC3140 AO22X1
X1537 N2234 N144 S_fract_48_i[39] N10020 N8150 _NC3141 _NC3142 AO22X1
X1538 N1690 N227 N1696 _NC3143 _NC3144 AND2X4
X1539 N469 _NC3145 _NC3146 N813 DELLN1X2
X1540 N688 Add_90_I26_L07002_C132_carry[1] Add_90_I26_L07002_C132_carry[2] _NC3147 _NC3148 _NC3149 HADDX2
X1541 N699 N196 S_fract_48_i[21] N8240 N812 _NC3150 _NC3151 AO22X1
X1542 N1899 N204 N1074 N8750 N811 _NC3152 _NC3153 AO22X1
X1543 N700 N196 S_fract_48_i[21] N8230 N810 _NC3154 _NC3155 AO22X1
X1544 N1757 _NC3156 _NC3157 N8080 DELLN1X2
X1545 N902 N223 S_fract_48_i[9] N9530 N8070 _NC3158 _NC3159 AO22X1
X1546 N903 N223 S_fract_48_i[9] N180 N8060 _NC3160 _NC3161 AO22X1
X1547 N534 _NC3162 _NC3163 N8050 DELLN1X2
X1548 N164 N2091 N1077 N9020 N2097 _NC3164 _NC3165 AO22X1
X1549 N921 N224 S_fract_48_i[8] N10270 N997 _NC3166 _NC3167 AO22X1
X1550 N531 N162 S_fract_48_i[31] N862 N6340 _NC3168 _NC3169 AO22X1
X1551 N2312 N119 N1062 N45 N6330 _NC3170 _NC3171 AO22X1
X1552 N2303 Add_105_I45_L07002_C136_carry[1] Add_105_I45_L07002_C136_carry[2] _NC3172 _NC3173 _NC3174 HADDX1
X1553 N2313 N119 N1062 N44 N6210 _NC3175 _NC3176 AO22X1
X1554 N2286 _NC3177 _NC3178 N6200 DELLN1X2
X1555 N751 N204 N1074 N17 N931 _NC3179 _NC3180 AO22X1
X1556 N757 Add_90_I30_L07002_C132_carry[2] Add_90_I30_L07002_C132_carry[3] _NC3181 _NC3182 _NC3183 HADDX2
X1557 N837 N214 S_fract_48_i[13] N111 N5970 _NC3184 _NC3185 AO22X1
X1558 Add_105_I23_L07002_C136_carry[1] N1951 Add_105_I23_L07002_C136_carry[2] _NC3186 _NC3187 _NC3188 HADDX1
X1559 Add_105_I19_L07002_C136_carry[0] N1886 Add_105_I19_L07002_C136_carry[1] _NC3189 _NC3190 _NC3191 HADDX2
X1560 N1896 N204 N1074 N8710 N1902 _NC3192 _NC3193 AO22X1
X1561 N1896 N204 N1074 N8710 N591 _NC3194 _NC3195 AO22X1
X1562 N1851 N210 S_fract_48_i[15] N9050 N5790 _NC3196 _NC3197 AO22X1
X1563 N383 Add_90_I8_L07002_C132_carry[2] Add_90_I8_L07002_C132_carry[3] _NC3198 _NC3199 _NC3200 HADDX2
X1564 Add_90_I33_L07002_C132_carry[0] N806 Add_90_I33_L07002_C132_carry[1] _NC3201 _NC3202 _NC3203 HADDX2
X1565 N766 N206 S_fract_48_i[17] N8730 N4130 _NC3204 _NC3205 AO22X1
X1566 N382 Add_90_I8_L07002_C132_carry[1] Add_90_I8_L07002_C132_carry[2] _NC3206 _NC3207 _NC3208 HADDX2
X1567 N381 Add_90_I8_L07002_C132_carry[0] Add_90_I8_L07002_C132_carry[1] _NC3209 _NC3210 _NC3211 HADDX1
X1568 N430 N431 Add_90_I11_L07002_C132_carry[0] _NC3212 _NC3213 _NC3214 HADDX2
X1569 N2077 _NC3215 _NC3216 N3810 DELLN1X2
X1570 Add_90_I35_L07002_C132_carry[2] N842 Add_90_I35_L07002_C132_carry[3] _NC3217 _NC3218 _NC3219 HADDX2
X1571 N2058 N171 S_fract_48_i[28] N911 N3740 _NC3220 _NC3221 AO22X1
X1572 N2285 _NC3222 _NC3223 N3730 DELLN1X2
X1573 N808 Add_90_I33_L07002_C132_carry[2] Add_90_I33_L07002_C132_carry[3] _NC3224 _NC3225 _NC3226 HADDX2
X1574 N786 N208 S_fract_48_i[16] N105 N3560 _NC3227 _NC3228 AO22X1
X1575 N2144 Add_105_I35_L07002_C136_carry[2] Add_105_I35_L07002_C136_carry[3] _NC3229 _NC3230 _NC3231 HADDX1
X1576 Add_105_I47_L07002_C136_carry[3] N2337 N2347 _NC3232 _NC3233 XOR2X1
X1577 N2347 N69 N1064 N67 N330 _NC3234 _NC3235 AO22X1
X1578 N2317 _NC3236 _NC3237 N329 DELLN1X2
X1579 N649 N177 N1146 N1014 N655 _NC3238 _NC3239 AO22X1
X1580 N2151 N156 S_fract_48_i[34] N8590 N314 _NC3240 _NC3241 AO22X1
X1581 N7500 N146 N7510 _NC3242 _NC3243 NAND2X0
X1582 N34 N5800 N245 _NC3244 _NC3245 AND2X1
X1583 N240 N241 N242 N243 N7510 N245 N576 _NC3246 _NC3247 OAI222X1
X1584 N93 N226 N1088 N13 N239 _NC3248 _NC3249 AO22X1
X1585 N2152 N156 S_fract_48_i[34] N860 N237 _NC3250 _NC3251 AO22X1
X1586 N791 Add_90_I32_L07002_C132_carry[2] Add_90_I32_L07002_C132_carry[3] _NC3252 _NC3253 _NC3254 HADDX2
X1587 N2073 N170 S_fract_48_i[29] N9550 N228 _NC3255 _NC3256 AO22X1
X1588 Add_105_I46_L07002_C136_carry[3] N2321 N2331 _NC3257 _NC3258 XOR2X1
X1589 N2282 N123 N1090 N879 N220 _NC3259 _NC3260 AO22X1
X1590 N401 _NC3261 _NC3262 N241 INVX0
X1591 Add_90_I9_L07002_C132_carry[3] N401 N412 _NC3263 _NC3264 XOR2X2
X1592 N818 N212 S_fract_48_i[14] N219 N824 _NC3265 _NC3266 AO22X1
X1593 N801 N210 S_fract_48_i[15] N9600 N219 _NC3267 _NC3268 AO22X1
X1594 N805 _NC3269 _NC3270 N218 DELLN1X2
X1595 N869 N221 S_fract_48_i[11] N8670 N217 _NC3271 _NC3272 AO22X1
X1596 N1885 _NC3273 _NC3274 N216 DELLN1X2
X1597 N806 _NC3275 _NC3276 N213 DELLN1X2
X1598 Add_90_I33_L07002_C132_carry[1] N807 Add_90_I33_L07002_C132_carry[2] _NC3277 _NC3278 _NC3279 HADDX1
X1599 N870 N221 S_fract_48_i[11] N22 N8160 _NC3280 _NC3281 AO22X1
X1600 Add_105_I19_L07002_C136_carry[1] N1887 Add_105_I19_L07002_C136_carry[2] _NC3282 _NC3283 _NC3284 HADDX1
X1601 N1897 N204 N1075 N8200 N209 _NC3285 _NC3286 AO22X1
X1602 N752 N204 N1075 N9580 N207 _NC3287 _NC3288 AO22X1
X1603 N2056 N171 S_fract_48_i[28] N930 N205 _NC3289 _NC3290 AO22X1
X1604 N1857 Add_105_I17_L07002_C136_carry[3] N1867 _NC3291 _NC3292 XOR2X2
X1605 Add_105_I20_L07002_C136_carry[1] N1903 Add_105_I20_L07002_C136_carry[2] _NC3293 _NC3294 _NC3295 HADDX1
X1606 N1913 N198 S_fract_48_i[19] N209 N202 _NC3296 _NC3297 AO22X1
X1607 Add_105_I21_L07002_C136_carry[0] N1918 Add_105_I21_L07002_C136_carry[1] _NC3298 _NC3299 _NC3300 HADDX2
X1608 N754 _NC3301 _NC3302 N200 DELLN1X2
X1609 N2061 _NC3303 _NC3304 N199 DELLN1X2
X1610 N1979 N182 S_fract_48_i[23] N9620 N195 _NC3305 _NC3306 AO22X1
X1611 N485 Add_90_I14_L07002_C132_carry[2] Add_90_I14_L07002_C132_carry[3] _NC3307 _NC3308 _NC3309 HADDX2
X1612 Add_105_I24_L07002_C136_carry[2] N1968 Add_105_I24_L07002_C136_carry[3] _NC3310 _NC3311 _NC3312 HADDX1
X1613 N1978 N182 S_fract_48_i[23] N878 N194 _NC3313 _NC3314 AO22X1
X1614 N1724 N81 Add_105_I9_L07002_C136_carry[0] _NC3315 _NC3316 _NC3317 HADDX2
X1615 N1735 N224 S_fract_48_i[8] N9030 N1741 _NC3318 _NC3319 AO22X2
X1616 N334 Add_90_I5_L07002_C132_carry[2] N344 _NC3320 _NC3321 _NC3322 HADDX2
X1617 N343 N123 N1089 N334 N192 _NC3323 _NC3324 AO22X1
X1618 N1745 _NC3325 _NC3326 N191 DELLN1X2
X1619 N1824 Add_105_I15_L07002_C136_carry[2] Add_105_I15_L07002_C136_carry[3] _NC3327 _NC3328 _NC3329 HADDX2
X1620 Add_105_I35_L07002_C136_carry[3] N2145 N2155 _NC3330 _NC3331 XOR2X1
X1621 N2012 N2013 Add_105_I27_L07002_C136_carry[0] _NC3332 _NC3333 _NC3334 HADDX2
X1622 N2023 N173 S_fract_48_i[26] N9850 N2029 _NC3335 _NC3336 AO22X2
X1623 N954 N226 N1087 N86 N188 _NC3337 _NC3338 AO22X1
X1624 N874 _NC3339 _NC3340 N187 DELLN1X2
X1625 N854 N215 N1072 N5970 N186 _NC3341 _NC3342 AO22X1
X1626 N901 N223 S_fract_48_i[9] N9270 N185 _NC3343 _NC3344 AO22X1
X1627 N1898 N204 N1074 N9090 N1904 _NC3345 _NC3346 AO22X1
X1628 Add_105_I20_L07002_C136_carry[2] N1904 Add_105_I20_L07002_C136_carry[3] _NC3347 _NC3348 _NC3349 HADDX2
X1629 Add_105_I24_L07002_C136_carry[0] N1966 Add_105_I24_L07002_C136_carry[1] _NC3350 _NC3351 _NC3352 HADDX1
X1630 N1976 N182 S_fract_48_i[23] N827 N184 _NC3353 _NC3354 AO22X1
X1631 N1679 Add_105_I6_L07002_C136_carry[2] Add_105_I6_L07002_C136_carry[3] _NC3355 _NC3356 _NC3357 HADDX1
X1632 N1688 N227 N1084 N1034 N183 _NC3358 _NC3359 AO22X1
X1633 N783 N208 S_fract_48_i[16] N4130 N181 _NC3360 _NC3361 AO22X1
X1634 N751 N204 N1074 N17 N757 _NC3362 _NC3363 AO22X1
X1635 Add_90_I29_L07002_C132_carry[2] N740 Add_90_I29_L07002_C132_carry[3] _NC3364 _NC3365 _NC3366 HADDX2
X1636 N2092 N2093 Add_105_I32_L07002_C136_carry[0] _NC3367 _NC3368 _NC3369 HADDX2
X1637 N2103 N162 S_fract_48_i[31] N9380 N2109 _NC3370 _NC3371 AO22X2
X1638 N2203 N146 S_fract_48_i[37] N1018 N178 _NC3372 _NC3373 AOI22X1
X1639 Add_105_I39_L07002_C136_carry[3] N178 N2219 _NC3374 _NC3375 XNOR2X1
X1640 N175 _NC3376 _NC3377 N176 INVX0
X1641 N118 _NC3378 _NC3379 N175 INVX0
X1642 N1863 N208 S_fract_48_i[16] N999 N169 _NC3380 _NC3381 AO22X1
X1643 N1929 N197 S_fract_48_i[20] N202 N168 _NC3382 _NC3383 AO22X1
X1644 N1692 N1693 Add_105_I7_L07002_C136_carry[0] _NC3384 _NC3385 _NC3386 HADDX2
X1645 N1703 N226 N1086 N8360 N167 _NC3387 _NC3388 AO22X1
X1646 N434 Add_90_I11_L07002_C132_carry[2] Add_90_I11_L07002_C132_carry[3] _NC3389 _NC3390 _NC3391 HADDX2
X1647 N570 Add_90_I19_L07002_C132_carry[2] Add_90_I19_L07002_C132_carry[3] _NC3392 _NC3393 _NC3394 HADDX2
X1648 N449 Add_90_I12_L07002_C132_carry[0] Add_90_I12_L07002_C132_carry[1] _NC3395 _NC3396 _NC3397 HADDX2
X1649 N460 N154 S_fract_48_i[35] N9420 N166 _NC3398 _NC3399 AO22X1
X1650 N502 Add_90_I15_L07002_C132_carry[2] Add_90_I15_L07002_C132_carry[3] _NC3400 _NC3401 _NC3402 HADDX2
X1651 N1705 N226 N1088 N13 N1711 _NC3403 _NC3404 AO22X1
X1652 N468 Add_90_I13_L07002_C132_carry[2] Add_90_I13_L07002_C132_carry[3] _NC3405 _NC3406 _NC3407 HADDX2
X1653 N1689 N227 N1680 N1082 N1695 _NC3408 _NC3409 AO22X1
X1654 Add_105_I9_L07002_C136_carry[0] N1726 Add_105_I9_L07002_C136_carry[1] _NC3410 _NC3411 _NC3412 HADDX2
X1655 N706 Add_90_I27_L07002_C132_carry[2] Add_90_I27_L07002_C132_carry[3] _NC3413 _NC3414 _NC3415 HADDX2
X1656 N1711 Add_105_I8_L07002_C136_carry[1] Add_105_I8_L07002_C136_carry[2] _NC3416 _NC3417 _NC3418 HADDX2
X1657 N2219 _NC3419 _NC3420 N165 DELLN1X2
X1658 N587 Add_90_I20_L07002_C132_carry[2] Add_90_I20_L07002_C132_carry[3] _NC3421 _NC3422 _NC3423 HADDX2
X1659 N774 Add_90_I31_L07002_C132_carry[2] Add_90_I31_L07002_C132_carry[3] _NC3424 _NC3425 _NC3426 HADDX2
X1660 N536 Add_90_I17_L07002_C132_carry[2] Add_90_I17_L07002_C132_carry[3] _NC3427 _NC3428 _NC3429 HADDX2
X1661 N547 N164 N1077 N24 N553 _NC3430 _NC3431 AO22X1
X1662 N720 _NC3432 _NC3433 N163 DELLN1X2
X1663 N433 Add_90_I11_L07002_C132_carry[1] Add_90_I11_L07002_C132_carry[2] _NC3434 _NC3435 _NC3436 HADDX2
X1664 N519 Add_90_I16_L07002_C132_carry[2] Add_90_I16_L07002_C132_carry[3] _NC3437 _NC3438 _NC3439 HADDX2
X1665 N2168 N154 S_fract_48_i[35] N237 N159 _NC3440 _NC3441 AO22X1
X1666 N450 Add_90_I12_L07002_C132_carry[1] Add_90_I12_L07002_C132_carry[2] _NC3442 _NC3443 _NC3444 HADDX1
X1667 N461 N154 S_fract_48_i[35] N9410 N157 _NC3445 _NC3446 AO22X1
X1668 Add_105_I19_L07002_C136_carry[3] N1889 N1899 _NC3447 _NC3448 XOR2X1
X1669 N739 Add_90_I29_L07002_C132_carry[1] Add_90_I29_L07002_C132_carry[2] _NC3449 _NC3450 _NC3451 HADDX2
X1670 N722 Add_90_I28_L07002_C132_carry[1] Add_90_I28_L07002_C132_carry[2] _NC3452 _NC3453 _NC3454 HADDX2
X1671 N733 N198 S_fract_48_i[19] N9700 N155 _NC3455 _NC3456 AO22X1
X1672 N621 Add_90_I22_L07002_C132_carry[2] Add_90_I22_L07002_C132_carry[3] _NC3457 _NC3458 _NC3459 HADDX2
X1673 Add_90_I17_L07002_C132_carry[0] N534 Add_90_I17_L07002_C132_carry[1] _NC3460 _NC3461 _NC3462 HADDX2
X1674 N545 N164 N1077 N8050 N153 _NC3463 _NC3464 AO22X1
X1675 N2219 N145 S_fract_48_i[38] N861 N151 _NC3465 _NC3466 AOI22X1
X1676 Add_105_I40_L07002_C136_carry[3] N151 N2235 _NC3467 _NC3468 XNOR2X1
X1677 N731 N198 S_fract_48_i[19] N163 N150 _NC3469 _NC3470 AO22X1
X1678 N1823 Add_105_I15_L07002_C136_carry[1] Add_105_I15_L07002_C136_carry[2] _NC3471 _NC3472 _NC3473 HADDX1
X1679 N480 N156 S_fract_48_i[34] N813 N148 _NC3474 _NC3475 AO22X1
X1680 N578 N171 S_fract_48_i[28] N8180 N143 _NC3476 _NC3477 AO22X1
X1681 N2346 N69 N1064 N136 N141 _NC3478 _NC3479 AO22X2
X1682 N871 N221 S_fract_48_i[11] N186 N147 _NC3480 _NC3481 AO22X1
X1683 N801 N210 S_fract_48_i[15] N9600 N139 _NC3482 _NC3483 AO22X1
X1684 N2251 N137 S_fract_48_i[40] N10050 N138 _NC3484 _NC3485 AOI22X1
X1685 Add_105_I42_L07002_C136_carry[3] N138 N2267 _NC3486 _NC3487 XNOR2X1
X1686 N2330 N176 S_fract_48_i[45] N8500 N2336 _NC3488 _NC3489 AO22X1
X1687 Add_90_I38_L07002_C132_carry[2] N893 Add_90_I38_L07002_C132_carry[3] _NC3490 _NC3491 _NC3492 HADDX2
X1688 N2091 N164 N1077 N9020 N135 _NC3493 _NC3494 AOI22X1
X1689 Add_105_I32_L07002_C136_carry[3] N135 N2107 _NC3495 _NC3496 XNOR2X1
X1690 N955 N226 N1085 N8040 N134 _NC3497 _NC3498 AO22X1
X1691 N718 N197 S_fract_48_i[20] N963 N133 _NC3499 _NC3500 AO22X1
X1692 N1011 _NC3501 _NC3502 N132 DELLN1X2
X1693 Add_105_I41_L07002_C136_carry[1] N2239 Add_105_I41_L07002_C136_carry[2] _NC3503 _NC3504 _NC3505 HADDX2
X1694 N2267 N130 S_fract_48_i[41] N826 N129 _NC3506 _NC3507 AOI22X1
X1695 Add_105_I43_L07002_C136_carry[3] N129 N2283 _NC3508 _NC3509 XNOR2X1
X1696 N2104 N162 S_fract_48_i[31] N49 N128 _NC3510 _NC3511 AO22X1
X1697 N118 S_fract_48_i[46] N745 _NC3512 _NC3513 XNOR2X1
X1698 N745 N1061 N127 _NC3514 _NC3515 XNOR2X2
X1699 N2167 N154 S_fract_48_i[35] N314 N126 _NC3516 _NC3517 AO22X1
X1700 N1899 N204 N1074 N8750 N125 _NC3518 _NC3519 AOI22X1
X1701 N125 Add_105_I20_L07002_C136_carry[3] N1915 _NC3520 _NC3521 XNOR2X1
X1702 N1947 N196 S_fract_48_i[21] N9780 N124 _NC3522 _NC3523 AOI22X1
X1703 N124 Add_105_I23_L07002_C136_carry[3] N1963 _NC3524 _NC3525 XNOR2X1
X1704 N8010 N8020 N334 _NC3526 _NC3527 AND2X4
X1705 N332 N333 Add_90_I5_L07002_C132_carry[2] _NC3528 _NC3529 _NC3530 HADDX2
X1706 N2043 N172 S_fract_48_i[27] N8350 N121 _NC3531 _NC3532 AOI22X1
X1707 N121 Add_105_I29_L07002_C136_carry[3] N2059 _NC3533 _NC3534 XNOR2X1
X1708 N459 N154 S_fract_48_i[35] N4000 N120 _NC3535 _NC3536 AO22X1
X1709 N638 Add_90_I23_L07002_C132_carry[2] Add_90_I23_L07002_C132_carry[3] _NC3537 _NC3538 _NC3539 HADDX2
X1710 N553 Add_90_I18_L07002_C132_carry[2] Add_90_I18_L07002_C132_carry[3] _NC3540 _NC3541 _NC3542 HADDX2
X1711 N8020 N1053 N333 _NC3543 _NC3544 XOR2X2
X1712 N2123 N160 S_fract_48_i[32] N9960 N116 _NC3545 _NC3546 AOI22X1
X1713 Add_105_I34_L07002_C136_carry[3] N116 N2139 _NC3547 _NC3548 XNOR2X1
X1714 N1927 N197 S_fract_48_i[20] N9350 N115 _NC3549 _NC3550 AO22X1
X1715 N2281 N123 N1091 N85 N114 _NC3551 _NC3552 AO22X1
X1716 N2217 N145 S_fract_48_i[38] N8870 N112 _NC3553 _NC3554 AO22X1
X1717 N803 N210 S_fract_48_i[15] N3560 N113 _NC3555 _NC3556 AO22X1
X1718 N840 _NC3557 _NC3558 N110 DELLN1X2
X1719 N2187 N152 S_fract_48_i[36] N8910 N572 _NC3559 _NC3560 AO22X1
X1720 N2283 N123 N1089 N9910 N108 _NC3561 _NC3562 AOI22X1
X1721 Add_105_I44_L07002_C136_carry[3] N108 N2299 _NC3563 _NC3564 XNOR2X1
X1722 N342 N123 N1089 N117 N347 _NC3565 _NC3566 AO22X1
X1723 N342 N123 N1089 N117 N107 _NC3567 _NC3568 AO22X1
X1724 N2075 N170 S_fract_48_i[29] N950 N106 _NC3569 _NC3570 AOI22X1
X1725 Add_105_I31_L07002_C136_carry[3] N106 N2091 _NC3571 _NC3572 XNOR2X1
X1726 Add_90_I7_L07002_C132_carry[0] N101 Add_90_I7_L07002_C132_carry[1] _NC3573 _NC3574 _NC3575 HADDX2
X1727 N2169 N154 S_fract_48_i[35] N8320 N104 _NC3576 _NC3577 AO22X1
X1728 N478 N156 S_fract_48_i[34] N157 N948 _NC3578 _NC3579 AO22X1
X1729 N484 Add_90_I14_L07002_C132_carry[1] Add_90_I14_L07002_C132_carry[2] _NC3580 _NC3581 _NC3582 HADDX2
X1730 N346 N347 Add_90_I6_L07002_C132_carry[2] _NC3583 _NC3584 _NC3585 HADDX1
X1731 N2235 N144 S_fract_48_i[39] N8520 N99 _NC3586 _NC3587 AOI22X1
X1732 Add_105_I41_L07002_C136_carry[3] N99 N2251 _NC3588 _NC3589 XNOR2X1
X1733 N973 N227 N1084 N9940 N97 _NC3590 _NC3591 AO22X1
X1734 N96 Add_105_I18_L07002_C136_carry[3] N1883 _NC3592 _NC3593 XNOR2X1
X1735 Add_105_I11_L07002_C136_carry[2] N1760 Add_105_I11_L07002_C136_carry[3] _NC3594 _NC3595 _NC3596 HADDX2
X1736 N91 N222 S_fract_48_i[10] N8370 N9370 _NC3597 _NC3598 AO22X1
X1737 N1770 N222 S_fract_48_i[10] N8370 N1776 _NC3599 _NC3600 AO22X1
X1738 N2204 N2205 Add_105_I39_L07002_C136_carry[0] _NC3601 _NC3602 _NC3603 HADDX2
X1739 N2215 N145 S_fract_48_i[38] N8850 N2221 _NC3604 _NC3605 AO22X2
X1740 N788 _NC3606 _NC3607 N94 DELLN1X2
X1741 Add_105_I11_L07002_C136_carry[1] N1759 Add_105_I11_L07002_C136_carry[2] _NC3608 _NC3609 _NC3610 HADDX2
X1742 N837 N214 S_fract_48_i[13] N111 N92 _NC3611 _NC3612 AOI22X1
X1743 Add_90_I35_L07002_C132_carry[3] N92 N854 _NC3613 _NC3614 XNOR2X1
X1744 N1866 N208 S_fract_48_i[16] N898 N6180 _NC3615 _NC3616 AO22X1
X1745 N1866 N208 S_fract_48_i[16] N898 N1872 _NC3617 _NC3618 AO22X1
X1746 N1740 N1741 Add_105_I10_L07002_C136_carry[0] _NC3619 _NC3620 _NC3621 HADDX2
X1747 N1751 N223 S_fract_48_i[9] N193 N90 _NC3622 _NC3623 AO22X2
X1748 N942 _NC3624 _NC3625 N89 DELLN1X2
X1749 N956 N226 N1085 N142 N88 _NC3626 _NC3627 AOI22X1
X1750 Add_90_I42_L07002_C132_carry[3] N88 N973 _NC3628 _NC3629 XNOR2X1
X1751 N636 Add_90_I23_L07002_C132_carry[0] Add_90_I23_L07002_C132_carry[1] _NC3630 _NC3631 _NC3632 HADDX2
X1752 N647 N177 N1146 N10100 N87 _NC3633 _NC3634 AO22X1
X1753 N2249 N137 S_fract_48_i[40] N8570 N131 _NC3635 _NC3636 AO22X1
X1754 N888 N222 S_fract_48_i[10] N147 N84 _NC3637 _NC3638 AOI22X1
X1755 Add_90_I38_L07002_C132_carry[3] N84 N905 _NC3639 _NC3640 XNOR2X1
X1756 N935 N225 S_fract_48_i[7] N9430 N83 _NC3641 _NC3642 AO22X1
X1757 Add_105_I26_L07002_C136_carry[0] N1998 Add_105_I26_L07002_C136_carry[1] _NC3643 _NC3644 _NC3645 HADDX2
X1758 N1708 N1709 Add_105_I8_L07002_C136_carry[0] _NC3646 _NC3647 _NC3648 HADDX2
X1759 N1719 N225 S_fract_48_i[7] N167 N81 _NC3649 _NC3650 AO22X2
X1760 N938 N225 S_fract_48_i[7] N997 N944 _NC3651 _NC3652 AO22X1
X1761 Add_90_I39_L07002_C132_carry[1] N909 Add_90_I39_L07002_C132_carry[2] _NC3653 _NC3654 _NC3655 HADDX1
X1762 N1771 N222 S_fract_48_i[10] N917 N79 _NC3656 _NC3657 AO22X1
X1763 N1867 N208 S_fract_48_i[16] N5790 N96 _NC3658 _NC3659 AOI22X1
X1764 N1867 N208 S_fract_48_i[16] N5790 N203 _NC3660 _NC3661 AO22X1
X1765 N854 N215 N1072 N5970 N78 _NC3662 _NC3663 AOI22X1
X1766 Add_90_I36_L07002_C132_carry[3] N78 N871 _NC3664 _NC3665 XNOR2X1
X1767 Add_90_I37_L07002_C132_carry[2] N876 Add_90_I37_L07002_C132_carry[3] _NC3666 _NC3667 _NC3668 HADDX1
X1768 N1832 N212 S_fract_48_i[14] N10110 N77 _NC3669 _NC3670 AO22X1
X1769 Add_90_I41_L07002_C132_carry[0] N942 Add_90_I41_L07002_C132_carry[1] _NC3671 _NC3672 _NC3673 HADDX2
X1770 N953 N226 N1085 N89 N76 _NC3674 _NC3675 AO22X1
X1771 N1786 N221 S_fract_48_i[11] N9370 N1792 _NC3676 _NC3677 AO22X1
X1772 N921 N224 S_fract_48_i[8] N10270 N927 _NC3678 _NC3679 AO22X1
X1773 N922 N224 S_fract_48_i[8] N9950 N75 _NC3680 _NC3681 AOI22X1
X1774 Add_90_I40_L07002_C132_carry[3] N75 N939 _NC3682 _NC3683 XNOR2X1
X1775 N1818 N214 S_fract_48_i[13] N9720 N809 _NC3684 _NC3685 AO22X1
X1776 N1818 N214 S_fract_48_i[13] N9720 N1824 _NC3686 _NC3687 AO22X1
X1777 N1834 N212 S_fract_48_i[14] N809 N9890 _NC3688 _NC3689 AO22X1
X1778 N1834 N212 S_fract_48_i[14] N809 N1840 _NC3690 _NC3691 AO22X1
X1779 Add_105_I18_L07002_C136_carry[1] N1871 Add_105_I18_L07002_C136_carry[2] _NC3692 _NC3693 _NC3694 HADDX2
X1780 N1753 N223 S_fract_48_i[9] N9200 N1759 _NC3695 _NC3696 AO22X1
X1781 N939 N225 S_fract_48_i[7] N9180 N142 _NC3697 _NC3698 AO22X1
X1782 N912 N913 N73 _NC3699 _NC3700 NAND2X0
X1783 N71 N73 N142 N72 N74 N6140 _NC3701 _NC3702 AOI221X1
X1784 N2331 N176 S_fract_48_i[45] N10210 N2337 _NC3703 _NC3704 AO22X1
X1785 N1815 N214 S_fract_48_i[13] N8740 N70 _NC3705 _NC3706 AO22X1
X1786 N939 N225 S_fract_48_i[7] N9180 N66 _NC3707 _NC3708 AOI22X1
X1787 Add_90_I41_L07002_C132_carry[3] N66 N956 _NC3709 _NC3710 XNOR2X1
X1788 N612 N173 S_fract_48_i[26] N846 N65 _NC3711 _NC3712 AO22X1
X1789 N2011 N174 S_fract_48_i[25] N2001 N2017 _NC3713 _NC3714 AO22X1
X1790 N2347 N69 N1064 N67 N64 _NC3715 _NC3716 AOI22X1
X1791 Add_105_I48_L07002_C136_carry[3] N64 N2363 _NC3717 _NC3718 XNOR2X1
X1792 N633 N174 S_fract_48_i[25] N8920 N9240 _NC3719 _NC3720 AO22X1
X1793 N9000 N9010 N62 _NC3721 _NC3722 NAND2X0
X1794 N61 N62 N9240 N1312 N31 N590 _NC3723 _NC3724 AOI221X1
X1795 N416 Add_90_I10_L07002_C132_carry[1] Add_90_I10_L07002_C132_carry[2] _NC3725 _NC3726 _NC3727 HADDX2
X1796 N427 N146 S_fract_48_i[37] N966 N433 _NC3728 _NC3729 AO22X1
X1797 Add_90_I34_L07002_C132_carry[3] N58 N837 _NC3730 _NC3731 XNOR2X1
X1798 N870 N221 S_fract_48_i[11] N22 N876 _NC3732 _NC3733 AO22X1
X1799 Add_105_I16_L07002_C136_carry[1] N1839 Add_105_I16_L07002_C136_carry[2] _NC3734 _NC3735 _NC3736 HADDX1
X1800 N1849 N210 S_fract_48_i[15] N149 N57 _NC3737 _NC3738 AO22X1
X1801 Add_105_I22_L07002_C136_carry[2] N1936 Add_105_I22_L07002_C136_carry[3] _NC3739 _NC3740 _NC3741 HADDX1
X1802 N820 N212 S_fract_48_i[14] N113 N58 _NC3742 _NC3743 AOI22X1
X1803 N820 N212 S_fract_48_i[14] N113 N111 _NC3744 _NC3745 AO22X1
X1804 N816 N212 S_fract_48_i[14] N218 N56 _NC3746 _NC3747 AO22X1
X1805 N2028 N2029 Add_105_I28_L07002_C136_carry[0] _NC3748 _NC3749 _NC3750 HADDX2
X1806 Add_105_I30_L07002_C136_carry[0] N2062 Add_105_I30_L07002_C136_carry[1] _NC3751 _NC3752 _NC3753 HADDX2
X1807 N53 Add_90_I33_L07002_C132_carry[3] N820 _NC3754 _NC3755 XNOR2X1
X1808 Add_105_I22_L07002_C136_carry[0] N1934 Add_105_I22_L07002_C136_carry[1] _NC3756 _NC3757 _NC3758 HADDX2
X1809 N871 N221 S_fract_48_i[11] N186 N51 _NC3759 _NC3760 AOI22X1
X1810 Add_90_I37_L07002_C132_carry[3] N51 N888 _NC3761 _NC3762 XNOR2X1
X1811 N697 N196 S_fract_48_i[21] N8490 N50 _NC3763 _NC3764 AO22X1
X1812 N2088 N164 N1078 N8390 N49 _NC3765 _NC3766 AO22X1
X1813 Add_105_I22_L07002_C136_carry[3] N48 N1947 _NC3767 _NC3768 XNOR2X1
X1814 Add_90_I39_L07002_C132_carry[3] N47 N922 _NC3769 _NC3770 XNOR2X1
X1815 N734 N198 S_fract_48_i[19] N10060 N740 _NC3771 _NC3772 AO22X1
X1816 Add_105_I23_L07002_C136_carry[2] N1952 Add_105_I23_L07002_C136_carry[3] _NC3773 _NC3774 _NC3775 HADDX2
X1817 Add_105_I44_L07002_C136_carry[0] N2286 Add_105_I44_L07002_C136_carry[1] _NC3776 _NC3777 _NC3778 HADDX2
X1818 Add_105_I44_L07002_C136_carry[1] N2287 Add_105_I44_L07002_C136_carry[2] _NC3779 _NC3780 _NC3781 HADDX1
X1819 N6160 _NC3782 _NC3783 N71 INVX0
X1820 N331 N4800 N4810 N847 N2975 _NC3784 _NC3785 AO22X1
X1821 N331 _NC3786 _NC3787 N10400 INVX0
X1822 N573 _NC3788 _NC3789 N10290 INVX0
X1823 N352 _NC3790 _NC3791 N1044 INVX0
X1824 N5810 N5820 N5830 N34 _NC3792 _NC3793 AND3X1
X1825 N340 N3420 N3410 N33 _NC3794 _NC3795 AND3X1
X1826 N598 N172 S_fract_48_i[27] N9920 N896 _NC3796 _NC3797 AOI22X1
X1827 N6050 N606 N607 N32 _NC3798 _NC3799 AND3X1
X1828 N554 N1078 N8190 N5950 N31 _NC3800 _NC3801 AO22X1
X1829 N3650 N367 N3660 N30 _NC3802 _NC3803 AND3X1
X1830 N547 N164 N1077 N24 N28 _NC3804 _NC3805 AO22X1
X1831 N1704 N226 N1088 N984 N27 _NC3806 _NC3807 AO22X1
X1832 N546 N164 N1077 N949 N26 _NC3808 _NC3809 AO22X1
X1833 N1856 Add_105_I17_L07002_C136_carry[2] Add_105_I17_L07002_C136_carry[3] _NC3810 _NC3811 _NC3812 HADDX1
X1834 N530 N162 S_fract_48_i[31] N1 N24 _NC3813 _NC3814 AO22X1
X1835 N1706 N226 N1087 N1696 N23 _NC3815 _NC3816 AO22X2
X1836 N853 N215 N1071 N9740 N22 _NC3817 _NC3818 AO22X1
X1837 N479 N156 S_fract_48_i[34] N161 N21 _NC3819 _NC3820 AO22X1
X1838 N1769 N222 S_fract_48_i[10] N845 N20 _NC3821 _NC3822 AO22X1
X1839 N1738 N224 S_fract_48_i[8] N4 N19 _NC3823 _NC3824 AO22X1
X1840 N359 N130 N349 S_fract_48_i[41] N18 _NC3825 _NC3826 AO22X1
X1841 N734 N198 S_fract_48_i[19] N10060 N17 _NC3827 _NC3828 AO22X1
X1842 N818 N212 S_fract_48_i[14] N219 N16 _NC3829 _NC3830 AO22X1
X1843 N377 N137 S_fract_48_i[40] N366 N15 _NC3831 _NC3832 AO22X2
X1844 N375 N137 S_fract_48_i[40] N9900 N14 _NC3833 _NC3834 AO22X1
X1845 N1689 N227 N1680 N1082 N13 _NC3835 _NC3836 AO22X1
X1846 N564 N170 S_fract_48_i[29] N28 N8 _NC3837 _NC3838 AO22X1
X1847 N649 N177 N1146 N1014 N5 _NC3839 _NC3840 AO22X1
X1848 N1722 N225 S_fract_48_i[7] N23 N4 _NC3841 _NC3842 AO22X1
X1849 N496 N158 S_fract_48_i[33] N21 N3 _NC3843 _NC3844 AO22X1
X1850 N376 N137 S_fract_48_i[40] N18 N2 _NC3845 _NC3846 AO22X1
X1851 N513 N160 S_fract_48_i[32] N3 N1 _NC3847 _NC3848 AO22X1
X1852 N1915 N198 S_fract_48_i[19] N811 N1921 _NC3849 _NC3850 AO22X1
X1853 Add_105_I24_L07002_C136_carry[3] N1969 N1979 _NC3851 _NC3852 XOR2X1
X1854 N1774 Add_105_I12_L07002_C136_carry[0] Add_105_I12_L07002_C136_carry[1] _NC3853 _NC3854 _NC3855 HADDX1
X1855 N1784 N221 S_fract_48_i[11] N1774 N1790 _NC3856 _NC3857 AO22X1
X1856 Add_105_I31_L07002_C136_carry[0] N54 Add_105_I31_L07002_C136_carry[1] _NC3858 _NC3859 _NC3860 HADDX1
X1857 N2088 N164 N1078 N8390 N2094 _NC3861 _NC3862 AO22X1
X1858 N3328 N1729 N3330 N1181 N3340 N191 N1042 _NC3863 _NC3864 AOI222X1
X1859 N8700 _NC3865 _NC3866 N243 INVX0
X1860 N5770 _NC3867 _NC3868 N240 INVX0
X1861 N5780 _NC3869 _NC3870 N242 INVX0
X1862 N394 N144 S_fract_48_i[39] N15 N4510 _NC3871 _NC3872 AO22X1
X1863 N411 N145 S_fract_48_i[38] N4510 N9520 _NC3873 _NC3874 AO22X1
X1864 N410 N145 S_fract_48_i[38] N4120 N966 _NC3875 _NC3876 AO22X1
X1865 N393 N144 S_fract_48_i[39] N2 N4120 _NC3877 _NC3878 AO22X1
X1866 N392 N144 S_fract_48_i[39] N14 N4010 _NC3879 _NC3880 AO22X1
X1867 N358 N130 S_fract_48_i[41] N192 N364 _NC3881 _NC3882 AO22X1
X1868 N409 N145 S_fract_48_i[38] N4010 N983 _NC3883 _NC3884 AO22X1
X1869 N357 N130 S_fract_48_i[41] N107 N102 _NC3885 _NC3886 AO22X1
X1870 N1737 N224 S_fract_48_i[8] N9930 N9200 _NC3887 _NC3888 AO22X1
X1871 N1785 N221 S_fract_48_i[11] N20 N8220 _NC3889 _NC3890 AO22X1
X1872 N149 N3430 N9770 N1071 N1033 N3440 N4260 _NC3891 _NC3892 AOI222X1
X1873 N1705 _NC3893 _NC3894 N93 NBUFFX4
X1874 N1720 N225 S_fract_48_i[7] N27 N814 _NC3895 _NC3896 AO22X1
X1875 N1719 N225 S_fract_48_i[7] N167 N1725 _NC3897 _NC3898 AO22X1
X1876 N395 N144 S_fract_48_i[39] N1171 N401 _NC3899 _NC3900 AO22X1
X1877 N592 _NC3901 _NC3902 N61 INVX0
X1878 N462 N154 S_fract_48_i[35] N25 N161 _NC3903 _NC3904 AO22X1
X1879 N445 N152 S_fract_48_i[36] N828 N25 _NC3905 _NC3906 AO22X1
X1880 N615 N173 S_fract_48_i[26] N10260 N863 _NC3907 _NC3908 AOI22X1
X1881 N581 N171 S_fract_48_i[28] N8 N8720 _NC3909 _NC3910 AOI22X1
X1882 N394 N144 S_fract_48_i[39] N15 N400 _NC3911 _NC3912 AO22X1
X1883 N410 N145 S_fract_48_i[38] N4120 N416 _NC3913 _NC3914 AO22X1
X1884 N444 N152 S_fract_48_i[36] N830 N9410 _NC3915 _NC3916 AO22X1
X1885 N512 N160 S_fract_48_i[32] N103 N5680 _NC3917 _NC3918 AO22X1
X1886 N495 N158 S_fract_48_i[33] N948 N103 _NC3919 _NC3920 AO22X1
X1887 N529 N162 S_fract_48_i[31] N5680 N949 _NC3921 _NC3922 AO22X1
X1888 N580 N171 S_fract_48_i[28] N829 N9880 _NC3923 _NC3924 AO22X1
X1889 N359 N130 N349 S_fract_48_i[41] N365 _NC3925 _NC3926 AO22X1
X1890 N443 N152 S_fract_48_i[36] N8340 N9420 _NC3927 _NC3928 AO22X1
X1891 N391 N144 S_fract_48_i[39] N380 N397 _NC3929 _NC3930 AO22X1
X1892 N527 N162 S_fract_48_i[31] N9400 N9610 _NC3931 _NC3932 AO22X1
X1893 N442 N152 S_fract_48_i[36] N8840 N4000 _NC3933 _NC3934 AO22X1
X1894 N351 _NC3935 _NC3936 N1043 INVX0
X1895 N1722 N225 S_fract_48_i[7] N23 N1728 _NC3937 _NC3938 AO22X1
X1896 N1770 _NC3939 _NC3940 N91 NBUFFX4
X1897 N1882 N206 S_fract_48_i[17] N6180 N9090 _NC3941 _NC3942 AO22X1
X1898 N1769 N222 S_fract_48_i[10] N845 N1775 _NC3943 _NC3944 AO22X1
X1899 N201 N389 N591 N1075 N9340 N3900 N4650 _NC3945 _NC3946 AOI222X1
X1900 N1800 N215 N1072 N1017 N10190 _NC3947 _NC3948 AO22X1
X1901 N1790 _NC3949 _NC3950 N1017 NBUFFX2
X1902 N1751 N223 S_fract_48_i[9] N193 N1757 _NC3951 _NC3952 AO22X1
X1903 N1049 S_fract_48_i[2] N5710 _NC3953 _NC3954 XNOR2X1
X1904 N323 S_exp_10b[9] N322 _NC3955 _NC3956 NOR2X0
X1905 N463 N154 S_fract_48_i[35] N452 N469 _NC3957 _NC3958 AO22X1
X1906 N428 N146 S_fract_48_i[37] N9520 N434 _NC3959 _NC3960 AO22X1
X1907 N496 N158 S_fract_48_i[33] N21 N502 _NC3961 _NC3962 AO22X1
X1908 N632 N174 S_fract_48_i[25] N10200 N1014 _NC3963 _NC3964 AO22X1
X1909 N717 N197 S_fract_48_i[20] N810 N10060 _NC3965 _NC3966 AO22X1
X1910 N683 N189 S_fract_48_i[22] N982 N8230 _NC3967 _NC3968 AO22X1
X1911 N530 N162 S_fract_48_i[31] N1 N536 _NC3969 _NC3970 AO22X1
X1912 N598 N172 S_fract_48_i[27] N9920 N604 _NC3971 _NC3972 AO22X1
X1913 N564 N170 S_fract_48_i[29] N28 N570 _NC3973 _NC3974 AO22X1
X1914 N563 N170 S_fract_48_i[29] N26 N829 _NC3975 _NC3976 AO22X1
X1915 N716 N197 S_fract_48_i[20] N812 N9700 _NC3977 _NC3978 AO22X1
X1916 N682 N189 S_fract_48_i[22] N9750 N8240 _NC3979 _NC3980 AO22X1
X1917 N579 N171 S_fract_48_i[28] N8380 N8250 _NC3981 _NC3982 AO22X1
X1918 N460 N154 S_fract_48_i[35] N9420 N466 _NC3983 _NC3984 AO22X1
X1919 N528 N162 S_fract_48_i[31] N517 N534 _NC3985 _NC3986 AO22X1
X1920 N510 N160 S_fract_48_i[32] N8680 N516 _NC3987 _NC3988 AO22X1
X1921 N476 N156 S_fract_48_i[34] N120 N482 _NC3989 _NC3990 AO22X1
X1922 N333 _NC3991 _NC3992 N117 NBUFFX4
X1923 N1883 N206 S_fract_48_i[17] N203 N8750 _NC3993 _NC3994 AO22X1
X1924 N1915 N198 S_fract_48_i[19] N811 N3820 _NC3995 _NC3996 AO22X1
X1925 N1819 N214 S_fract_48_i[13] N877 N1825 _NC3997 _NC3998 AO22X1
X1926 N1930 N197 S_fract_48_i[20] N981 N9760 _NC3999 _NC4000 AO22X1
X1927 N1743 Add_105_I10_L07002_C136_carry[1] Add_105_I10_L07002_C136_carry[2] _NC4001 _NC4002 _NC4003 HADDX1
X1928 N1833 N212 S_fract_48_i[14] N1033 N1839 _NC4004 _NC4005 AO22X1
X1929 N1865 N208 S_fract_48_i[16] N57 N1871 _NC4006 _NC4007 AO22X1
X1930 N1831 N212 S_fract_48_i[14] N70 N1837 _NC4008 _NC4009 AO22X1
X1931 N497 N158 S_fract_48_i[33] N148 N503 _NC4010 _NC4011 AO22X1
X1932 N723 Add_90_I28_L07002_C132_carry[2] Add_90_I28_L07002_C132_carry[3] _NC4012 _NC4013 _NC4014 HADDX1
X1933 N768 N206 S_fract_48_i[17] N931 N6150 _NC4015 _NC4016 AO22X1
X1934 N802 N210 S_fract_48_i[15] N965 N230 _NC4017 _NC4018 AO22X1
X1935 N819 N212 S_fract_48_i[14] N230 N3570 _NC4019 _NC4020 AO22X1
X1936 N683 N189 S_fract_48_i[22] N982 N689 _NC4021 _NC4022 AO22X1
X1937 N767 N206 S_fract_48_i[17] N880 N5960 _NC4023 _NC4024 AO22X1
X1938 N835 N214 S_fract_48_i[13] N16 N916 _NC4025 _NC4026 AO22X1
X1939 N648 N177 S_fract_48_i[24] N10090 N654 _NC4027 _NC4028 AO22X1
X1940 N2059 N171 S_fract_48_i[28] N10080 N950 _NC4029 _NC4030 AO22X1
X1941 N928 N370 N350 N371 N4100 _NC4031 _NC4032 AOI22X1
X1942 N1962 N189 S_fract_48_i[22] N8170 N878 _NC4033 _NC4034 AO22X1
X1943 N2057 N171 S_fract_48_i[28] N10120 N9550 _NC4035 _NC4036 AO22X1
X1944 N2025 N173 S_fract_48_i[26] N897 N881 _NC4037 _NC4038 AO22X1
X1945 N1961 N189 S_fract_48_i[22] N9060 N5940 _NC4039 _NC4040 AO22X1
X1946 N1913 N198 S_fract_48_i[19] N209 N1919 _NC4041 _NC4042 AO22X1
X1947 N1960 N189 S_fract_48_i[22] N9250 N827 _NC4043 _NC4044 AO22X1
X1948 N1944 N196 S_fract_48_i[21] N201 N1950 _NC4045 _NC4046 AO22X1
X1949 N2008 N174 S_fract_48_i[25] N9070 N2014 _NC4047 _NC4048 AO22X1
X1950 N2039 N172 S_fract_48_i[27] N190 N55 _NC4049 _NC4050 AO22X1
X1951 N2023 N173 S_fract_48_i[26] N9850 N190 _NC4051 _NC4052 AO22X1
X1952 N1895 N204 N1075 N216 N1901 _NC4053 _NC4054 AO22X1
X1953 N1911 N198 S_fract_48_i[19] N8400 N1917 _NC4055 _NC4056 AO22X1
X1954 N1879 N206 S_fract_48_i[17] N169 N1885 _NC4057 _NC4058 AO22X1
X1955 N1847 N210 S_fract_48_i[15] N8530 N1853 _NC4059 _NC4060 AO22X1
X1956 Add_90_I25_L07002_C132_carry[3] N673 N684 _NC4061 _NC4062 XOR2X1
X1957 N6170 _NC4063 _NC4064 N72 INVX0
X1958 N186 N1072 N147 N6190 N74 _NC4065 _NC4066 AO22X1
X1959 N888 N222 S_fract_48_i[10] N147 N140 _NC4067 _NC4068 AO22X1
X1960 N769 N206 S_fract_48_i[17] N207 N105 _NC4069 _NC4070 AO22X1
X1961 N904 N223 S_fract_48_i[9] N211 N8900 _NC4071 _NC4072 AOI22X1
X1962 N22 N1071 N8160 N6190 N6560 _NC4073 _NC4074 AOI22X1
X1963 N887 N222 S_fract_48_i[10] N8160 N211 _NC4075 _NC4076 AO22X1
X1964 N768 N206 S_fract_48_i[17] N931 N774 _NC4077 _NC4078 AO22X1
X1965 N802 N210 S_fract_48_i[15] N965 N808 _NC4079 _NC4080 AO22X1
X1966 N579 N171 S_fract_48_i[28] N8380 N585 _NC4081 _NC4082 AO22X1
X1967 N886 N222 S_fract_48_i[10] N217 N180 _NC4083 _NC4084 AO22X1
X1968 N613 N173 S_fract_48_i[26] N8580 N619 _NC4085 _NC4086 AO22X1
X1969 N817 N212 S_fract_48_i[14] N213 N63 _NC4087 _NC4088 AO22X1
X1970 N732 N198 S_fract_48_i[19] N9190 N738 _NC4089 _NC4090 AO22X1
X1971 N698 N196 S_fract_48_i[21] N10040 N704 _NC4091 _NC4092 AO22X1
X1972 N681 N189 S_fract_48_i[22] N9710 N687 _NC4093 _NC4094 AO22X1
X1973 N663 N182 S_fract_48_i[23] N652 N669 _NC4095 _NC4096 AO22X1
X1974 N714 N197 S_fract_48_i[20] N50 N720 _NC4097 _NC4098 AO22X1
X1975 N595 N172 S_fract_48_i[27] N143 N601 _NC4099 _NC4100 AO22X1
X1976 N1931 N197 S_fract_48_i[20] N3820 N48 _NC4101 _NC4102 AOI22X1
X1977 N1978 N182 S_fract_48_i[23] N878 N1984 _NC4103 _NC4104 AO22X1
X1978 Add_105_I25_L07002_C136_carry[2] N1984 Add_105_I25_L07002_C136_carry[3] _NC4105 _NC4106 _NC4107 HADDX1
X1979 N165 N145 S_fract_48_i[38] N861 N29 _NC4108 _NC4109 AO22X1
X1980 N2203 N146 S_fract_48_i[37] N1018 N861 _NC4110 _NC4111 AO22X1
X1981 N2187 N152 S_fract_48_i[36] N8910 N2193 _NC4112 _NC4113 AO22X1
X1982 N2139 N158 S_fract_48_i[33] N932 N8690 _NC4114 _NC4115 AO22X1
X1983 N2027 N173 S_fract_48_i[26] N915 N2033 _NC4116 _NC4117 AO22X1
X1984 N1962 N189 S_fract_48_i[22] N8170 N1968 _NC4118 _NC4119 AO22X1
X1985 N2074 N170 S_fract_48_i[29] N3740 N2080 _NC4120 _NC4121 AO22X1
X1986 Add_105_I26_L07002_C136_carry[2] N2000 Add_105_I26_L07002_C136_carry[3] _NC4122 _NC4123 _NC4124 HADDX1
X1987 N1977 N182 S_fract_48_i[23] N5940 N1983 _NC4125 _NC4126 AO22X1
X1988 N2041 N172 S_fract_48_i[27] N881 N2047 _NC4127 _NC4128 AO22X1
X1989 N1945 N196 S_fract_48_i[21] N168 N1951 _NC4129 _NC4130 AO22X1
X1990 N1944 N196 S_fract_48_i[21] N201 N52 _NC4131 _NC4132 AO22X1
X1991 N2072 N170 S_fract_48_i[29] N205 N2078 _NC4133 _NC4134 AO22X1
X1992 N474 N4750 N4760 N472 _NC4135 _NC4136 NAND3X0
X1993 N2136 N158 S_fract_48_i[33] N8860 N860 _NC4137 _NC4138 AO22X1
X1994 N1976 N182 S_fract_48_i[23] N827 N1982 _NC4139 _NC4140 AO22X1
X1995 N2135 N158 S_fract_48_i[33] N8830 N8590 _NC4141 _NC4142 AO22X1
X1996 N2103 N162 S_fract_48_i[31] N9380 N179 _NC4143 _NC4144 AO22X1
X1997 N2055 N171 S_fract_48_i[28] N55 N2061 _NC4145 _NC4146 AO22X1
X1998 N2007 N174 S_fract_48_i[25] N9040 N2013 _NC4147 _NC4148 AO22X1
X1999 Add_90_I30_L07002_C132_carry[3] N758 N769 _NC4149 _NC4150 XOR2X1
X2000 Add_90_I32_L07002_C132_carry[3] N792 N803 _NC4151 _NC4152 XOR2X1
X2001 N887 N222 S_fract_48_i[10] N8160 N893 _NC4153 _NC4154 AO22X1
X2002 N938 N225 S_fract_48_i[7] N997 N8040 _NC4155 _NC4156 AO22X1
X2003 N920 N224 S_fract_48_i[8] N8060 N80 _NC4157 _NC4158 AO22X1
X2004 N937 N225 S_fract_48_i[7] N80 N86 _NC4159 _NC4160 AO22X1
X2005 N738 Add_90_I29_L07002_C132_carry[0] Add_90_I29_L07002_C132_carry[1] _NC4161 _NC4162 _NC4163 HADDX1
X2006 N817 N212 S_fract_48_i[14] N213 N823 _NC4164 _NC4165 AO22X1
X2007 N799 N210 S_fract_48_i[15] N94 N805 _NC4166 _NC4167 AO22X1
X2008 N782 N208 S_fract_48_i[16] N771 N788 _NC4168 _NC4169 AO22X1
X2009 N2331 N176 S_fract_48_i[45] N10210 N67 _NC4170 _NC4171 AO22X1
X2010 N2299 N122 S_fract_48_i[43] N945 N234 _NC4172 _NC4173 AO22X1
X2011 N2251 N137 S_fract_48_i[40] N10050 N826 _NC4174 _NC4175 AO22X1
X2012 Add_105_I30_L07002_C136_carry[2] N2064 Add_105_I30_L07002_C136_carry[3] _NC4176 _NC4177 _NC4178 HADDX1
X2013 N2202 N146 S_fract_48_i[37] N1032 N9100 _NC4179 _NC4180 AO22X1
X2014 N2201 N146 S_fract_48_i[37] N9080 N8870 _NC4181 _NC4182 AO22X1
X2015 N2121 N160 S_fract_48_i[32] N8560 N2127 _NC4183 _NC4184 AO22X1
X2016 N2089 N164 N1078 N228 N2095 _NC4185 _NC4186 AO22X1
X2017 N2008 N174 S_fract_48_i[25] N9070 N82 _NC4187 _NC4188 AO22X1
X2018 N2136 N158 S_fract_48_i[33] N8860 N2142 _NC4189 _NC4190 AO22X1
X2019 Add_105_I34_L07002_C136_carry[0] N2126 Add_105_I34_L07002_C136_carry[1] _NC4191 _NC4192 _NC4193 HADDX1
X2020 N2072 N170 S_fract_48_i[29] N205 N54 _NC4194 _NC4195 AO22X1
X2021 N2039 N172 S_fract_48_i[27] N190 N2045 _NC4196 _NC4197 AO22X1
X2022 N2215 N145 S_fract_48_i[38] N8850 N95 _NC4198 _NC4199 AO22X1
X2023 N2119 N160 S_fract_48_i[32] N179 N2125 _NC4200 _NC4201 AO22X1
X2024 N2087 N164 N1077 N3810 N2093 _NC4202 _NC4203 AO22X1
X2025 N905 N223 S_fract_48_i[9] N140 N47 _NC4204 _NC4205 AOI22X1
X2026 Add_90_I40_L07002_C132_carry[2] N927 Add_90_I40_L07002_C132_carry[3] _NC4206 _NC4207 _NC4208 HADDX1
X2027 N1012 Add_90_I45_L07002_C132_carry[2] Add_90_I45_L07002_C132_carry[3] _NC4209 _NC4210 _NC4211 HADDX1
X2028 N995 Add_90_I44_L07002_C132_carry[2] Add_90_I44_L07002_C132_carry[3] _NC4212 _NC4213 _NC4214 HADDX1
X2029 N989 N229 S_fract_48_i[4] N947 N995 _NC4215 _NC4216 AO22X1
X2030 N835 N214 S_fract_48_i[13] N16 N841 _NC4217 _NC4218 AO22X1
X2031 N1005 N231 S_fract_48_i[3] N994 N1011 _NC4219 _NC4220 AO22X1
X2032 N937 N225 S_fract_48_i[7] N80 N943 _NC4221 _NC4222 AO22X1
X2033 N885 N222 S_fract_48_i[10] N187 N891 _NC4223 _NC4224 AO22X1
X2034 N2346 N69 N1064 N136 N2352 _NC4225 _NC4226 AO22X1
X2035 N2352 Add_105_I48_L07002_C136_carry[2] Add_105_I48_L07002_C136_carry[3] _NC4227 _NC4228 _NC4229 HADDX1
X2036 N2336 Add_105_I47_L07002_C136_carry[2] Add_105_I47_L07002_C136_carry[3] _NC4230 _NC4231 _NC4232 HADDX1
X2037 N2299 N122 S_fract_48_i[43] N945 N2305 _NC4233 _NC4234 AO22X1
X2038 N165 N145 S_fract_48_i[38] N861 N8520 _NC4235 _NC4236 AO22X1
X2039 Add_105_I32_L07002_C136_carry[2] N2096 Add_105_I32_L07002_C136_carry[3] _NC4237 _NC4238 _NC4239 HADDX1
X2040 N2154 N156 S_fract_48_i[34] N928 N2160 _NC4240 _NC4241 AO22X1
X2041 Add_105_I36_L07002_C136_carry[2] N2160 Add_105_I36_L07002_C136_carry[3] _NC4242 _NC4243 _NC4244 HADDX1
X2042 N2266 N130 S_fract_48_i[41] N10030 N879 _NC4245 _NC4246 AO22X1
X2043 N2336 _NC4247 _NC4248 N136 NBUFFX4
X2044 N2218 N145 S_fract_48_i[38] N9100 N2224 _NC4249 _NC4250 AO22X1
X2045 N2186 N152 S_fract_48_i[36] N8880 N2192 _NC4251 _NC4252 AO22X1
X2046 Add_105_I33_L07002_C136_carry[1] N2111 Add_105_I33_L07002_C136_carry[2] _NC4253 _NC4254 _NC4255 HADDX1
X2047 N2201 N146 S_fract_48_i[37] N9080 N2207 _NC4256 _NC4257 AO22X1
X2048 Add_105_I38_L07002_C136_carry[1] N2191 Add_105_I38_L07002_C136_carry[2] _NC4258 _NC4259 _NC4260 HADDX1
X2049 N2265 N130 S_fract_48_i[41] N131 N85 _NC4261 _NC4262 AO22X1
X2050 N2297 N122 S_fract_48_i[43] N114 N44 _NC4263 _NC4264 AO22X1
X2051 N2350 Add_105_I48_L07002_C136_carry[0] Add_105_I48_L07002_C136_carry[1] _NC4265 _NC4266 _NC4267 HADDX1
X2052 N2296 N122 S_fract_48_i[43] N6200 N45 _NC4268 _NC4269 AO22X1
X2053 N2247 N137 S_fract_48_i[40] N843 N100 _NC4270 _NC4271 AO22X1
X2054 N2263 N130 S_fract_48_i[41] N100 N2269 _NC4272 _NC4273 AO22X1
X2055 N868 N221 S_fract_48_i[11] N857 N874 _NC4274 _NC4275 AO22X1
X2056 N919 N224 S_fract_48_i[8] N8070 N925 _NC4276 _NC4277 AO22X1
X2057 N884 N222 S_fract_48_i[10] N873 N890 _NC4278 _NC4279 AO22X1
X2058 N918 N224 S_fract_48_i[8] N185 N924 _NC4280 _NC4281 AO22X1
X2059 N2335 Add_105_I47_L07002_C136_carry[1] Add_105_I47_L07002_C136_carry[2] _NC4282 _NC4283 _NC4284 HADDX1
X2060 N2266 N130 S_fract_48_i[41] N10030 N2272 _NC4285 _NC4286 AO22X1
X2061 Add_105_I37_L07002_C136_carry[1] N2175 Add_105_I37_L07002_C136_carry[2] _NC4287 _NC4288 _NC4289 HADDX1
X2062 N2233 N144 S_fract_48_i[39] N112 N2239 _NC4290 _NC4291 AO22X1
X2063 Add_105_I46_L07002_C136_carry[1] N2319 Add_105_I46_L07002_C136_carry[2] _NC4292 _NC4293 _NC4294 HADDX1
X2064 N2232 N144 S_fract_48_i[39] N98 N2238 _NC4295 _NC4296 AO22X1
X2065 Add_105_I41_L07002_C136_carry[0] N2238 Add_105_I41_L07002_C136_carry[1] _NC4297 _NC4298 _NC4299 HADDX1
X2066 N2248 N137 S_fract_48_i[40] N8410 N2254 _NC4300 _NC4301 AO22X1
X2067 Add_105_I42_L07002_C136_carry[0] N2254 Add_105_I42_L07002_C136_carry[1] _NC4302 _NC4303 _NC4304 HADDX1
X2068 Add_105_I47_L07002_C136_carry[0] N2334 Add_105_I47_L07002_C136_carry[1] _NC4305 _NC4306 _NC4307 HADDX1
X2069 N2231 N144 S_fract_48_i[39] N95 N2237 _NC4308 _NC4309 AO22X1
X2070 N2236 N2237 Add_105_I41_L07002_C136_carry[0] _NC4310 _NC4311 _NC4312 HADDX1
X2071 N2247 N137 S_fract_48_i[40] N843 N2253 _NC4313 _NC4314 AO22X1
X2072 N2252 N2253 Add_105_I42_L07002_C136_carry[0] _NC4315 _NC4316 _NC4317 HADDX1
X2073 Add_105_I40_L07002_C136_carry[0] N2222 Add_105_I40_L07002_C136_carry[1] _NC4318 _NC4319 _NC4320 HADDX1
X2074 N1735 N224 S_fract_48_i[8] N9030 N193 _NC4321 _NC4322 AO22X1
X2075 N393 N144 S_fract_48_i[39] N2 N399 _NC4323 _NC4324 AO22X1
X2076 N358 N130 S_fract_48_i[41] N192 N101 _NC4325 _NC4326 AO22X1
X2077 N1787 N221 S_fract_48_i[11] N79 N1793 _NC4327 _NC4328 AO22X1
X2078 Add_105_I9_L07002_C136_carry[3] N1729 N1739 _NC4329 _NC4330 XOR2X1
X2079 N1739 N224 S_fract_48_i[8] N1729 N1745 _NC4331 _NC4332 AO22X1
X2080 N1754 N223 S_fract_48_i[9] N19 N8370 _NC4333 _NC4334 AO22X1
X2081 N1833 N212 S_fract_48_i[14] N1033 N149 _NC4335 _NC4336 AO22X1
X2082 N1865 N208 S_fract_48_i[16] N57 N59 _NC4337 _NC4338 AO22X1
X2083 N1881 N206 S_fract_48_i[17] N59 N8200 _NC4339 _NC4340 AO22X1
X2084 N1768 N222 S_fract_48_i[10] N8540 N1774 _NC4341 _NC4342 AO22X1
X2085 N1720 N225 S_fract_48_i[7] N27 N1726 _NC4343 _NC4344 AO22X1
X2086 N429 N146 S_fract_48_i[37] N844 N435 _NC4345 _NC4346 AO22X1
X2087 N571 _NC4347 _NC4348 N8190 NBUFFX4
X2088 N445 N152 S_fract_48_i[36] N828 N451 _NC4349 _NC4350 AO22X1
X2089 N479 N156 S_fract_48_i[34] N161 N485 _NC4351 _NC4352 AO22X1
X2090 N513 N160 S_fract_48_i[32] N3 N519 _NC4353 _NC4354 AO22X1
X2091 N581 N171 S_fract_48_i[28] N8 N587 _NC4355 _NC4356 AO22X1
X2092 N426 N146 S_fract_48_i[37] N983 N432 _NC4357 _NC4358 AO22X1
X2093 N1738 N224 S_fract_48_i[8] N4 N1744 _NC4359 _NC4360 AO22X1
X2094 N1785 N221 S_fract_48_i[11] N20 N1791 _NC4361 _NC4362 AO22X1
X2095 N1849 N210 S_fract_48_i[15] N149 N1855 _NC4363 _NC4364 AO22X1
X2096 Add_105_I17_L07002_C136_carry[1] N1855 Add_105_I17_L07002_C136_carry[2] _NC4365 _NC4366 _NC4367 HADDX1
X2097 Add_105_I11_L07002_C136_carry[0] N1758 Add_105_I11_L07002_C136_carry[1] _NC4368 _NC4369 _NC4370 HADDX1
X2098 N1928 N197 S_fract_48_i[20] N9340 N201 _NC4371 _NC4372 AO22X1
X2099 N1848 N210 S_fract_48_i[15] N77 N10070 _NC4373 _NC4374 AO22X1
X2100 N1767 N222 S_fract_48_i[10] N8080 N1773 _NC4375 _NC4376 AO22X1
X2101 N582 N171 S_fract_48_i[28] N8190 N588 _NC4377 _NC4378 AO22X1
X2102 N615 N173 S_fract_48_i[26] N10260 N621 _NC4379 _NC4380 AO22X1
X2103 N700 N196 S_fract_48_i[21] N8230 N706 _NC4381 _NC4382 AO22X1
X2104 N666 N182 S_fract_48_i[23] N5 N672 _NC4383 _NC4384 AO22X1
X2105 N1963 N189 S_fract_48_i[22] N998 N9620 _NC4385 _NC4386 AO22X1
X2106 N2027 N173 S_fract_48_i[26] N915 N8350 _NC4387 _NC4388 AO22X1
X2107 N1664 N1665 Add_105_I5_L07002_C136_carry[2] _NC4389 _NC4390 _NC4391 HADDX1
X2108 N1897 N204 N1075 N8200 N1903 _NC4392 _NC4393 AO22X1
X2109 N701 N196 S_fract_48_i[21] N8510 N707 _NC4394 _NC4395 AO22X1
X2110 N735 N198 S_fract_48_i[19] N133 N741 _NC4396 _NC4397 AO22X1
X2111 N650 N177 N1146 N9240 N656 _NC4398 _NC4399 AO22X1
X2112 N819 N212 S_fract_48_i[14] N230 N825 _NC4400 _NC4401 AO22X1
X2113 N825 Add_90_I34_L07002_C132_carry[2] Add_90_I34_L07002_C132_carry[3] _NC4402 _NC4403 _NC4404 HADDX1
X2114 N756 Add_90_I30_L07002_C132_carry[1] Add_90_I30_L07002_C132_carry[2] _NC4405 _NC4406 _NC4407 HADDX1
X2115 N647 N177 N1146 N10100 N653 _NC4408 _NC4409 AO22X1
X2116 N562 N170 S_fract_48_i[29] N153 N568 _NC4410 _NC4411 AO22X1
X2117 N596 N172 S_fract_48_i[27] N8250 N602 _NC4412 _NC4413 AO22X1
X2118 N2155 N156 S_fract_48_i[34] N8690 N353 _NC4414 _NC4415 AO22X1
X2119 N2154 N156 S_fract_48_i[34] N928 N350 _NC4416 _NC4417 AO22X1
X2120 N2026 N173 S_fract_48_i[26] N8660 N2032 _NC4418 _NC4419 AO22X1
X2121 N1946 N196 S_fract_48_i[21] N9760 N1952 _NC4420 _NC4421 AO22X1
X2122 N2057 N171 S_fract_48_i[28] N10120 N2063 _NC4422 _NC4423 AO22X1
X2123 N1993 N177 S_fract_48_i[24] N914 N1999 _NC4424 _NC4425 AO22X1
X2124 N1928 N197 S_fract_48_i[20] N9340 N1934 _NC4426 _NC4427 AO22X1
X2125 N1960 N189 S_fract_48_i[22] N9250 N1966 _NC4428 _NC4429 AO22X1
X2126 N1943 N196 S_fract_48_i[21] N115 N1949 _NC4430 _NC4431 AO22X1
X2127 N1975 N182 S_fract_48_i[23] N8210 N1981 _NC4432 _NC4433 AO22X1
X2128 N803 N210 S_fract_48_i[15] N3560 N53 _NC4434 _NC4435 AOI22X1
X2129 N800 N210 S_fract_48_i[15] N181 N806 _NC4436 _NC4437 AO22X1
X2130 N834 N214 S_fract_48_i[13] N63 N840 _NC4438 _NC4439 AO22X1
X2131 Add_105_I27_L07002_C136_carry[2] N2016 Add_105_I27_L07002_C136_carry[3] _NC4440 _NC4441 _NC4442 HADDX1
X2132 N2155 N156 S_fract_48_i[34] N8690 N2161 _NC4443 _NC4444 AO22X1
X2133 N2106 N162 S_fract_48_i[31] N848 N2112 _NC4445 _NC4446 AO22X1
X2134 N2170 N154 S_fract_48_i[35] N350 N2176 _NC4447 _NC4448 AO22X1
X2135 N2025 N173 S_fract_48_i[26] N897 N2031 _NC4449 _NC4450 AO22X1
X2136 Add_105_I28_L07002_C136_carry[1] N2031 Add_105_I28_L07002_C136_carry[2] _NC4451 _NC4452 _NC4453 HADDX1
X2137 N2216 N145 S_fract_48_i[38] N8760 N98 _NC4454 _NC4455 AO22X1
X2138 N2120 N160 S_fract_48_i[32] N128 N2126 _NC4456 _NC4457 AO22X1
X2139 N2071 N170 S_fract_48_i[29] N199 N2077 _NC4458 _NC4459 AO22X1
X2140 N904 N223 S_fract_48_i[9] N211 N910 _NC4460 _NC4461 AO22X1
X2141 Add_90_I41_L07002_C132_carry[2] N944 Add_90_I41_L07002_C132_carry[3] _NC4462 _NC4463 _NC4464 HADDX1
X2142 Add_105_I37_L07002_C136_carry[2] N2176 Add_105_I37_L07002_C136_carry[3] _NC4465 _NC4466 _NC4467 HADDX1
X2143 N2185 N152 S_fract_48_i[36] N104 N2191 _NC4468 _NC4469 AO22X1
X2144 N2200 N146 S_fract_48_i[37] N2190 N2206 _NC4470 _NC4471 AO22X1
X2145 N2248 N137 S_fract_48_i[40] N8410 N109 _NC4472 _NC4473 AO22X1
X2146 N2264 N130 S_fract_48_i[41] N109 N2270 _NC4474 _NC4475 AO22X1
X2147 N936 N225 S_fract_48_i[7] N9440 N942 _NC4476 _NC4477 AO22X1
X2148 N2298 N122 S_fract_48_i[43] N220 N46 _NC4478 _NC4479 AO22X1
X2149 N46 Add_105_I45_L07002_C136_carry[2] Add_105_I45_L07002_C136_carry[3] _NC4480 _NC4481 _NC4482 HADDX1
X2150 Add_105_I41_L07002_C136_carry[2] N2240 Add_105_I41_L07002_C136_carry[3] _NC4483 _NC4484 _NC4485 HADDX1
X2151 N2202 N146 S_fract_48_i[37] N1032 N2208 _NC4486 _NC4487 AO22X1
X2152 Add_105_I39_L07002_C136_carry[2] N2208 Add_105_I39_L07002_C136_carry[3] _NC4488 _NC4489 _NC4490 HADDX1
X2153 N2190 Add_105_I38_L07002_C136_carry[0] Add_105_I38_L07002_C136_carry[1] _NC4491 _NC4492 _NC4493 HADDX1
X2154 N2249 N137 S_fract_48_i[40] N8570 N2255 _NC4494 _NC4495 AO22X1
X2155 N2297 N122 S_fract_48_i[43] N114 N2303 _NC4496 _NC4497 AO22X1
X2156 Add_105_I46_L07002_C136_carry[0] N2318 Add_105_I46_L07002_C136_carry[1] _NC4498 _NC4499 _NC4500 HADDX1
X2157 N376 N137 S_fract_48_i[40] N18 N382 _NC4501 _NC4502 AO22X1
X2158 N392 N144 S_fract_48_i[39] N14 N398 _NC4503 _NC4504 AO22X1
X2159 N362 N363 Add_90_I7_L07002_C132_carry[0] _NC4505 _NC4506 _NC4507 HADDX1
X2160 N495 N158 S_fract_48_i[33] N948 N501 _NC4508 _NC4509 AO22X1
X2161 N563 N170 S_fract_48_i[29] N26 N569 _NC4510 _NC4511 AO22X1
X2162 N1754 N223 S_fract_48_i[9] N19 N1760 _NC4512 _NC4513 AO22X1
X2163 N565 N170 S_fract_48_i[29] N554 N571 _NC4514 _NC4515 AO22X1
X2164 N597 N172 S_fract_48_i[27] N9880 N603 _NC4516 _NC4517 AO22X1
X2165 N699 N196 S_fract_48_i[21] N8240 N705 _NC4518 _NC4519 AO22X1
X2166 N1807 Add_105_I14_L07002_C136_carry[1] Add_105_I14_L07002_C136_carry[2] _NC4520 _NC4521 _NC4522 HADDX1
X2167 Add_90_I24_L07002_C132_carry[3] N656 N667 _NC4523 _NC4524 XOR2X1
X2168 N767 N206 S_fract_48_i[17] N880 N773 _NC4525 _NC4526 AO22X1
X2169 Add_105_I20_L07002_C136_carry[0] N1902 Add_105_I20_L07002_C136_carry[1] _NC4527 _NC4528 _NC4529 HADDX1
X2170 N769 N206 S_fract_48_i[17] N207 N775 _NC4530 _NC4531 AO22X1
X2171 Add_90_I31_L07002_C132_carry[3] N775 N786 _NC4532 _NC4533 XOR2X1
X2172 N1961 N189 S_fract_48_i[22] N9060 N1967 _NC4534 _NC4535 AO22X1
X2173 Add_105_I24_L07002_C136_carry[1] N1967 Add_105_I24_L07002_C136_carry[2] _NC4536 _NC4537 _NC4538 HADDX1
X2174 Add_105_I22_L07002_C136_carry[1] N1935 Add_105_I22_L07002_C136_carry[2] _NC4539 _NC4540 _NC4541 HADDX1
X2175 N886 N222 S_fract_48_i[10] N217 N892 _NC4542 _NC4543 AO22X1
X2176 N920 N224 S_fract_48_i[8] N8060 N926 _NC4544 _NC4545 AO22X1
X2177 N2250 N137 S_fract_48_i[40] N8150 N2256 _NC4546 _NC4547 AO22X1
X2178 N2265 N130 S_fract_48_i[41] N131 N2271 _NC4548 _NC4549 AO22X1
X2179 N2296 N122 S_fract_48_i[43] N6200 N2302 _NC4550 _NC4551 AO22X1
X2180 Add_105_I40_L07002_C136_carry[1] N2223 Add_105_I40_L07002_C136_carry[2] _NC4552 _NC4553 _NC4554 HADDX1
X2181 N375 N137 S_fract_48_i[40] N9900 N381 _NC4555 _NC4556 AO22X1
X2182 N478 N156 S_fract_48_i[34] N157 N484 _NC4557 _NC4558 AO22X1
X2183 N512 N160 S_fract_48_i[32] N103 N518 _NC4559 _NC4560 AO22X1
X2184 N682 N189 S_fract_48_i[22] N9750 N688 _NC4561 _NC4562 AO22X1
X2185 Clk_i Fract_48_i[36] S_fract_48_i[36] N152 _NC4563 _NC4564 DFFX1
X2186 Clk_i Fract_48_i[30] S_fract_48_i[30] N164 _NC4565 _NC4566 DFFX1
X2187 Clk_i Fract_48_i[18] S_fract_48_i[18] N204 _NC4567 _NC4568 DFFX1
X2188 Clk_i Fract_48_i[24] S_fract_48_i[24] N177 _NC4569 _NC4570 DFFX1
X2189 Clk_i N3083 S_shr2[2] N36 _NC4571 _NC4572 DFFX1
X2190 Clk_i Fract_48_i[5] S_fract_48_i[5] N227 _NC4573 _NC4574 DFFX2
X2191 Clk_i Fract_48_i[6] S_fract_48_i[6] N226 _NC4575 _NC4576 DFFX2
X2192 Clk_i Fract_48_i[12] S_fract_48_i[12] N215 _NC4577 _NC4578 DFFX2
X2193 Clk_i Fract_48_i[42] S_fract_48_i[42] N123 _NC4579 _NC4580 DFFX2
X2194 N2993 N1148 Sub_0_root_add_0_root_add_148_carry[0] Sub_0_root_add_0_root_add_148_carry[1] N3000 _NC4581 _NC4582 FADDX1
X2195 N348 Add_90_I6_L07002_C132_carry[2] Add_90_I6_L07002_C132_carry[3] _NC4583 _NC4584 _NC4585 HADDX1
X2196 N379 N380 Add_90_I8_L07002_C132_carry[0] _NC4586 _NC4587 _NC4588 HADDX1
X2197 N400 Add_90_I9_L07002_C132_carry[2] Add_90_I9_L07002_C132_carry[3] _NC4589 _NC4590 _NC4591 HADDX1
X2198 N396 N397 Add_90_I9_L07002_C132_carry[0] _NC4592 _NC4593 _NC4594 HADDX1
X2199 N414 N413 Add_90_I10_L07002_C132_carry[0] _NC4595 _NC4596 _NC4597 HADDX1
X2200 N432 Add_90_I11_L07002_C132_carry[0] Add_90_I11_L07002_C132_carry[1] _NC4598 _NC4599 _NC4600 HADDX1
X2201 N448 N447 Add_90_I12_L07002_C132_carry[0] _NC4601 _NC4602 _NC4603 HADDX1
X2202 N466 Add_90_I13_L07002_C132_carry[0] Add_90_I13_L07002_C132_carry[1] _NC4604 _NC4605 _NC4606 HADDX1
X2203 N464 N465 Add_90_I13_L07002_C132_carry[0] _NC4607 _NC4608 _NC4609 HADDX1
X2204 N483 Add_90_I14_L07002_C132_carry[0] Add_90_I14_L07002_C132_carry[1] _NC4610 _NC4611 _NC4612 HADDX1
X2205 N481 N482 Add_90_I14_L07002_C132_carry[0] _NC4613 _NC4614 _NC4615 HADDX1
X2206 Add_90_I15_L07002_C132_carry[1] N501 Add_90_I15_L07002_C132_carry[2] _NC4616 _NC4617 _NC4618 HADDX1
X2207 Add_90_I15_L07002_C132_carry[0] N500 Add_90_I15_L07002_C132_carry[1] _NC4619 _NC4620 _NC4621 HADDX1
X2208 N498 N499 Add_90_I15_L07002_C132_carry[0] _NC4622 _NC4623 _NC4624 HADDX1
X2209 N518 Add_90_I16_L07002_C132_carry[1] Add_90_I16_L07002_C132_carry[2] _NC4625 _NC4626 _NC4627 HADDX1
X2210 N517 Add_90_I16_L07002_C132_carry[0] Add_90_I16_L07002_C132_carry[1] _NC4628 _NC4629 _NC4630 HADDX1
X2211 N516 N515 Add_90_I16_L07002_C132_carry[0] _NC4631 _NC4632 _NC4633 HADDX1
X2212 N533 N532 Add_90_I17_L07002_C132_carry[0] _NC4634 _NC4635 _NC4636 HADDX1
X2213 N552 Add_90_I18_L07002_C132_carry[1] Add_90_I18_L07002_C132_carry[2] _NC4637 _NC4638 _NC4639 HADDX1
X2214 Add_90_I18_L07002_C132_carry[0] N551 Add_90_I18_L07002_C132_carry[1] _NC4640 _NC4641 _NC4642 HADDX1
X2215 N550 N549 Add_90_I18_L07002_C132_carry[0] _NC4643 _NC4644 _NC4645 HADDX1
X2216 Add_90_I19_L07002_C132_carry[1] N569 Add_90_I19_L07002_C132_carry[2] _NC4646 _NC4647 _NC4648 HADDX1
X2217 N566 N567 Add_90_I19_L07002_C132_carry[0] _NC4649 _NC4650 _NC4651 HADDX1
X2218 Add_90_I20_L07002_C132_carry[0] N585 Add_90_I20_L07002_C132_carry[1] _NC4652 _NC4653 _NC4654 HADDX1
X2219 N583 N584 Add_90_I20_L07002_C132_carry[0] _NC4655 _NC4656 _NC4657 HADDX1
X2220 Add_90_I21_L07002_C132_carry[0] N602 Add_90_I21_L07002_C132_carry[1] _NC4658 _NC4659 _NC4660 HADDX1
X2221 N600 N601 Add_90_I21_L07002_C132_carry[0] _NC4661 _NC4662 _NC4663 HADDX1
X2222 N620 Add_90_I22_L07002_C132_carry[1] Add_90_I22_L07002_C132_carry[2] _NC4664 _NC4665 _NC4666 HADDX1
X2223 N619 Add_90_I22_L07002_C132_carry[0] Add_90_I22_L07002_C132_carry[1] _NC4667 _NC4668 _NC4669 HADDX1
X2224 N617 N618 Add_90_I22_L07002_C132_carry[0] _NC4670 _NC4671 _NC4672 HADDX1
X2225 N634 N635 Add_90_I23_L07002_C132_carry[0] _NC4673 _NC4674 _NC4675 HADDX1
X2226 Add_90_I24_L07002_C132_carry[1] N654 Add_90_I24_L07002_C132_carry[2] _NC4676 _NC4677 _NC4678 HADDX1
X2227 Add_90_I24_L07002_C132_carry[0] N653 Add_90_I24_L07002_C132_carry[1] _NC4679 _NC4680 _NC4681 HADDX1
X2228 N651 N652 Add_90_I24_L07002_C132_carry[0] _NC4682 _NC4683 _NC4684 HADDX1
X2229 N670 Add_90_I25_L07002_C132_carry[0] Add_90_I25_L07002_C132_carry[1] _NC4685 _NC4686 _NC4687 HADDX1
X2230 N669 N668 Add_90_I25_L07002_C132_carry[0] _NC4688 _NC4689 _NC4690 HADDX1
X2231 Add_90_I26_L07002_C132_carry[0] N687 Add_90_I26_L07002_C132_carry[1] _NC4691 _NC4692 _NC4693 HADDX1
X2232 N686 N685 Add_90_I26_L07002_C132_carry[0] _NC4694 _NC4695 _NC4696 HADDX1
X2233 Add_90_I27_L07002_C132_carry[1] N705 Add_90_I27_L07002_C132_carry[2] _NC4697 _NC4698 _NC4699 HADDX1
X2234 Add_90_I27_L07002_C132_carry[0] N704 Add_90_I27_L07002_C132_carry[1] _NC4700 _NC4701 _NC4702 HADDX1
X2235 N702 N703 Add_90_I27_L07002_C132_carry[0] _NC4703 _NC4704 _NC4705 HADDX1
X2236 N721 Add_90_I28_L07002_C132_carry[0] Add_90_I28_L07002_C132_carry[1] _NC4706 _NC4707 _NC4708 HADDX1
X2237 N719 N720 Add_90_I28_L07002_C132_carry[0] _NC4709 _NC4710 _NC4711 HADDX1
X2238 N736 N737 Add_90_I29_L07002_C132_carry[0] _NC4712 _NC4713 _NC4714 HADDX1
X2239 N755 Add_90_I30_L07002_C132_carry[0] Add_90_I30_L07002_C132_carry[1] _NC4715 _NC4716 _NC4717 HADDX1
X2240 N753 N754 Add_90_I30_L07002_C132_carry[0] _NC4718 _NC4719 _NC4720 HADDX1
X2241 Add_90_I31_L07002_C132_carry[1] N773 Add_90_I31_L07002_C132_carry[2] _NC4721 _NC4722 _NC4723 HADDX1
X2242 Add_90_I31_L07002_C132_carry[0] N772 Add_90_I31_L07002_C132_carry[1] _NC4724 _NC4725 _NC4726 HADDX1
X2243 N770 N771 Add_90_I31_L07002_C132_carry[0] _NC4727 _NC4728 _NC4729 HADDX1
X2244 N790 Add_90_I32_L07002_C132_carry[1] Add_90_I32_L07002_C132_carry[2] _NC4730 _NC4731 _NC4732 HADDX1
X2245 Add_90_I32_L07002_C132_carry[0] N789 Add_90_I32_L07002_C132_carry[1] _NC4733 _NC4734 _NC4735 HADDX1
X2246 N787 N788 Add_90_I32_L07002_C132_carry[0] _NC4736 _NC4737 _NC4738 HADDX1
X2247 N804 N805 Add_90_I33_L07002_C132_carry[0] _NC4739 _NC4740 _NC4741 HADDX1
X2248 N824 Add_90_I34_L07002_C132_carry[1] Add_90_I34_L07002_C132_carry[2] _NC4742 _NC4743 _NC4744 HADDX1
X2249 Add_90_I34_L07002_C132_carry[0] N823 Add_90_I34_L07002_C132_carry[1] _NC4745 _NC4746 _NC4747 HADDX1
X2250 N821 N822 Add_90_I34_L07002_C132_carry[0] _NC4748 _NC4749 _NC4750 HADDX1
X2251 N841 Add_90_I35_L07002_C132_carry[1] Add_90_I35_L07002_C132_carry[2] _NC4751 _NC4752 _NC4753 HADDX1
X2252 Add_90_I35_L07002_C132_carry[0] N840 Add_90_I35_L07002_C132_carry[1] _NC4754 _NC4755 _NC4756 HADDX1
X2253 N838 N839 Add_90_I35_L07002_C132_carry[0] _NC4757 _NC4758 _NC4759 HADDX1
X2254 Add_90_I36_L07002_C132_carry[2] N859 Add_90_I36_L07002_C132_carry[3] _NC4760 _NC4761 _NC4762 HADDX1
X2255 N858 Add_90_I36_L07002_C132_carry[1] Add_90_I36_L07002_C132_carry[2] _NC4763 _NC4764 _NC4765 HADDX1
X2256 Add_90_I36_L07002_C132_carry[0] N857 Add_90_I36_L07002_C132_carry[1] _NC4766 _NC4767 _NC4768 HADDX1
X2257 N856 N855 Add_90_I36_L07002_C132_carry[0] _NC4769 _NC4770 _NC4771 HADDX1
X2258 Add_90_I37_L07002_C132_carry[1] N875 Add_90_I37_L07002_C132_carry[2] _NC4772 _NC4773 _NC4774 HADDX1
X2259 Add_90_I37_L07002_C132_carry[0] N874 Add_90_I37_L07002_C132_carry[1] _NC4775 _NC4776 _NC4777 HADDX1
X2260 N872 N873 Add_90_I37_L07002_C132_carry[0] _NC4778 _NC4779 _NC4780 HADDX1
X2261 N892 Add_90_I38_L07002_C132_carry[1] Add_90_I38_L07002_C132_carry[2] _NC4781 _NC4782 _NC4783 HADDX1
X2262 N891 Add_90_I38_L07002_C132_carry[0] Add_90_I38_L07002_C132_carry[1] _NC4784 _NC4785 _NC4786 HADDX1
X2263 N890 N889 Add_90_I38_L07002_C132_carry[0] _NC4787 _NC4788 _NC4789 HADDX1
X2264 Add_90_I39_L07002_C132_carry[0] N908 Add_90_I39_L07002_C132_carry[1] _NC4790 _NC4791 _NC4792 HADDX1
X2265 N906 N907 Add_90_I39_L07002_C132_carry[0] _NC4793 _NC4794 _NC4795 HADDX1
X2266 N926 Add_90_I40_L07002_C132_carry[1] Add_90_I40_L07002_C132_carry[2] _NC4796 _NC4797 _NC4798 HADDX1
X2267 N925 Add_90_I40_L07002_C132_carry[0] Add_90_I40_L07002_C132_carry[1] _NC4799 _NC4800 _NC4801 HADDX1
X2268 N924 N923 Add_90_I40_L07002_C132_carry[0] _NC4802 _NC4803 _NC4804 HADDX1
X2269 Add_90_I41_L07002_C132_carry[1] N943 Add_90_I41_L07002_C132_carry[2] _NC4805 _NC4806 _NC4807 HADDX1
X2270 N940 N941 Add_90_I41_L07002_C132_carry[0] _NC4808 _NC4809 _NC4810 HADDX1
X2271 Add_90_I42_L07002_C132_carry[1] N960 Add_90_I42_L07002_C132_carry[2] _NC4811 _NC4812 _NC4813 HADDX1
X2272 Add_90_I42_L07002_C132_carry[0] N959 Add_90_I42_L07002_C132_carry[1] _NC4814 _NC4815 _NC4816 HADDX1
X2273 N957 N958 Add_90_I42_L07002_C132_carry[0] _NC4817 _NC4818 _NC4819 HADDX1
X2274 N978 Add_90_I43_L07002_C132_carry[2] Add_90_I43_L07002_C132_carry[3] _NC4820 _NC4821 _NC4822 HADDX1
X2275 N977 Add_90_I43_L07002_C132_carry[1] Add_90_I43_L07002_C132_carry[2] _NC4823 _NC4824 _NC4825 HADDX1
X2276 N976 Add_90_I43_L07002_C132_carry[0] Add_90_I43_L07002_C132_carry[1] _NC4826 _NC4827 _NC4828 HADDX1
X2277 N975 N974 Add_90_I43_L07002_C132_carry[0] _NC4829 _NC4830 _NC4831 HADDX1
X2278 Add_90_I44_L07002_C132_carry[1] N994 Add_90_I44_L07002_C132_carry[2] _NC4832 _NC4833 _NC4834 HADDX1
X2279 Add_90_I44_L07002_C132_carry[0] N993 Add_90_I44_L07002_C132_carry[1] _NC4835 _NC4836 _NC4837 HADDX1
X2280 N991 N992 Add_90_I44_L07002_C132_carry[0] _NC4838 _NC4839 _NC4840 HADDX1
X2281 N1011 Add_90_I45_L07002_C132_carry[1] Add_90_I45_L07002_C132_carry[2] _NC4841 _NC4842 _NC4843 HADDX1
X2282 N1010 Add_90_I45_L07002_C132_carry[0] Add_90_I45_L07002_C132_carry[1] _NC4844 _NC4845 _NC4846 HADDX1
X2283 N1009 N1008 Add_90_I45_L07002_C132_carry[0] _NC4847 _NC4848 _NC4849 HADDX1
X2284 N1029 Add_90_I46_L07002_C132_carry[2] Add_90_I46_L07002_C132_carry[3] _NC4850 _NC4851 _NC4852 HADDX1
X2285 N1028 Add_90_I46_L07002_C132_carry[1] Add_90_I46_L07002_C132_carry[2] _NC4853 _NC4854 _NC4855 HADDX1
X2286 N1027 Add_90_I46_L07002_C132_carry[0] Add_90_I46_L07002_C132_carry[1] _NC4856 _NC4857 _NC4858 HADDX1
X2287 N1026 N1025 Add_90_I46_L07002_C132_carry[0] _NC4859 _NC4860 _NC4861 HADDX1
X2288 N1677 N1678 Add_105_I6_L07002_C136_carry[2] _NC4862 _NC4863 _NC4864 HADDX1
X2289 N183 Add_105_I7_L07002_C136_carry[0] Add_105_I7_L07002_C136_carry[1] _NC4865 _NC4866 _NC4867 HADDX1
X2290 Add_105_I8_L07002_C136_carry[0] N1710 Add_105_I8_L07002_C136_carry[1] _NC4868 _NC4869 _NC4870 HADDX1
X2291 Add_105_I10_L07002_C136_carry[0] N1742 Add_105_I10_L07002_C136_carry[1] _NC4871 _NC4872 _NC4873 HADDX1
X2292 N1756 N90 Add_105_I11_L07002_C136_carry[0] _NC4874 _NC4875 _NC4876 HADDX1
X2293 N1773 N1772 Add_105_I12_L07002_C136_carry[0] _NC4877 _NC4878 _NC4879 HADDX1
X2294 N1804 N1805 Add_105_I14_L07002_C136_carry[0] _NC4880 _NC4881 _NC4882 HADDX1
X2295 N1822 Add_105_I15_L07002_C136_carry[0] Add_105_I15_L07002_C136_carry[1] _NC4883 _NC4884 _NC4885 HADDX1
X2296 N1820 N1821 Add_105_I15_L07002_C136_carry[0] _NC4886 _NC4887 _NC4888 HADDX1
X2297 N1836 N1837 Add_105_I16_L07002_C136_carry[0] _NC4889 _NC4890 _NC4891 HADDX1
X2298 N1854 Add_105_I17_L07002_C136_carry[0] Add_105_I17_L07002_C136_carry[1] _NC4892 _NC4893 _NC4894 HADDX1
X2299 N1853 N1852 Add_105_I17_L07002_C136_carry[0] _NC4895 _NC4896 _NC4897 HADDX1
X2300 Add_105_I18_L07002_C136_carry[0] N1870 Add_105_I18_L07002_C136_carry[1] _NC4898 _NC4899 _NC4900 HADDX1
X2301 N1868 N1869 Add_105_I18_L07002_C136_carry[0] _NC4901 _NC4902 _NC4903 HADDX1
X2302 N1884 N1885 Add_105_I19_L07002_C136_carry[0] _NC4904 _NC4905 _NC4906 HADDX1
X2303 N1900 N1901 Add_105_I20_L07002_C136_carry[0] _NC4907 _NC4908 _NC4909 HADDX1
X2304 N1916 N1917 Add_105_I21_L07002_C136_carry[0] _NC4910 _NC4911 _NC4912 HADDX1
X2305 N1932 N1933 Add_105_I22_L07002_C136_carry[0] _NC4913 _NC4914 _NC4915 HADDX1
X2306 N1948 N1949 Add_105_I23_L07002_C136_carry[0] _NC4916 _NC4917 _NC4918 HADDX1
X2307 N1964 N1965 Add_105_I24_L07002_C136_carry[0] _NC4919 _NC4920 _NC4921 HADDX1
X2308 Add_105_I25_L07002_C136_carry[1] N1983 Add_105_I25_L07002_C136_carry[2] _NC4922 _NC4923 _NC4924 HADDX1
X2309 N1980 N1981 Add_105_I25_L07002_C136_carry[0] _NC4925 _NC4926 _NC4927 HADDX1
X2310 N1996 N1997 Add_105_I26_L07002_C136_carry[0] _NC4928 _NC4929 _NC4930 HADDX1
X2311 Add_105_I27_L07002_C136_carry[0] N82 Add_105_I27_L07002_C136_carry[1] _NC4931 _NC4932 _NC4933 HADDX1
X2312 N2046 Add_105_I29_L07002_C136_carry[0] Add_105_I29_L07002_C136_carry[1] _NC4934 _NC4935 _NC4936 HADDX1
X2313 N2044 N2045 Add_105_I29_L07002_C136_carry[0] _NC4937 _NC4938 _NC4939 HADDX1
X2314 N2063 Add_105_I30_L07002_C136_carry[1] Add_105_I30_L07002_C136_carry[2] _NC4940 _NC4941 _NC4942 HADDX1
X2315 N2060 N2061 Add_105_I30_L07002_C136_carry[0] _NC4943 _NC4944 _NC4945 HADDX1
X2316 Add_105_I31_L07002_C136_carry[1] N2079 Add_105_I31_L07002_C136_carry[2] _NC4946 _NC4947 _NC4948 HADDX1
X2317 N2076 N2077 Add_105_I31_L07002_C136_carry[0] _NC4949 _NC4950 _NC4951 HADDX1
X2318 Add_105_I33_L07002_C136_carry[0] N2110 Add_105_I33_L07002_C136_carry[1] _NC4952 _NC4953 _NC4954 HADDX1
X2319 N2108 N2109 Add_105_I33_L07002_C136_carry[0] _NC4955 _NC4956 _NC4957 HADDX1
X2320 Add_105_I34_L07002_C136_carry[1] N2127 Add_105_I34_L07002_C136_carry[2] _NC4958 _NC4959 _NC4960 HADDX1
X2321 N2143 Add_105_I35_L07002_C136_carry[1] Add_105_I35_L07002_C136_carry[2] _NC4961 _NC4962 _NC4963 HADDX1
X2322 N2140 N2141 Add_105_I35_L07002_C136_carry[0] _NC4964 _NC4965 _NC4966 HADDX1
X2323 Add_105_I36_L07002_C136_carry[1] N2159 Add_105_I36_L07002_C136_carry[2] _NC4967 _NC4968 _NC4969 HADDX1
X2324 Add_105_I36_L07002_C136_carry[0] N2158 Add_105_I36_L07002_C136_carry[1] _NC4970 _NC4971 _NC4972 HADDX1
X2325 N2156 N2157 Add_105_I36_L07002_C136_carry[0] _NC4973 _NC4974 _NC4975 HADDX1
X2326 Add_105_I37_L07002_C136_carry[0] N2174 Add_105_I37_L07002_C136_carry[1] _NC4976 _NC4977 _NC4978 HADDX1
X2327 N2172 N2173 Add_105_I37_L07002_C136_carry[0] _NC4979 _NC4980 _NC4981 HADDX1
X2328 N2189 N2188 Add_105_I38_L07002_C136_carry[0] _NC4982 _NC4983 _NC4984 HADDX1
X2329 N2220 N2221 Add_105_I40_L07002_C136_carry[0] _NC4985 _NC4986 _NC4987 HADDX1
X2330 Add_105_I42_L07002_C136_carry[1] N2255 Add_105_I42_L07002_C136_carry[2] _NC4988 _NC4989 _NC4990 HADDX1
X2331 N2271 Add_105_I43_L07002_C136_carry[1] Add_105_I43_L07002_C136_carry[2] _NC4991 _NC4992 _NC4993 HADDX1
X2332 N2270 Add_105_I43_L07002_C136_carry[0] Add_105_I43_L07002_C136_carry[1] _NC4994 _NC4995 _NC4996 HADDX1
X2333 N2269 N2268 Add_105_I43_L07002_C136_carry[0] _NC4997 _NC4998 _NC4999 HADDX1
X2334 N2284 N2285 Add_105_I44_L07002_C136_carry[0] _NC5000 _NC5001 _NC5002 HADDX1
X2335 N2302 Add_105_I45_L07002_C136_carry[0] Add_105_I45_L07002_C136_carry[1] _NC5003 _NC5004 _NC5005 HADDX1
X2336 N2300 N2301 Add_105_I45_L07002_C136_carry[0] _NC5006 _NC5007 _NC5008 HADDX1
X2337 N2316 N2317 Add_105_I46_L07002_C136_carry[0] _NC5009 _NC5010 _NC5011 HADDX1
X2338 N2333 N2332 Add_105_I47_L07002_C136_carry[0] _NC5012 _NC5013 _NC5014 HADDX1
X2339 N2349 N2348 Add_105_I48_L07002_C136_carry[0] _NC5015 _NC5016 _NC5017 HADDX1
X2340 S_exp_10a[0] S_exp_10a[1] S_exp_10a[2] S_exp_10a[3] S_exp_10a[4] S_exp_10a[5] S_exp_10a[6] S_exp_10a[7] S_exp_10a[8] S_exp_10a[9] S_zeros[0] S_zeros[1] S_zeros[2] S_zeros[3] S_zeros[4] S_zeros[5] Vss Vss Vss Vss Vss S_exp_10b[0] S_exp_10b[1] S_exp_10b[2] S_exp_10b[3] S_exp_10b[4] S_exp_10b[5] S_exp_10b[6] S_exp_10b[7] S_exp_10b[8] S_exp_10b[9] _NC5018 post_norm_mul_DW01_sub_2
X2341 S_zeros[0] S_zeros[1] S_zeros[2] S_zeros[3] S_zeros[4] S_zeros[5] S_exp_10a[0] S_exp_10a[1] S_exp_10a[2] S_exp_10a[3] S_exp_10a[4] S_exp_10a[5] Vss N3019 N3020 N3021 N3022 N3023 N3024 _NC5019 post_norm_mul_DW01_sub_1
X2342 S_frac2a[23] S_frac2a[24] S_frac2a[25] S_frac2a[26] S_frac2a[27] S_frac2a[28] S_frac2a[29] S_frac2a[30] S_frac2a[31] S_frac2a[32] S_frac2a[33] S_frac2a[34] S_frac2a[35] S_frac2a[36] S_frac2a[37] S_frac2a[38] S_frac2a[39] S_frac2a[40] S_frac2a[41] S_frac2a[42] S_frac2a[43] S_frac2a[44] S_frac2a[45] S_frac2a[46] S_frac2a[47] N3278 N3279 N3280 N3281 N3282 N3283 N3284 N3285 N3286 N3287 N3288 N3289 N3290 N3291 N3292 N3293 N3294 N3295 N3296 N3297 N3298 N3299 N3300 N3301 N3302 post_norm_mul_DW01_inc_1
X2343 S_expo2b[0] S_expo2b[1] S_expo2b[2] S_expo2b[3] S_expo2b[4] S_expo2b[5] S_expo2b[6] S_expo2b[7] S_expo2b[8] N3346 N3347 N3348 N3349 N3350 N3351 N3352 N3353 N3354 post_norm_mul_DW01_inc_0
X2344 N122 N127 N332 _NC5020 _NC5021 XNOR2X1
X2345 N341 N123 N1091 N332 N346 _NC5022 _NC5023 AO22X1
X2346 N356 N130 S_fract_48_i[41] N346 N362 _NC5024 _NC5025 AO22X1
X2347 N373 N137 S_fract_48_i[40] N362 N379 _NC5026 _NC5027 AO22X1
X2348 N390 N144 S_fract_48_i[39] N379 N396 _NC5028 _NC5029 AO22X1
X2349 N407 N145 S_fract_48_i[38] N396 N413 _NC5030 _NC5031 AO22X1
X2350 N424 N146 S_fract_48_i[37] N413 N430 _NC5032 _NC5033 AO22X1
X2351 N441 N152 S_fract_48_i[36] N430 N447 _NC5034 _NC5035 AO22X1
X2352 N458 N154 S_fract_48_i[35] N447 N464 _NC5036 _NC5037 AO22X1
X2353 N475 N156 S_fract_48_i[34] N464 N481 _NC5038 _NC5039 AO22X1
X2354 N492 N158 S_fract_48_i[33] N481 N498 _NC5040 _NC5041 AO22X1
X2355 N509 N160 S_fract_48_i[32] N498 N515 _NC5042 _NC5043 AO22X1
X2356 N526 N162 S_fract_48_i[31] N515 N532 _NC5044 _NC5045 AO22X1
X2357 N543 N164 N1078 N532 N549 _NC5046 _NC5047 AO22X1
X2358 N560 N170 S_fract_48_i[29] N549 N566 _NC5048 _NC5049 AO22X1
X2359 N577 N171 S_fract_48_i[28] N566 N583 _NC5050 _NC5051 AO22X1
X2360 N594 N172 S_fract_48_i[27] N583 N600 _NC5052 _NC5053 AO22X1
X2361 N611 N173 S_fract_48_i[26] N600 N617 _NC5054 _NC5055 AO22X1
X2362 N1241 N174 S_fract_48_i[25] N617 N634 _NC5056 _NC5057 AO22X1
X2363 N645 N177 N1146 N634 N651 _NC5058 _NC5059 AO22X1
X2364 N662 N182 S_fract_48_i[23] N651 N668 _NC5060 _NC5061 AO22X1
X2365 N679 N189 S_fract_48_i[22] N668 N685 _NC5062 _NC5063 AO22X1
X2366 N696 N196 S_fract_48_i[21] N685 N702 _NC5064 _NC5065 AO22X1
X2367 N713 N197 S_fract_48_i[20] N702 N719 _NC5066 _NC5067 AO22X1
X2368 N730 N198 S_fract_48_i[19] N719 N736 _NC5068 _NC5069 AO22X1
X2369 N747 N204 N1074 N736 N753 _NC5070 _NC5071 AO22X1
X2370 N764 N206 S_fract_48_i[17] N753 N770 _NC5072 _NC5073 AO22X1
X2371 N781 N208 S_fract_48_i[16] N770 N787 _NC5074 _NC5075 AO22X1
X2372 N798 N210 S_fract_48_i[15] N787 N804 _NC5076 _NC5077 AO22X1
X2373 N815 N212 S_fract_48_i[14] N804 N821 _NC5078 _NC5079 AO22X1
X2374 N832 N214 S_fract_48_i[13] N821 N838 _NC5080 _NC5081 AO22X1
X2375 N849 N215 N1072 N838 N855 _NC5082 _NC5083 AO22X1
X2376 N866 N221 S_fract_48_i[11] N855 N872 _NC5084 _NC5085 AO22X1
X2377 N883 N222 S_fract_48_i[10] N872 N889 _NC5086 _NC5087 AO22X1
X2378 N900 N223 S_fract_48_i[9] N889 N906 _NC5088 _NC5089 AO22X1
X2379 N1240 N224 S_fract_48_i[8] N906 N923 _NC5090 _NC5091 AO22X1
X2380 N934 N225 S_fract_48_i[7] N923 N940 _NC5092 _NC5093 AO22X1
X2381 N951 N226 N1086 N940 N957 _NC5094 _NC5095 AO22X1
X2382 N968 N227 N1082 N957 N974 _NC5096 _NC5097 AO22X1
X2383 N985 N229 S_fract_48_i[4] N974 N991 _NC5098 _NC5099 AO22X1
X2384 N1002 N231 S_fract_48_i[3] N991 N1008 _NC5100 _NC5101 AO22X1
X2385 N119 N1052 N8000 N8020 _NC5102 _NC5103 AO21X1
X2386 N374 N137 S_fract_48_i[40] N102 N380 _NC5104 _NC5105 AO22X1
X2387 N408 N145 S_fract_48_i[38] N8330 N414 _NC5106 _NC5107 AO22X1
X2388 N459 N154 S_fract_48_i[35] N4000 N465 _NC5108 _NC5109 AO22X1
X2389 N493 N158 S_fract_48_i[33] N894 N499 _NC5110 _NC5111 AO22X1
X2390 N544 N164 N1078 N9610 N550 _NC5112 _NC5113 AO22X1
X2391 N561 N170 S_fract_48_i[29] N8420 N567 _NC5114 _NC5115 AO22X1
X2392 N578 N171 S_fract_48_i[28] N8180 N584 _NC5116 _NC5117 AO22X1
X2393 N612 N173 S_fract_48_i[26] N846 N618 _NC5118 _NC5119 AO22X1
X2394 N629 N174 S_fract_48_i[25] N65 N635 _NC5120 _NC5121 AO22X1
X2395 N646 N177 N1146 N635 N652 _NC5122 _NC5123 AO22X1
X2396 N680 N189 S_fract_48_i[22] N980 N686 _NC5124 _NC5125 AO22X1
X2397 N697 N196 S_fract_48_i[21] N8490 N703 _NC5126 _NC5127 AO22X1
X2398 N731 N198 S_fract_48_i[19] N163 N737 _NC5128 _NC5129 AO22X1
X2399 N748 N204 N1075 N150 N754 _NC5130 _NC5131 AO22X1
X2400 N765 N206 S_fract_48_i[17] N200 N771 _NC5132 _NC5133 AO22X1
X2401 N816 N212 S_fract_48_i[14] N218 N822 _NC5134 _NC5135 AO22X1
X2402 N833 N214 S_fract_48_i[13] N56 N839 _NC5136 _NC5137 AO22X1
X2403 N850 N215 N1072 N839 N856 _NC5138 _NC5139 AO22X1
X2404 N867 N221 S_fract_48_i[11] N856 N873 _NC5140 _NC5141 AO22X1
X2405 N901 N223 S_fract_48_i[9] N9270 N907 _NC5142 _NC5143 AO22X1
X2406 N935 N225 S_fract_48_i[7] N9430 N941 _NC5144 _NC5145 AO22X1
X2407 N952 N226 N1086 N83 N958 _NC5146 _NC5147 AO22X1
X2408 N969 N227 N1082 N958 N975 _NC5148 _NC5149 AO22X1
X2409 N986 N229 S_fract_48_i[4] N975 N992 _NC5150 _NC5151 AO22X1
X2410 N1003 N231 S_fract_48_i[3] N992 N1009 _NC5152 _NC5153 AO22X1
X2411 N343 N123 N1089 N334 N348 _NC5154 _NC5155 AO22X1
X2412 N409 N145 S_fract_48_i[38] N4010 N415 _NC5156 _NC5157 AO22X1
X2413 N443 N152 S_fract_48_i[36] N8340 N449 _NC5158 _NC5159 AO22X1
X2414 N477 N156 S_fract_48_i[34] N166 N483 _NC5160 _NC5161 AO22X1
X2415 N494 N158 S_fract_48_i[33] N9510 N500 _NC5162 _NC5163 AO22X1
X2416 N511 N160 S_fract_48_i[32] N882 N517 _NC5164 _NC5165 AO22X1
X2417 N545 N164 N1077 N8050 N551 _NC5166 _NC5167 AO22X1
X2418 N630 N174 S_fract_48_i[25] N10130 N636 _NC5168 _NC5169 AO22X1
X2419 N664 N182 S_fract_48_i[23] N87 N670 _NC5170 _NC5171 AO22X1
X2420 N715 N197 S_fract_48_i[20] N10280 N721 _NC5172 _NC5173 AO22X1
X2421 N749 N204 N1074 N9860 N755 _NC5174 _NC5175 AO22X1
X2422 N766 N206 S_fract_48_i[17] N8730 N772 _NC5176 _NC5177 AO22X1
X2423 N783 N208 S_fract_48_i[16] N4130 N789 _NC5178 _NC5179 AO22X1
X2424 N851 N215 N1071 N110 N857 _NC5180 _NC5181 AO22X1
X2425 N902 N223 S_fract_48_i[9] N9530 N908 _NC5182 _NC5183 AO22X1
X2426 N953 N226 N1085 N89 N959 _NC5184 _NC5185 AO22X1
X2427 N970 N227 N1081 N76 N976 _NC5186 _NC5187 AO22X1
X2428 N987 N229 S_fract_48_i[4] N976 N993 _NC5188 _NC5189 AO22X1
X2429 N1004 N231 S_fract_48_i[3] N993 N1010 _NC5190 _NC5191 AO22X1
X2430 N344 N123 N349 _NC5192 _NC5193 AND2X1
X2431 N444 N152 S_fract_48_i[36] N830 N450 _NC5194 _NC5195 AO22X1
X2432 N529 N162 S_fract_48_i[31] N5680 N535 _NC5196 _NC5197 AO22X1
X2433 N546 N164 N1077 N949 N552 _NC5198 _NC5199 AO22X1
X2434 N580 N171 S_fract_48_i[28] N829 N586 _NC5200 _NC5201 AO22X1
X2435 N614 N173 S_fract_48_i[26] N8550 N620 _NC5202 _NC5203 AO22X1
X2436 N631 N174 S_fract_48_i[25] N1015 N637 _NC5204 _NC5205 AO22X1
X2437 N665 N182 S_fract_48_i[23] N864 N671 _NC5206 _NC5207 AO22X1
X2438 N716 N197 S_fract_48_i[20] N812 N722 _NC5208 _NC5209 AO22X1
X2439 N750 N204 N1075 N155 N756 _NC5210 _NC5211 AO22X1
X2440 N784 N208 S_fract_48_i[16] N5960 N790 _NC5212 _NC5213 AO22X1
X2441 N801 N210 S_fract_48_i[15] N9600 N807 _NC5214 _NC5215 AO22X1
X2442 N852 N215 N1071 N916 N858 _NC5216 _NC5217 AO22X1
X2443 N869 N221 S_fract_48_i[11] N8670 N875 _NC5218 _NC5219 AO22X1
X2444 N903 N223 S_fract_48_i[9] N180 N909 _NC5220 _NC5221 AO22X1
X2445 N954 N226 N1087 N86 N960 _NC5222 _NC5223 AO22X1
X2446 N971 N227 N1081 N188 N977 _NC5224 _NC5225 AO22X1
X2447 N988 N229 S_fract_48_i[4] N8890 N994 _NC5226 _NC5227 AO22X1
X2448 N411 N145 S_fract_48_i[38] N4510 N417 _NC5228 _NC5229 AO22X1
X2449 N632 N174 S_fract_48_i[25] N10200 N638 _NC5230 _NC5231 AO22X1
X2450 N717 N197 S_fract_48_i[20] N810 N723 _NC5232 _NC5233 AO22X1
X2451 N785 N208 S_fract_48_i[16] N6150 N791 _NC5234 _NC5235 AO22X1
X2452 N836 N214 S_fract_48_i[13] N3570 N842 _NC5236 _NC5237 AO22X1
X2453 N853 N215 N1071 N9740 N859 _NC5238 _NC5239 AO22X1
X2454 N955 N226 N1085 N8040 N961 _NC5240 _NC5241 AO22X1
X2455 N972 N227 N1081 N10220 N978 _NC5242 _NC5243 AO22X1
X2456 N412 N145 S_fract_48_i[38] N401 N418 _NC5244 _NC5245 AO22X1
X2457 N446 N152 S_fract_48_i[36] N8700 N452 _NC5246 _NC5247 AO22X1
X2458 N480 N156 S_fract_48_i[34] N813 N486 _NC5248 _NC5249 AO22X1
X2459 N514 N160 S_fract_48_i[32] N865 N520 _NC5250 _NC5251 AO22X1
X2460 N531 N162 S_fract_48_i[31] N862 N537 _NC5252 _NC5253 AO22X1
X2461 N548 N164 N1078 N6340 N554 _NC5254 _NC5255 AO22X1
X2462 N599 N172 S_fract_48_i[27] N9360 N605 _NC5256 _NC5257 AO22X1
X2463 N616 N173 S_fract_48_i[26] N9560 N622 _NC5258 _NC5259 AO22X1
X2464 N633 N174 S_fract_48_i[25] N8920 N639 _NC5260 _NC5261 AO22X1
X2465 N667 N182 S_fract_48_i[23] N9730 N673 _NC5262 _NC5263 AO22X1
X2466 N684 N189 S_fract_48_i[22] N9220 N690 _NC5264 _NC5265 AO22X1
X2467 N718 N197 S_fract_48_i[20] N963 N724 _NC5266 _NC5267 AO22X1
X2468 N752 N204 N1075 N9580 N758 _NC5268 _NC5269 AO22X1
X2469 N786 N208 S_fract_48_i[16] N105 N792 _NC5270 _NC5271 AO22X1
X2470 N226 N956 N1085 N142 N962 _NC5272 _NC5273 AO22X1
X2471 N973 N227 N1084 N9940 N979 _NC5274 _NC5275 AO22X1
X2472 N990 N229 S_fract_48_i[4] N97 N996 _NC5276 _NC5277 AO22X1
X2473 N1007 N231 S_fract_48_i[3] N996 N1013 _NC5278 _NC5279 AO22X1
X2474 N1019 N232 N1063 N1008 N1025 _NC5280 _NC5281 AO22X1
X2475 N1020 N232 N1063 N1009 N1026 _NC5282 _NC5283 AO22X1
X2476 N1021 N232 N1063 N1010 N1027 _NC5284 _NC5285 AO22X1
X2477 N1022 N232 N1063 N132 N1028 _NC5286 _NC5287 AO22X1
X2478 N1023 N232 N1063 N10240 N1029 _NC5288 _NC5289 AO22X1
X2479 N1024 N232 N1063 N1013 N1030 _NC5290 _NC5291 AO22X1
X2480 N8000 N68 N7160 _NC5292 _NC5293 AND2X1
X2481 N7990 N7980 N5770 _NC5294 _NC5295 AND2X1
X2482 N379 N574 N396 N5770 N413 N575 N7470 _NC5296 _NC5297 AOI222X1
X2483 N797 N796 N5990 _NC5298 _NC5299 AND2X1
X2484 N685 N6000 N702 N5990 N719 N5980 N7690 _NC5300 _NC5301 AOI222X1
X2485 N1066 N1063 N795 N624 _NC5302 _NC5303 NOR3X0
X2486 N794 N795 N625 _NC5304 _NC5305 AND2X1
X2487 N1036 N624 N625 N1008 N626 N1025 N7910 _NC5306 _NC5307 AO222X1
X2488 N793 N226 N6220 _NC5308 _NC5309 AND2X1
X2489 N6220 N974 N1087 N957 N623 N991 N7920 _NC5310 _NC5311 AO222X1
X2490 N951 N6170 N7900 N6160 N7830 _NC5312 _NC5313 OA22X1
X2491 N7890 N215 N6190 _NC5314 _NC5315 AND2X1
X2492 N855 N1071 N872 N6190 N7840 _NC5316 _NC5317 AOI22X1
X2493 N7890 N7880 N627 _NC5318 _NC5319 OR2X1
X2494 N7860 N7870 N6290 _NC5320 _NC5321 OR2X1
X2495 N900 N627 N1240 N628 N934 N6290 N7850 _NC5322 _NC5323 OA222X1
X2496 N7830 N7840 N7850 N780 _NC5324 _NC5325 NAND3X0
X2497 N6110 N770 N1074 N753 N7810 _NC5326 _NC5327 AO22X1
X2498 N6120 N838 N709 N780 N7810 N7750 _NC5328 _NC5329 AO221X1
X2499 N610 N821 N609 N804 N608 N787 N776 _NC5330 _NC5331 AO222X1
X2500 N7730 N177 N6030 _NC5332 _NC5333 AND2X1
X2501 N651 S_fract_48_i[24] N668 N6030 N7720 _NC5334 _NC5335 AOI22X1
X2502 N7710 N7140 N747 N7150 N7720 N7700 _NC5336 _NC5337 OA221X1
X2503 N7690 N7700 N592 N761 _NC5338 _NC5339 AO21X1
X2504 N7680 N164 N5950 _NC5340 _NC5341 AND2X1
X2505 N549 N1077 N566 N5950 N763 _NC5342 _NC5343 AOI22X1
X2506 N7680 N7670 N6300 _NC5344 _NC5345 OR2X1
X2507 N7650 N7660 N6320 _NC5346 _NC5347 OR2X1
X2508 N594 N6300 N611 N6310 N1241 N6320 N7640 _NC5348 _NC5349 OA222X1
X2509 N761 N762 N763 N7640 N7580 _NC5350 _NC5351 NAND4X0
X2510 N5870 N464 S_fract_48_i[36] N447 N759 _NC5352 _NC5353 AO22X1
X2511 N5880 N532 N6960 N7580 N759 N7530 _NC5354 _NC5355 AO221X1
X2512 N5860 N515 N5850 N498 N5840 N481 N7540 _NC5356 _NC5357 AO222X1
X2513 N7530 N7540 N7490 _NC5358 _NC5359 OR2X1
X2514 N7500 N7510 N5780 _NC5360 _NC5361 AND2X1
X2515 N7490 N1248 N362 N6350 N430 N5780 N7480 _NC5362 _NC5363 AOI222X1
X2516 N744 N1052 N661 N746 N7180 N1632 _NC5364 _NC5365 AO221X1
X2517 N380 N574 N8330 N5770 N414 N575 N7190 _NC5366 _NC5367 AOI222X1
X2518 N8490 N6000 N50 N5990 N163 N5980 N7300 _NC5368 _NC5369 AOI222X1
X2519 N1037 N624 N625 N1009 N626 N1026 N742 _NC5370 _NC5371 AO222X1
X2520 N6220 N975 N1086 N958 N623 N992 N743 _NC5372 _NC5373 AO222X1
X2521 N1232 N6170 N7410 N6160 N7380 _NC5374 _NC5375 OA22X1
X2522 N856 N1072 N873 N6190 N7390 _NC5376 _NC5377 AOI22X1
X2523 N1235 N627 N1234 N628 N1233 N6290 N7400 _NC5378 _NC5379 OA222X1
X2524 N7380 N7390 N7400 N7360 _NC5380 _NC5381 NAND3X0
X2525 N6110 N771 N1075 N200 N7370 _NC5382 _NC5383 AO22X1
X2526 N6120 N839 N709 N7360 N7370 N7340 _NC5384 _NC5385 AO221X1
X2527 N610 N56 N609 N218 N608 N94 N7350 _NC5386 _NC5387 AO222X1
X2528 N652 S_fract_48_i[24] N980 N6030 N7330 _NC5388 _NC5389 AOI22X1
X2529 N7320 N7140 N1236 N7150 N7330 N7310 _NC5390 _NC5391 OA221X1
X2530 N7300 N7310 N592 N726 _NC5392 _NC5393 AO21X1
X2531 N8420 N1078 N8180 N5950 N728 _NC5394 _NC5395 AOI22X1
X2532 N1239 N6300 N1238 N6310 N1237 N6320 N729 _NC5396 _NC5397 OA222X1
X2533 N726 N727 N728 N729 N7240 _NC5398 _NC5399 NAND4X0
X2534 N5870 N120 S_fract_48_i[36] N4000 N725 _NC5400 _NC5401 AO22X1
X2535 N5880 N9610 N6960 N7240 N725 N7220 _NC5402 _NC5403 AO221X1
X2536 N5860 N9400 N5850 N8680 N5840 N894 N7230 _NC5404 _NC5405 AO222X1
X2537 N7220 N7230 N7210 _NC5406 _NC5407 OR2X1
X2538 N7210 N1248 N102 N6350 N8840 N5780 N7200 _NC5408 _NC5409 AOI222X1
X2539 N7160 N1062 N661 N7170 N7180 N1633 _NC5410 _NC5411 AO221X1
X2540 N1231 N6300 N1230 N6310 N1229 N6320 N694 _NC5412 _NC5413 OA222X1
X2541 N1227 N627 N1226 N628 N1225 N6290 N7070 _NC5414 _NC5415 OA222X1
X2542 N1038 N624 N625 N1010 N626 N1027 N712 _NC5416 _NC5417 AO222X1
X2543 N6220 N976 N1087 N76 N623 N993 N7130 _NC5418 _NC5419 AO222X1
X2544 N857 N1072 N187 N6190 N711 _NC5420 _NC5421 AOI22X1
X2545 N710 N6160 N1224 N6170 N711 N708 _NC5422 _NC5423 OA221X1
X2546 N7070 N708 N1330 N7030 _NC5424 _NC5425 AO21X1
X2547 N8730 N1075 N4130 N6110 N7050 _NC5426 _NC5427 AOI22X1
X2548 N181 N608 N213 N609 N63 N610 N7060 _NC5428 _NC5429 AOI222X1
X2549 N7030 N7040 N7050 N7060 N7010 _NC5430 _NC5431 NAND4X0
X2550 N6030 N9710 N1146 N87 N7020 _NC5432 _NC5433 AO22X1
X2551 N1321 N9860 N1320 N7010 N7020 N6990 _NC5434 _NC5435 AO221X1
X2552 N5980 N9190 N5990 N10280 N6000 N10040 N7000 _NC5436 _NC5437 AO222X1
X2553 N153 N1078 N8380 N5950 N6980 _NC5438 _NC5439 AOI22X1
X2554 N6970 N592 N1228 N593 N6980 N695 _NC5440 _NC5441 OA221X1
X2555 N694 N695 N1291 N6900 _NC5442 _NC5443 AO21X1
X2556 N9420 S_fract_48_i[36] N166 N5870 N692 _NC5444 _NC5445 AOI22X1
X2557 N9510 N5840 N882 N5850 N517 N5860 N693 _NC5446 _NC5447 AOI222X1
X2558 N6900 N691 N692 N693 N6880 _NC5448 _NC5449 NAND4X0
X2559 N5780 N8340 N6350 N9900 N6890 _NC5450 _NC5451 AO22X1
X2560 N1248 N6880 N5770 N4010 N6890 N6850 _NC5452 _NC5453 AO221X1
X2561 N575 N983 N574 N14 N6870 N6860 _NC5454 _NC5455 AO221X1
X2562 N1223 N6300 N1222 N6310 N1221 N6320 N6670 _NC5456 _NC5457 OA222X1
X2563 N1219 N627 N1218 N628 N1217 N6290 N6790 _NC5458 _NC5459 OA222X1
X2564 N1039 N624 N625 N132 N626 N1028 N6830 _NC5460 _NC5461 AO222X1
X2565 N6220 N8890 N1085 N188 N623 N994 N6840 _NC5462 _NC5463 AO222X1
X2566 N8670 N1071 N217 N6190 N6820 _NC5464 _NC5465 AOI22X1
X2567 N6810 N6160 N1216 N6170 N6820 N6800 _NC5466 _NC5467 OA221X1
X2568 N6790 N6800 N1330 N675 _NC5468 _NC5469 AO21X1
X2569 N880 N1074 N5960 N6110 N677 _NC5470 _NC5471 AOI22X1
X2570 N9600 N608 N139 N609 N16 N610 N678 _NC5472 _NC5473 AOI222X1
X2571 N675 N676 N677 N678 N6730 _NC5474 _NC5475 NAND4X0
X2572 N6030 N9750 S_fract_48_i[24] N864 N674 _NC5476 _NC5477 AO22X1
X2573 N1321 N155 N1320 N6730 N674 N6710 _NC5478 _NC5479 AO221X1
X2574 N5980 N9700 N5990 N812 N6000 N8240 N6720 _NC5480 _NC5481 AO222X1
X2575 N26 N1077 N829 N5950 N6700 _NC5482 _NC5483 AOI22X1
X2576 N6690 N592 N1220 N593 N6700 N6680 _NC5484 _NC5485 OA221X1
X2577 N6670 N6680 N1291 N6630 _NC5486 _NC5487 AO21X1
X2578 N9410 S_fract_48_i[36] N157 N5870 N6650 _NC5488 _NC5489 AOI22X1
X2579 N948 N5840 N103 N5850 N5680 N5860 N6660 _NC5490 _NC5491 AOI222X1
X2580 N6630 N6640 N6650 N6660 N6620 _NC5492 _NC5493 NAND4X0
X2581 N5780 N830 N6350 N18 N1248 N6620 N659 _NC5494 _NC5495 AO222X1
X2582 N575 N966 N5770 N4120 N574 N2 N660 _NC5496 _NC5497 AO222X1
X2583 N8720 N6300 N896 N6310 N863 N6320 N641 _NC5498 _NC5499 OA222X1
X2584 N1174 N627 N8900 N628 N1173 N6290 N6530 _NC5500 _NC5501 OA222X1
X2585 N1040 N624 N625 N10240 N626 N1029 N657 _NC5502 _NC5503 AO222X1
X2586 N6220 N947 N1086 N10220 N623 N10250 N658 _NC5504 _NC5505 AO222X1
X2587 N6550 N6160 N1172 N6170 N6560 N6540 _NC5506 _NC5507 OA221X1
X2588 N6530 N6540 N1330 N6490 _NC5508 _NC5509 AO21X1
X2589 N931 N1075 N6150 N6110 N6510 _NC5510 _NC5511 AOI22X1
X2590 N965 N608 N230 N609 N3570 N610 N6520 _NC5512 _NC5513 AOI222X1
X2591 N6490 N6500 N6510 N6520 N6470 _NC5514 _NC5515 NAND4X0
X2592 N6030 N982 S_fract_48_i[24] N5 N6480 _NC5516 _NC5517 AO22X1
X2593 N1321 N17 N1320 N6470 N6480 N6450 _NC5518 _NC5519 AO221X1
X2594 N5980 N10060 N5990 N810 N6000 N8230 N6460 _NC5520 _NC5521 AO222X1
X2595 N28 N1077 N8 N5950 N644 _NC5522 _NC5523 AOI22X1
X2596 N643 N592 N1175 N593 N644 N642 _NC5524 _NC5525 OA221X1
X2597 N641 N642 N1291 N6370 _NC5526 _NC5527 AO21X1
X2598 N25 S_fract_48_i[36] N161 N5870 N6390 _NC5528 _NC5529 AOI22X1
X2599 N21 N5840 N3 N5850 N1 N5860 N640 _NC5530 _NC5531 AOI222X1
X2600 N6370 N6380 N6390 N640 N6360 _NC5532 _NC5533 NAND4X0
X2601 N1170 N6300 N1169 N6310 N1168 N6320 N589 _NC5534 _NC5535 OA222X1
X2602 N1167 N627 N1166 N628 N1165 N6290 N6130 _NC5536 _NC5537 OA222X1
X2603 N6130 N6140 N1330 N6040 _NC5538 _NC5539 AO21X1
X2604 N207 N1074 N105 N6110 N606 _NC5540 _NC5541 AOI22X1
X2605 N3560 N608 N113 N609 N111 N610 N607 _NC5542 _NC5543 AOI222X1
X2606 N6030 N9220 S_fract_48_i[24] N9730 N6020 _NC5544 _NC5545 AO22X1
X2607 N589 N590 N1291 N5800 _NC5546 _NC5547 AO21X1
X2608 N148 N5840 N865 N5850 N862 N5860 N5830 _NC5548 _NC5549 AOI222X1
X2609 N1055 N231 N1664 _NC5550 _NC5551 XNOR2X1
X2610 N1054 N232 N4810 N5700 _NC5552 _NC5553 AO21X1
X2611 N5700 N5690 N1665 _NC5554 _NC5555 XOR2X1
X2612 N1067 N5700 N1666 _NC5556 _NC5557 AND2X1
X2613 N1672 N229 S_fract_48_i[4] N1664 N1677 _NC5558 _NC5559 AO22X1
X2614 N1674 N229 N1666 S_fract_48_i[4] N1679 _NC5560 _NC5561 AO22X1
X2615 N1675 N229 N1680 _NC5562 _NC5563 AND2X1
X2616 N1686 N227 N1083 N1677 N1692 _NC5564 _NC5565 AO22X1
X2617 N1687 N227 N1084 N1678 N1693 _NC5566 _NC5567 AO22X1
X2618 N1688 N227 N1084 N1034 N1694 _NC5568 _NC5569 AO22X1
X2619 N1702 N226 N1088 N1692 N1708 _NC5570 _NC5571 AO22X1
X2620 N1703 N226 N1086 N8360 N1709 _NC5572 _NC5573 AO22X1
X2621 N1704 N226 N1088 N984 N1710 _NC5574 _NC5575 AO22X1
X2622 N1718 N225 S_fract_48_i[7] N1708 N1724 _NC5576 _NC5577 AO22X1
X2623 N1721 N225 S_fract_48_i[7] N239 N1727 _NC5578 _NC5579 AO22X1
X2624 N1723 N225 S_fract_48_i[7] N1181 N1729 _NC5580 _NC5581 AO22X1
X2625 N1734 N224 S_fract_48_i[8] N1724 N1740 _NC5582 _NC5583 AO22X1
X2626 N1736 N224 S_fract_48_i[8] N814 N1742 _NC5584 _NC5585 AO22X1
X2627 N1737 N224 S_fract_48_i[8] N9930 N1743 _NC5586 _NC5587 AO22X1
X2628 N1750 N223 S_fract_48_i[9] N1740 N1756 _NC5588 _NC5589 AO22X1
X2629 N1752 N223 S_fract_48_i[9] N9210 N1758 _NC5590 _NC5591 AO22X1
X2630 N1755 N223 S_fract_48_i[9] N191 N1761 _NC5592 _NC5593 AO22X1
X2631 N1766 N222 S_fract_48_i[10] N1756 N1772 _NC5594 _NC5595 AO22X1
X2632 N1771 N222 S_fract_48_i[10] N917 N1777 _NC5596 _NC5597 AO22X1
X2633 N1782 N221 S_fract_48_i[11] N1772 N1788 _NC5598 _NC5599 AO22X1
X2634 N1783 N221 S_fract_48_i[11] N9790 N1789 _NC5600 _NC5601 AO22X1
X2635 N1798 N215 N1071 N1788 N1804 _NC5602 _NC5603 AO22X1
X2636 N1799 N215 N1071 N9230 N1805 _NC5604 _NC5605 AO22X1
X2637 N1800 N215 N1072 N1790 N1806 _NC5606 _NC5607 AO22X1
X2638 N1801 N215 N1072 N8220 N1807 _NC5608 _NC5609 AO22X1
X2639 N1802 N215 N1072 N933 N1808 _NC5610 _NC5611 AO22X1
X2640 N1803 N215 N1071 N895 N1809 _NC5612 _NC5613 AO22X1
X2641 N1814 N214 S_fract_48_i[13] N1804 N1820 _NC5614 _NC5615 AO22X1
X2642 N1815 N214 S_fract_48_i[13] N8740 N1821 _NC5616 _NC5617 AO22X1
X2643 N1816 N214 S_fract_48_i[13] N10190 N1822 _NC5618 _NC5619 AO22X1
X2644 N1830 N212 S_fract_48_i[14] N1820 N1836 _NC5620 _NC5621 AO22X1
X2645 N1832 N212 S_fract_48_i[14] N10110 N1838 _NC5622 _NC5623 AO22X1
X2646 N1835 N212 S_fract_48_i[14] N9690 N1841 _NC5624 _NC5625 AO22X1
X2647 N1846 N210 S_fract_48_i[15] N1836 N1852 _NC5626 _NC5627 AO22X1
X2648 N1848 N210 S_fract_48_i[15] N1001 N1854 _NC5628 _NC5629 AO22X1
X2649 N1850 N210 S_fract_48_i[15] N9890 N1856 _NC5630 _NC5631 AO22X1
X2650 N1851 N210 S_fract_48_i[15] N9050 N1857 _NC5632 _NC5633 AO22X1
X2651 N1862 N208 S_fract_48_i[16] N1852 N1868 _NC5634 _NC5635 AO22X1
X2652 N1863 N208 S_fract_48_i[16] N999 N1869 _NC5636 _NC5637 AO22X1
X2653 N1864 N208 S_fract_48_i[16] N10070 N1870 _NC5638 _NC5639 AO22X1
X2654 N1878 N206 S_fract_48_i[17] N1868 N1884 _NC5640 _NC5641 AO22X1
X2655 N1880 N206 S_fract_48_i[17] N967 N1886 _NC5642 _NC5643 AO22X1
X2656 N1881 N206 S_fract_48_i[17] N59 N1887 _NC5644 _NC5645 AO22X1
X2657 N1882 N206 S_fract_48_i[17] N6180 N1888 _NC5646 _NC5647 AO22X1
X2658 N1883 N206 S_fract_48_i[17] N203 N1889 _NC5648 _NC5649 AO22X1
X2659 N1894 N204 N1075 N1884 N1900 _NC5650 _NC5651 AO22X1
X2660 N1910 N198 S_fract_48_i[19] N1900 N1916 _NC5652 _NC5653 AO22X1
X2661 N1914 N198 S_fract_48_i[19] N831 N1920 _NC5654 _NC5655 AO22X1
X2662 N1926 N197 S_fract_48_i[20] N1916 N1932 _NC5656 _NC5657 AO22X1
X2663 N1927 N197 S_fract_48_i[20] N9350 N1933 _NC5658 _NC5659 AO22X1
X2664 N1929 N197 S_fract_48_i[20] N202 N1935 _NC5660 _NC5661 AO22X1
X2665 N1930 N197 S_fract_48_i[20] N981 N1936 _NC5662 _NC5663 AO22X1
X2666 N1942 N196 S_fract_48_i[21] N1932 N1948 _NC5664 _NC5665 AO22X1
X2667 N1958 N189 S_fract_48_i[22] N1948 N1964 _NC5666 _NC5667 AO22X1
X2668 N1959 N189 S_fract_48_i[22] N9260 N1965 _NC5668 _NC5669 AO22X1
X2669 N1963 N189 S_fract_48_i[22] N998 N1969 _NC5670 _NC5671 AO22X1
X2670 N1326 N182 S_fract_48_i[23] N1964 N1980 _NC5672 _NC5673 AO22X1
X2671 N1979 N182 S_fract_48_i[23] N9620 N1985 _NC5674 _NC5675 AO22X1
X2672 N1990 N177 S_fract_48_i[24] N1980 N1996 _NC5676 _NC5677 AO22X1
X2673 N1991 N177 S_fract_48_i[24] N9680 N1997 _NC5678 _NC5679 AO22X1
X2674 N1992 N177 S_fract_48_i[24] N184 N1998 _NC5680 _NC5681 AO22X1
X2675 N1994 N177 S_fract_48_i[24] N194 N2000 _NC5682 _NC5683 AO22X1
X2676 N1995 N177 N1146 N195 N2001 _NC5684 _NC5685 AO22X1
X2677 N2006 N174 S_fract_48_i[25] N1996 N2012 _NC5686 _NC5687 AO22X1
X2678 N2009 N174 S_fract_48_i[25] N946 N2015 _NC5688 _NC5689 AO22X1
X2679 N2010 N174 S_fract_48_i[25] N9870 N2016 _NC5690 _NC5691 AO22X1
X2680 N2022 N173 S_fract_48_i[26] N2012 N2028 _NC5692 _NC5693 AO22X1
X2681 N2024 N173 S_fract_48_i[26] N9390 N2030 _NC5694 _NC5695 AO22X1
X2682 N2038 N172 S_fract_48_i[27] N2028 N2044 _NC5696 _NC5697 AO22X1
X2683 N2040 N172 S_fract_48_i[27] N929 N2046 _NC5698 _NC5699 AO22X1
X2684 N2042 N172 S_fract_48_i[27] N1031 N2048 _NC5700 _NC5701 AO22X1
X2685 N2054 N171 S_fract_48_i[28] N2044 N2060 _NC5702 _NC5703 AO22X1
X2686 N2056 N171 S_fract_48_i[28] N930 N2062 _NC5704 _NC5705 AO22X1
X2687 N2058 N171 S_fract_48_i[28] N911 N2064 _NC5706 _NC5707 AO22X1
X2688 N2059 N171 S_fract_48_i[28] N10080 N2065 _NC5708 _NC5709 AO22X1
X2689 N2070 N170 S_fract_48_i[29] N2060 N2076 _NC5710 _NC5711 AO22X1
X2690 N2073 N170 S_fract_48_i[29] N9550 N2079 _NC5712 _NC5713 AO22X1
X2691 N2086 N164 N1077 N2076 N2092 _NC5714 _NC5715 AO22X1
X2692 N2090 N164 N1078 N1016 N2096 _NC5716 _NC5717 AO22X1
X2693 N2102 N162 S_fract_48_i[31] N2092 N2108 _NC5718 _NC5719 AO22X1
X2694 N2104 N162 S_fract_48_i[31] N49 N2110 _NC5720 _NC5721 AO22X1
X2695 N2105 N162 S_fract_48_i[31] N8930 N2111 _NC5722 _NC5723 AO22X1
X2696 N2107 N162 S_fract_48_i[31] N1000 N2113 _NC5724 _NC5725 AO22X1
X2697 N2118 N160 S_fract_48_i[32] N2108 N2124 _NC5726 _NC5727 AO22X1
X2698 N2122 N160 S_fract_48_i[32] N9590 N2128 _NC5728 _NC5729 AO22X1
X2699 N2134 N158 S_fract_48_i[33] N2124 N2140 _NC5730 _NC5731 AO22X1
X2700 N2137 N158 S_fract_48_i[33] N9570 N2143 _NC5732 _NC5733 AO22X1
X2701 N2138 N158 S_fract_48_i[33] N964 N2144 _NC5734 _NC5735 AO22X1
X2702 N2139 N158 S_fract_48_i[33] N932 N2145 _NC5736 _NC5737 AO22X1
X2703 N2150 N156 S_fract_48_i[34] N2140 N2156 _NC5738 _NC5739 AO22X1
X2704 N2151 N156 S_fract_48_i[34] N8590 N2157 _NC5740 _NC5741 AO22X1
X2705 N2152 N156 S_fract_48_i[34] N860 N2158 _NC5742 _NC5743 AO22X1
X2706 N2153 N156 S_fract_48_i[34] N899 N2159 _NC5744 _NC5745 AO22X1
X2707 N2166 N154 S_fract_48_i[35] N2156 N2172 _NC5746 _NC5747 AO22X1
X2708 N2167 N154 S_fract_48_i[35] N314 N2173 _NC5748 _NC5749 AO22X1
X2709 N2168 N154 S_fract_48_i[35] N237 N2174 _NC5750 _NC5751 AO22X1
X2710 N2169 N154 S_fract_48_i[35] N8320 N2175 _NC5752 _NC5753 AO22X1
X2711 N2171 N154 S_fract_48_i[35] N353 N2177 _NC5754 _NC5755 AO22X1
X2712 N2182 N152 S_fract_48_i[36] N2172 N2188 _NC5756 _NC5757 AO22X1
X2713 N2183 N152 S_fract_48_i[36] N126 N2189 _NC5758 _NC5759 AO22X1
X2714 N2184 N152 S_fract_48_i[36] N159 N2190 _NC5760 _NC5761 AO22X1
X2715 N2198 N146 S_fract_48_i[37] N2188 N2204 _NC5762 _NC5763 AO22X1
X2716 N2214 N145 S_fract_48_i[38] N2204 N2220 _NC5764 _NC5765 AO22X1
X2717 N2216 N145 S_fract_48_i[38] N8760 N2222 _NC5766 _NC5767 AO22X1
X2718 N2217 N145 S_fract_48_i[38] N8870 N2223 _NC5768 _NC5769 AO22X1
X2719 N2230 N144 S_fract_48_i[39] N2220 N2236 _NC5770 _NC5771 AO22X1
X2720 N2234 N144 S_fract_48_i[39] N10020 N2240 _NC5772 _NC5773 AO22X1
X2721 N2246 N137 S_fract_48_i[40] N2236 N2252 _NC5774 _NC5775 AO22X1
X2722 N2262 N130 S_fract_48_i[41] N2252 N2268 _NC5776 _NC5777 AO22X1
X2723 N2278 N123 N1092 N2268 N2284 _NC5778 _NC5779 AO22X1
X2724 N2279 N123 N1090 N2269 N2285 _NC5780 _NC5781 AO22X1
X2725 N2280 N123 N1092 N2270 N2286 _NC5782 _NC5783 AO22X1
X2726 N2281 N123 N1091 N85 N2287 _NC5784 _NC5785 AO22X1
X2727 N2294 N122 S_fract_48_i[43] N2284 N2300 _NC5786 _NC5787 AO22X1
X2728 N2295 N122 S_fract_48_i[43] N3730 N2301 _NC5788 _NC5789 AO22X1
X2729 N2310 N119 N1062 N2300 N2316 _NC5790 _NC5791 AO22X1
X2730 N2311 N119 N1062 N2301 N2317 _NC5792 _NC5793 AO22X1
X2731 N2312 N119 N1062 N45 N2318 _NC5794 _NC5795 AO22X1
X2732 N2313 N119 N1062 N44 N2319 _NC5796 _NC5797 AO22X1
X2733 N2314 N119 N1062 N9540 N2320 _NC5798 _NC5799 AO22X1
X2734 N2315 N119 N1062 N234 N2321 _NC5800 _NC5801 AO22X1
X2735 N2326 N118 S_fract_48_i[45] N2316 N2332 _NC5802 _NC5803 AO22X1
X2736 N2327 N118 S_fract_48_i[45] N329 N2333 _NC5804 _NC5805 AO22X1
X2737 N2328 N176 S_fract_48_i[45] N6330 N2334 _NC5806 _NC5807 AO22X1
X2738 N2329 N176 S_fract_48_i[45] N6210 N2335 _NC5808 _NC5809 AO22X1
X2739 N2342 N69 N1064 N2332 N2348 _NC5810 _NC5811 AO22X1
X2740 N2343 N69 N1064 N2333 N2349 _NC5812 _NC5813 AO22X1
X2741 N2344 N69 N1064 N2334 N2350 _NC5814 _NC5815 AO22X1
X2742 N2345 N69 N1064 N2335 N2351 _NC5816 _NC5817 AO22X1
X2743 N4810 N232 N5670 _NC5818 _NC5819 AND2X1
X2744 N1740 N3340 N1692 N1081 N5110 _NC5820 _NC5821 AOI22X1
X2745 N5650 N5660 N3328 _NC5822 _NC5823 AND2X1
X2746 N1708 N3330 N1724 N3328 N5120 _NC5824 _NC5825 AOI22X1
X2747 N5640 N5630 N338 _NC5826 _NC5827 AND2X1
X2748 N1756 N338 N1772 N337 N5130 _NC5828 _NC5829 AOI22X1
X2749 N5610 N177 N3580 _NC5830 _NC5831 AND2X1
X2750 N2028 N3590 N1996 N1146 N2012 N3580 N5320 _NC5832 _NC5833 AOI222X1
X2751 N5600 N559 N3800 _NC5834 _NC5835 OR2X1
X2752 N2246 N3790 N2262 N3800 N5470 _NC5836 _NC5837 OA22X1
X2753 N69 N68 N557 N558 _NC5838 _NC5839 NAND3X0
X2754 N557 N558 N386 _NC5840 _NC5841 AND2X1
X2755 N2358 N1194 N385 N2332 N386 N2348 N5530 _NC5842 _NC5843 AO222X1
X2756 N555 N556 N384 _NC5844 _NC5845 AND2X1
X2757 N3830 N2300 N1092 N2284 N384 N2316 N5540 _NC5846 _NC5847 AO222X1
X2758 N2278 N3770 N5520 N3760 N5480 _NC5848 _NC5849 OA22X1
X2759 N5500 N152 N388 _NC5850 _NC5851 AND2X1
X2760 N2220 N387 N2188 S_fract_48_i[36] N2204 N388 N5490 _NC5852 _NC5853 AOI222X1
X2761 N5470 N5480 N5490 N5430 _NC5854 _NC5855 NAND3X0
X2762 N371 N2156 N370 N2140 N5440 _NC5856 _NC5857 AO22X1
X2763 N372 N2172 N4420 N5430 N5440 N539 _NC5858 _NC5859 AO221X1
X2764 N369 N2108 N1077 N2092 N368 N2124 N540 _NC5860 _NC5861 AO222X1
X2765 N538 N5360 N3630 _NC5862 _NC5863 AND2X1
X2766 N2044 N3630 N2060 N3620 N5350 _NC5864 _NC5865 AOI22X1
X2767 N5340 N4470 N2086 N4480 N5350 N5330 _NC5866 _NC5867 OA221X1
X2768 N5320 N5330 N351 N524 _NC5868 _NC5869 AO21X1
X2769 N5300 N5310 N355 _NC5870 _NC5871 OR2X1
X2770 N1958 N354 N1326 N355 N5260 _NC5872 _NC5873 OA22X1
X2771 N5280 N204 N3900 _NC5874 _NC5875 AND2X1
X2772 N1932 N389 N1900 N1075 N1916 N3900 N5270 _NC5876 _NC5877 AOI222X1
X2773 N524 N525 N5260 N5270 N5200 _NC5878 _NC5879 NAND4X0
X2774 N3460 N1868 N345 N1852 N521 _NC5880 _NC5881 AO22X1
X2775 N3470 N1884 N4290 N5200 N521 N5160 _NC5882 _NC5883 AO221X1
X2776 N3440 N1820 N1072 N1804 N3430 N1836 N5170 _NC5884 _NC5885 AO222X1
X2777 N1798 N4500 N5150 N4490 N5140 _NC5886 _NC5887 OA22X1
X2778 N5110 N5120 N5130 N5140 N5100 _NC5888 _NC5889 NAND4X0
X2779 N5090 N233 N331 N5100 N2974 _NC5890 _NC5891 AO22X1
X2780 N193 N3340 N8360 N1084 N4820 _NC5892 _NC5893 AOI22X1
X2781 N167 N3330 N9030 N3328 N4830 _NC5894 _NC5895 AOI22X1
X2782 N8080 N338 N9790 N337 N4840 _NC5896 _NC5897 AOI22X1
X2783 N190 N3590 N9040 N1146 N9850 N3580 N4950 _NC5898 _NC5899 AOI222X1
X2784 N1274 N3790 N1267 N3800 N5030 _NC5900 _NC5901 OA22X1
X2785 N2359 N1194 N385 N2333 N386 N2349 N507 _NC5902 _NC5903 AO222X1
X2786 N3830 N2301 N1091 N3730 N384 N329 N508 _NC5904 _NC5905 AO222X1
X2787 N1260 N3770 N506 N3760 N504 _NC5906 _NC5907 OA22X1
X2788 N95 N387 N2189 S_fract_48_i[36] N8850 N388 N505 _NC5908 _NC5909 AOI222X1
X2789 N5030 N504 N505 N5010 _NC5910 _NC5911 NAND3X0
X2790 N371 N314 N370 N8590 N5020 _NC5912 _NC5913 AO22X1
X2791 N372 N126 N4420 N5010 N5020 N4990 _NC5914 _NC5915 AO221X1
X2792 N369 N179 N1078 N9380 N368 N8830 N5000 _NC5916 _NC5917 AO222X1
X2793 N55 N3630 N199 N3620 N4980 _NC5918 _NC5919 AOI22X1
X2794 N4970 N4470 N1317 N4480 N4980 N4960 _NC5920 _NC5921 OA221X1
X2795 N4950 N4960 N351 N491 _NC5922 _NC5923 AO21X1
X2796 N1329 N354 N1325 N355 N4930 _NC5924 _NC5925 OA22X1
X2797 N115 N389 N8400 N1074 N9350 N3900 N4940 _NC5926 _NC5927 AOI222X1
X2798 N491 N4920 N4930 N4940 N489 _NC5928 _NC5929 NAND4X0
X2799 N3470 N216 N4290 N489 N490 N487 _NC5930 _NC5931 AO221X1
X2800 N3440 N70 N1072 N8740 N3430 N8530 N488 _NC5932 _NC5933 AO222X1
X2801 N1348 N4500 N4860 N4490 N4850 _NC5934 _NC5935 OA22X1
X2802 N4820 N4830 N4840 N4850 N4800 _NC5936 _NC5937 NAND4X0
X2803 N27 N3330 N814 N3328 N454 _NC5938 _NC5939 AOI22X1
X2804 N8540 N338 N1774 N337 N455 _NC5940 _NC5941 AOI22X1
X2805 N929 N3590 N9070 N1146 N9390 N3580 N4660 _NC5942 _NC5943 AOI222X1
X2806 N1273 N3790 N1266 N3800 N474 _NC5944 _NC5945 OA22X1
X2807 N2360 N1194 N385 N2334 N386 N2350 N4780 _NC5946 _NC5947 AO222X1
X2808 N3830 N45 N1090 N6200 N384 N6330 N4790 _NC5948 _NC5949 AO222X1
X2809 N1259 N3770 N4770 N3760 N4750 _NC5950 _NC5951 OA22X1
X2810 N98 N387 N2190 S_fract_48_i[36] N8760 N388 N4760 _NC5952 _NC5953 AOI222X1
X2811 N371 N237 N370 N860 N473 _NC5954 _NC5955 AO22X1
X2812 N372 N159 N4420 N472 N473 N470 _NC5956 _NC5957 AO221X1
X2813 N369 N128 N1078 N49 N368 N8860 N471 _NC5958 _NC5959 AO222X1
X2814 N930 N3630 N205 N3620 N4690 _NC5960 _NC5961 AOI22X1
X2815 N4680 N4470 N1316 N4480 N4690 N4670 _NC5962 _NC5963 OA221X1
X2816 N4660 N4670 N351 N4620 _NC5964 _NC5965 AO21X1
X2817 N1328 N354 N1324 N355 N4640 _NC5966 _NC5967 OA22X1
X2818 N4620 N4630 N4640 N4650 N4600 _NC5968 _NC5969 NAND4X0
X2819 N3460 N967 N345 N10070 N4610 _NC5970 _NC5971 AO22X1
X2820 N3470 N8710 N4290 N4600 N4610 N4580 _NC5972 _NC5973 AO221X1
X2821 N3440 N10110 N1071 N10190 N3430 N1001 N4590 _NC5974 _NC5975 AO222X1
X2822 N1347 N4500 N457 N4490 N456 _NC5976 _NC5977 OA22X1
X2823 N168 N389 N209 N1074 N202 N3900 N4270 _NC5978 _NC5979 AOI222X1
X2824 N112 N387 N9080 S_fract_48_i[36] N8870 N388 N440 _NC5980 _NC5981 AOI222X1
X2825 N2361 N1194 N385 N2335 N386 N2351 N4450 _NC5982 _NC5983 AO222X1
X2826 N3830 N44 N1092 N2287 N384 N6210 N4460 _NC5984 _NC5985 AO222X1
X2827 N1272 N3790 N1265 N3800 N4440 _NC5986 _NC5987 OA22X1
X2828 N4430 N3760 N1258 N3770 N4440 N4410 _NC5988 _NC5989 OA221X1
X2829 N440 N4410 N1299 N436 _NC5990 _NC5991 AO21X1
X2830 N899 N370 N8320 N371 N438 _NC5992 _NC5993 AOI22X1
X2831 N9570 N368 N8930 N1078 N8560 N369 N439 _NC5994 _NC5995 AOI222X1
X2832 N436 N437 N438 N439 N4340 _NC5996 _NC5997 NAND4X0
X2833 N3620 N9550 N3630 N10120 N4350 _NC5998 _NC5999 AO22X1
X2834 N1315 N228 N1314 N4340 N4350 N4320 _NC6000 _NC6001 AO221X1
X2835 N3580 N897 N1146 N946 N3590 N881 N4330 _NC6002 _NC6003 AO222X1
X2836 N1327 N354 N1323 N355 N4310 _NC6004 _NC6005 OA22X1
X2837 N4300 N351 N1322 N352 N4310 N4280 _NC6006 _NC6007 OA221X1
X2838 N4270 N4280 N1335 N423 _NC6008 _NC6009 AO21X1
X2839 N57 N345 N59 N3460 N4250 _NC6010 _NC6011 AOI22X1
X2840 N423 N4240 N4250 N4260 N421 _NC6012 _NC6013 NAND4X0
X2841 N337 N20 N338 N845 N422 _NC6014 _NC6015 AO22X1
X2842 N1346 N8220 N1345 N421 N422 N4180 _NC6016 _NC6017 AO221X1
X2843 N3328 N9930 N3330 N239 N420 _NC6018 _NC6019 AO22X1
X2844 N3340 N9200 N1083 N13 N420 N419 _NC6020 _NC6021 AO221X1
X2845 N2362 N1194 N385 N136 N386 N141 N4160 _NC6022 _NC6023 AO222X1
X2846 N3830 N9540 N1090 N220 N384 N8500 N4170 _NC6024 _NC6025 AO222X1
X2847 N1184 N3790 N1183 N3800 N4150 _NC6026 _NC6027 OA22X1
X2848 N964 N368 N848 N1077 N9590 N369 N4110 _NC6028 _NC6029 AOI222X1
X2849 N4080 N4090 N4100 N4110 N406 _NC6030 _NC6031 NAND4X0
X2850 N3620 N2064 N3630 N911 N4070 _NC6032 _NC6033 AO22X1
X2851 N1315 N1016 N1314 N406 N4070 N404 _NC6034 _NC6035 AO221X1
X2852 N3580 N8660 N1146 N9870 N3590 N1031 N405 _NC6036 _NC6037 AO222X1
X2853 N1187 N354 N1186 N355 N403 _NC6038 _NC6039 OA22X1
X2854 N898 N345 N6180 N3460 N3980 _NC6040 _NC6041 AOI22X1
X2855 N9890 N3430 N9720 N1072 N809 N3440 N3990 _NC6042 _NC6043 AOI222X1
X2856 N3960 N3970 N3980 N3990 N3940 _NC6044 _NC6045 NAND4X0
X2857 N337 N9370 N338 N8370 N3950 _NC6046 _NC6047 AO22X1
X2858 N1346 N933 N1345 N3940 N3950 N3910 _NC6048 _NC6049 AO221X1
X2859 N3328 N4 N3330 N23 N3930 _NC6050 _NC6051 AO22X1
X2860 N3340 N19 N1083 N1696 N3930 N3920 _NC6052 _NC6053 AO221X1
X2861 N9780 N389 N811 N1074 N3820 N3900 N3480 _NC6054 _NC6055 AOI222X1
X2862 N1178 N3790 N1177 N3800 N3780 _NC6056 _NC6057 OA22X1
X2863 N8690 N370 N353 N371 N3660 _NC6058 _NC6059 AOI22X1
X2864 N932 N368 N1000 N1077 N9960 N369 N367 _NC6060 _NC6061 AOI222X1
X2865 N3620 N950 N3630 N10080 N361 _NC6062 _NC6063 AO22X1
X2866 N3480 N3490 N1335 N339 _NC6064 _NC6065 AO21X1
X2867 N5790 N345 N203 N3460 N3410 _NC6066 _NC6067 AOI22X1
X2868 N9050 N3430 N877 N1071 N9690 N3440 N3420 _NC6068 _NC6069 AOI222X1
X2869 N337 N79 N338 N917 N336 _NC6070 _NC6071 AO22X1
X2870 S_exp_10a[3] S_exp_10a[2] S_exp_10a[1] S_exp_10a[0] N326 _NC6072 _NC6073 NOR4X0
X2871 S_exp_10a[5] S_exp_10a[4] N328 _NC6074 _NC6075 OR2X1
X2872 N328 S_exp_10a[6] S_exp_10a[8] S_exp_10a[7] N327 _NC6076 _NC6077 NOR4X0
X2873 S_exp_10b[0] S_exp_10b[1] S_exp_10b[2] S_exp_10b[3] N324 _NC6078 _NC6079 OR4X1
X2874 S_exp_10b[7] S_exp_10b[8] S_exp_10b[6] N325 _NC6080 _NC6081 OR3X1
X2875 N324 N325 S_exp_10b[5] S_exp_10b[4] N323 _NC6082 _NC6083 NOR4X0
X2876 S_zeros[0] N318 N3019 N321 N3065 _NC6084 _NC6085 AO22X1
X2877 S_zeros[1] N318 N3020 N321 N3066 _NC6086 _NC6087 AO22X1
X2878 S_zeros[2] N318 N3021 N321 N3067 _NC6088 _NC6089 AO22X1
X2879 S_zeros[3] N318 N3022 N321 N3068 _NC6090 _NC6091 AO22X1
X2880 S_zeros[4] N318 N3023 N321 N3069 _NC6092 _NC6093 AO22X1
X2881 S_zeros[5] N318 N3024 N321 N3070 _NC6094 _NC6095 AO22X1
X2882 S_exp_10b[8] N319 N320 _NC6096 _NC6097 AND2X1
X2883 S_exp_10b[1] N319 N320 N3072 _NC6098 _NC6099 AO21X1
X2884 S_exp_10b[2] N319 N320 N3073 _NC6100 _NC6101 AO21X1
X2885 S_exp_10b[3] N319 N320 N3074 _NC6102 _NC6103 AO21X1
X2886 S_exp_10b[4] N319 N320 N3075 _NC6104 _NC6105 AO21X1
X2887 S_exp_10b[5] N319 N320 N3076 _NC6106 _NC6107 AO21X1
X2888 S_exp_10b[6] N319 N320 N3077 _NC6108 _NC6109 AO21X1
X2889 S_exp_10b[7] N319 N320 N3078 _NC6110 _NC6111 AO21X1
X2890 N3005 N316 N317 _NC6112 _NC6113 AND2X1
X2891 N2993 N318 N2999 N316 N317 N3081 _NC6114 _NC6115 AO221X1
X2892 N3000 N316 N317 N3082 _NC6116 _NC6117 AO21X1
X2893 N3001 N316 N317 N3083 _NC6118 _NC6119 AO21X1
X2894 N3002 N316 N317 N3084 _NC6120 _NC6121 AO21X1
X2895 N3003 N316 N317 N3085 _NC6122 _NC6123 AO21X1
X2896 N3004 N316 N317 N3086 _NC6124 _NC6125 AO21X1
X2897 N1145 N1139 S_shr2[3] N315 _NC6126 _NC6127 OR3X1
X2898 N3093 N1115 N3141 N1104 N3189 _NC6128 _NC6129 AO22X1
X2899 N3094 N1115 N3142 N1104 N3190 _NC6130 _NC6131 AO22X1
X2900 N3095 N1115 N3143 N1104 N3191 _NC6132 _NC6133 AO22X1
X2901 N3096 N1114 N3144 N1104 N3192 _NC6134 _NC6135 AO22X1
X2902 N3097 N1114 N3145 N1104 N3193 _NC6136 _NC6137 AO22X1
X2903 N3098 N1114 N3146 N1104 N3194 _NC6138 _NC6139 AO22X1
X2904 N3099 N1114 N3147 N1104 N3195 _NC6140 _NC6141 AO22X1
X2905 N3100 N1114 N3148 N1104 N3196 _NC6142 _NC6143 AO22X1
X2906 N3101 N1114 N3149 N1104 N3197 _NC6144 _NC6145 AO22X1
X2907 N3102 N1114 N3150 N1104 N3198 _NC6146 _NC6147 AO22X1
X2908 N3103 N1113 N3151 N1104 N3199 _NC6148 _NC6149 AO22X1
X2909 N3104 N1113 N3152 N1104 N3200 _NC6150 _NC6151 AO22X1
X2910 N3105 N1113 N3153 N1105 N3201 _NC6152 _NC6153 AO22X1
X2911 N3106 N1113 N3154 N1105 N3202 _NC6154 _NC6155 AO22X1
X2912 N3107 N1113 N3155 N1105 N3203 _NC6156 _NC6157 AO22X1
X2913 N3108 N1113 N3156 N1105 N3204 _NC6158 _NC6159 AO22X1
X2914 N3109 N1113 N3157 N1105 N3205 _NC6160 _NC6161 AO22X1
X2915 N3110 N1112 N3158 N1105 N3206 _NC6162 _NC6163 AO22X1
X2916 N3111 N1112 N3159 N1105 N3207 _NC6164 _NC6165 AO22X1
X2917 N3112 N1112 N3160 N1105 N3208 _NC6166 _NC6167 AO22X1
X2918 N3113 N1112 N3161 N1105 N3209 _NC6168 _NC6169 AO22X1
X2919 N3114 N1112 N3162 N1105 N3210 _NC6170 _NC6171 AO22X1
X2920 N3115 N1112 N3163 N1105 N3211 _NC6172 _NC6173 AO22X1
X2921 N3116 N1112 N3164 N1105 N3212 _NC6174 _NC6175 AO22X1
X2922 N3117 N1111 N3165 N1106 N3213 _NC6176 _NC6177 AO22X1
X2923 N3118 N1111 N3166 N1106 N3214 _NC6178 _NC6179 AO22X1
X2924 N3119 N1111 N3167 N1106 N3215 _NC6180 _NC6181 AO22X1
X2925 N3120 N1111 N3168 N1106 N3216 _NC6182 _NC6183 AO22X1
X2926 N3121 N1111 N3169 N1106 N3217 _NC6184 _NC6185 AO22X1
X2927 N3122 N1111 N3170 N1106 N3218 _NC6186 _NC6187 AO22X1
X2928 N3123 N1111 N3171 N1106 N3219 _NC6188 _NC6189 AO22X1
X2929 N3124 N1110 N3172 N1106 N3220 _NC6190 _NC6191 AO22X1
X2930 N3125 N1110 N1308 N1106 N3221 _NC6192 _NC6193 AO22X1
X2931 N3126 N1110 N1305 N1106 N3222 _NC6194 _NC6195 AO22X1
X2932 N3127 N1110 N1301 N1106 N3223 _NC6196 _NC6197 AO22X1
X2933 N3128 N1110 N1297 N1106 N3224 _NC6198 _NC6199 AO22X1
X2934 N3129 N1110 N1288 N1107 N3225 _NC6200 _NC6201 AO22X1
X2935 N3130 N1110 N1284 N1107 N3226 _NC6202 _NC6203 AO22X1
X2936 N3131 N1109 N1280 N1107 N3227 _NC6204 _NC6205 AO22X1
X2937 N3132 N1109 N1276 N1107 N3228 _NC6206 _NC6207 AO22X1
X2938 N3133 N1109 N1270 N1107 N3229 _NC6208 _NC6209 AO22X1
X2939 N3134 N1109 N1263 N1107 N3230 _NC6210 _NC6211 AO22X1
X2940 N3135 N1109 N1256 N1107 N3231 _NC6212 _NC6213 AO22X1
X2941 N3136 N1109 N1252 N1107 N3232 _NC6214 _NC6215 AO22X1
X2942 N3137 N1109 N3185 N1107 N3233 _NC6216 _NC6217 AO22X1
X2943 N3138 N1108 N3186 N1107 N3234 _NC6218 _NC6219 AO22X1
X2944 N3139 N1108 N3187 N1107 N3235 _NC6220 _NC6221 AO22X1
X2945 N3140 N1108 N3188 N1107 N3236 _NC6222 _NC6223 AO22X1
X2946 S_frac2a[0] N3244 N313 _NC6224 _NC6225 OR2X1
X2947 N313 S_frac2a[10] S_frac2a[12] S_frac2a[11] N306 _NC6226 _NC6227 NOR4X0
X2948 S_frac2a[18] S_frac2a[17] S_frac2a[16] N312 _NC6228 _NC6229 OR3X1
X2949 N312 S_frac2a[13] S_frac2a[15] S_frac2a[14] N307 _NC6230 _NC6231 NOR4X0
X2950 S_frac2a[1] S_frac2a[19] N311 _NC6232 _NC6233 OR2X1
X2951 N311 S_frac2a[20] S_frac2a[3] S_frac2a[2] N308 _NC6234 _NC6235 NOR4X0
X2952 S_frac2a[9] S_frac2a[8] S_frac2a[7] N310 _NC6236 _NC6237 OR3X1
X2953 N310 S_frac2a[4] S_frac2a[6] S_frac2a[5] N309 _NC6238 _NC6239 NOR4X0
X2954 N306 N307 N308 N309 N303 _NC6240 _NC6241 NAND4X0
X2955 S_frac2a[21] S_frac2a[22] N303 N287 _NC6242 _NC6243 NOR3X0
X2956 S_rmode_i[1] N304 S_output_o[31] N305 _NC6244 _NC6245 NAND3X0
X2957 S_frac2a[21] S_frac2a[23] N303 N302 _NC6246 _NC6247 OR3X1
X2958 S_frac2a[22] N302 N236 N235 N301 _NC6248 _NC6249 NAND4X0
X2959 N3278 N1118 S_frac2a[23] N299 N3303 _NC6250 _NC6251 AO22X1
X2960 N3279 N1118 S_frac2a[24] N1116 N3304 _NC6252 _NC6253 AO22X1
X2961 N3280 N1118 S_frac2a[25] N1116 N3305 _NC6254 _NC6255 AO22X1
X2962 N3281 N1118 S_frac2a[26] N1116 N3306 _NC6256 _NC6257 AO22X1
X2963 N3282 N1118 S_frac2a[27] N1116 N3307 _NC6258 _NC6259 AO22X1
X2964 N3283 N1118 S_frac2a[28] N1116 N3308 _NC6260 _NC6261 AO22X1
X2965 N3284 N1118 S_frac2a[29] N1116 N3309 _NC6262 _NC6263 AO22X1
X2966 N3285 N1117 S_frac2a[30] N1116 N3310 _NC6264 _NC6265 AO22X1
X2967 N3286 N1117 S_frac2a[31] N1116 N3311 _NC6266 _NC6267 AO22X1
X2968 N3287 N1117 S_frac2a[32] N1116 N3312 _NC6268 _NC6269 AO22X1
X2969 N3288 N1117 S_frac2a[33] N1116 N3313 _NC6270 _NC6271 AO22X1
X2970 N3289 N1117 S_frac2a[34] N1116 N3314 _NC6272 _NC6273 AO22X1
X2971 N3290 N1117 S_frac2a[35] N299 N3315 _NC6274 _NC6275 AO22X1
X2972 N3291 N1117 S_frac2a[36] N299 N3316 _NC6276 _NC6277 AO22X1
X2973 N3292 N1118 S_frac2a[37] N299 N3317 _NC6278 _NC6279 AO22X1
X2974 N3293 N1117 S_frac2a[38] N299 N3318 _NC6280 _NC6281 AO22X1
X2975 N3294 N1118 S_frac2a[39] N299 N3319 _NC6282 _NC6283 AO22X1
X2976 N3295 N1117 S_frac2a[40] N299 N3320 _NC6284 _NC6285 AO22X1
X2977 N3296 N1118 S_frac2a[41] N299 N3321 _NC6286 _NC6287 AO22X1
X2978 N3297 N1117 S_frac2a[42] N299 N3322 _NC6288 _NC6289 AO22X1
X2979 N3298 N1118 S_frac2a[43] N299 N3323 _NC6290 _NC6291 AO22X1
X2980 N3299 N1117 S_frac2a[44] N299 N3324 _NC6292 _NC6293 AO22X1
X2981 N3300 N1118 S_frac2a[45] N299 N3325 _NC6294 _NC6295 AO22X1
X2982 N3301 N1117 N299 S_frac2a[46] N3326 _NC6296 _NC6297 AO22X1
X2983 N3302 N1118 S_frac2a[47] N1116 N3327 _NC6298 _NC6299 AO22X1
X2984 N3351 N3350 N3352 N296 _NC6300 _NC6301 AND3X1
X2985 N298 N1190 N3354 S_expo2b[0] N297 _NC6302 _NC6303 NOR4X0
X2986 S_frac_rnd[24] N3353 N296 N297 N288 _NC6304 _NC6305 NAND4X0
X2987 S_expo2b[1] Sub_192_aco_carry[7] S_expo2b[0] N294 _NC6306 _NC6307 AND3X1
X2988 S_expo2b[4] S_expo2b[5] S_expo2b[6] S_expo2b[7] N295 _NC6308 _NC6309 AND4X1
X2989 S_expo2b[3] S_expo2b[2] N294 N295 N289 _NC6310 _NC6311 NAND4X0
X2990 S_expa[3] S_expa[2] S_expa[1] S_expa[0] N292 _NC6312 _NC6313 NAND4X0
X2991 S_expa[7] S_expa[6] S_expa[5] S_expa[4] N293 _NC6314 _NC6315 NAND4X0
X2992 N292 N293 N254 _NC6316 _NC6317 OR2X1
X2993 S_expb[3] S_expb[2] S_expb[1] S_expb[0] N290 _NC6318 _NC6319 NAND4X0
X2994 S_expb[7] S_expb[6] S_expb[5] S_expb[4] N291 _NC6320 _NC6321 NAND4X0
X2995 N290 N291 N252 _NC6322 _NC6323 OR2X1
X2996 N288 N289 N265 N258 _NC6324 _NC6325 AO21X1
X2997 N258 N287 N266 _NC6326 _NC6327 AND2X1
X2998 S_opa_i[30] S_opa_i[29] S_opa_i[28] N277 _NC6328 _NC6329 OR3X1
X2999 S_opa_i[10] S_opa_i[0] N286 _NC6330 _NC6331 OR2X1
X3000 N286 S_opa_i[11] S_opa_i[13] S_opa_i[12] N279 _NC6332 _NC6333 NOR4X0
X3001 S_opa_i[19] S_opa_i[18] S_opa_i[17] N285 _NC6334 _NC6335 OR3X1
X3002 N285 S_opa_i[14] S_opa_i[16] S_opa_i[15] N280 _NC6336 _NC6337 NOR4X0
X3003 S_opa_i[3] S_opa_i[2] S_opa_i[22] N284 _NC6338 _NC6339 OR3X1
X3004 N284 S_opa_i[1] S_opa_i[21] S_opa_i[20] N281 _NC6340 _NC6341 NOR4X0
X3005 S_opa_i[9] S_opa_i[8] S_opa_i[7] N283 _NC6342 _NC6343 OR3X1
X3006 N283 S_opa_i[4] S_opa_i[6] S_opa_i[5] N282 _NC6344 _NC6345 NOR4X0
X3007 N279 N280 N281 N282 N259 _NC6346 _NC6347 NAND4X0
X3008 S_opa_i[23] N259 S_opa_i[25] S_opa_i[24] N278 _NC6348 _NC6349 OR4X1
X3009 S_opa_i[27] S_opa_i[26] N277 N278 N262 _NC6350 _NC6351 NOR4X0
X3010 S_opb_i[30] S_opb_i[29] S_opb_i[28] N267 _NC6352 _NC6353 OR3X1
X3011 S_opb_i[10] S_opb_i[0] N276 _NC6354 _NC6355 OR2X1
X3012 N276 S_opb_i[11] S_opb_i[13] S_opb_i[12] N269 _NC6356 _NC6357 NOR4X0
X3013 S_opb_i[19] S_opb_i[18] S_opb_i[17] N275 _NC6358 _NC6359 OR3X1
X3014 N275 S_opb_i[14] S_opb_i[16] S_opb_i[15] N270 _NC6360 _NC6361 NOR4X0
X3015 S_opb_i[3] S_opb_i[2] S_opb_i[22] N274 _NC6362 _NC6363 OR3X1
X3016 N274 S_opb_i[1] S_opb_i[21] S_opb_i[20] N271 _NC6364 _NC6365 NOR4X0
X3017 S_opb_i[9] S_opb_i[8] S_opb_i[7] N273 _NC6366 _NC6367 OR3X1
X3018 N273 S_opb_i[4] S_opb_i[6] S_opb_i[5] N272 _NC6368 _NC6369 NOR4X0
X3019 N269 N270 N271 N272 N260 _NC6370 _NC6371 NAND4X0
X3020 S_opb_i[23] N260 S_opb_i[25] S_opb_i[24] N268 _NC6372 _NC6373 OR4X1
X3021 S_opb_i[27] S_opb_i[26] N267 N268 N261 _NC6374 _NC6375 NOR4X0
X3022 N266 N262 N261 N3532 _NC6376 _NC6377 NOR3X0
X3023 S_r_zeros[1] S_r_zeros[3] S_r_zeros[2] N264 _NC6378 _NC6379 NOR3X0
X3024 S_r_zeros[4] N238 S_r_zeros[5] N264 N257 _NC6380 _NC6381 NAND4X0
X3025 S_frac_rnd[1] N246 S_frac_rnd[0] N1079 S_output_o[0] _NC6382 _NC6383 AO22X1
X3026 S_frac_rnd[11] N246 S_frac_rnd[10] N1080 S_output_o[10] _NC6384 _NC6385 AO22X1
X3027 S_frac_rnd[12] N246 S_frac_rnd[11] N247 S_output_o[11] _NC6386 _NC6387 AO22X1
X3028 S_frac_rnd[13] N246 S_frac_rnd[12] N1079 S_output_o[12] _NC6388 _NC6389 AO22X1
X3029 S_frac_rnd[14] N246 S_frac_rnd[13] N1080 S_output_o[13] _NC6390 _NC6391 AO22X1
X3030 S_frac_rnd[15] N246 S_frac_rnd[14] N247 S_output_o[14] _NC6392 _NC6393 AO22X1
X3031 S_frac_rnd[16] N246 S_frac_rnd[15] N1079 S_output_o[15] _NC6394 _NC6395 AO22X1
X3032 S_frac_rnd[17] N246 S_frac_rnd[16] N1080 S_output_o[16] _NC6396 _NC6397 AO22X1
X3033 S_frac_rnd[18] N246 S_frac_rnd[17] N247 S_output_o[17] _NC6398 _NC6399 AO22X1
X3034 S_frac_rnd[19] N246 S_frac_rnd[18] N1079 S_output_o[18] _NC6400 _NC6401 AO22X1
X3035 S_frac_rnd[20] N246 S_frac_rnd[19] N1080 S_output_o[19] _NC6402 _NC6403 AO22X1
X3036 S_frac_rnd[2] N246 S_frac_rnd[1] N247 S_output_o[1] _NC6404 _NC6405 AO22X1
X3037 S_frac_rnd[21] N246 S_frac_rnd[20] N1079 S_output_o[20] _NC6406 _NC6407 AO22X1
X3038 S_frac_rnd[22] N246 S_frac_rnd[21] N1080 S_output_o[21] _NC6408 _NC6409 AO22X1
X3039 S_frac_rnd[23] S_frac_rnd[24] S_frac_rnd[22] N244 N256 _NC6410 _NC6411 AO22X1
X3040 N1193 N256 N257 N258 N255 _NC6412 _NC6413 NAND4X0
X3041 N1193 N251 N1192 N252 N253 S_output_o[22] _NC6414 _NC6415 OAI221X1
X3042 N248 S_expo2b[0] N249 N3346 N250 S_output_o[23] _NC6416 _NC6417 AO221X1
X3043 N248 S_expo2b[1] N249 N3347 N250 S_output_o[24] _NC6418 _NC6419 AO221X1
X3044 N248 S_expo2b[2] N249 N3348 N250 S_output_o[25] _NC6420 _NC6421 AO221X1
X3045 N248 S_expo2b[3] N249 N3349 N250 S_output_o[26] _NC6422 _NC6423 AO221X1
X3046 N248 S_expo2b[4] N249 N3350 N250 S_output_o[27] _NC6424 _NC6425 AO221X1
X3047 N248 S_expo2b[5] N249 N3351 N250 S_output_o[28] _NC6426 _NC6427 AO221X1
X3048 N248 S_expo2b[6] N249 N3352 N250 S_output_o[29] _NC6428 _NC6429 AO221X1
X3049 S_frac_rnd[3] N246 S_frac_rnd[2] N247 S_output_o[2] _NC6430 _NC6431 AO22X1
X3050 N248 S_expo2b[7] N249 N3353 N250 S_output_o[30] _NC6432 _NC6433 AO221X1
X3051 S_frac_rnd[4] N246 S_frac_rnd[3] N1079 S_output_o[3] _NC6434 _NC6435 AO22X1
X3052 S_frac_rnd[5] N246 S_frac_rnd[4] N1080 S_output_o[4] _NC6436 _NC6437 AO22X1
X3053 S_frac_rnd[6] N246 S_frac_rnd[5] N247 S_output_o[5] _NC6438 _NC6439 AO22X1
X3054 S_frac_rnd[7] N246 S_frac_rnd[6] N1079 S_output_o[6] _NC6440 _NC6441 AO22X1
X3055 S_frac_rnd[8] N246 S_frac_rnd[7] N1080 S_output_o[7] _NC6442 _NC6443 AO22X1
X3056 N246 S_frac_rnd[9] S_frac_rnd[8] N247 S_output_o[8] _NC6444 _NC6445 AO22X1
X3057 S_frac_rnd[10] N246 S_frac_rnd[9] N1079 S_output_o[9] _NC6446 _NC6447 AO22X1
X3058 Clk_i S_output_o[0] Output_o[0] _NC6448 _NC6449 _NC6450 DFFX1
X3059 Clk_i N3303 S_frac_rnd[0] _NC6451 _NC6452 _NC6453 DFFX1
X3060 Clk_i S_output_o[1] Output_o[1] _NC6454 _NC6455 _NC6456 DFFX1
X3061 Clk_i N3304 S_frac_rnd[1] _NC6457 _NC6458 _NC6459 DFFX1
X3062 Clk_i S_output_o[2] Output_o[2] _NC6460 _NC6461 _NC6462 DFFX1
X3063 Clk_i N3305 S_frac_rnd[2] _NC6463 _NC6464 _NC6465 DFFX1
X3064 Clk_i S_output_o[3] Output_o[3] _NC6466 _NC6467 _NC6468 DFFX1
X3065 Clk_i N3306 S_frac_rnd[3] _NC6469 _NC6470 _NC6471 DFFX1
X3066 Clk_i S_output_o[4] Output_o[4] _NC6472 _NC6473 _NC6474 DFFX1
X3067 Clk_i N3307 S_frac_rnd[4] _NC6475 _NC6476 _NC6477 DFFX1
X3068 Clk_i S_output_o[5] Output_o[5] _NC6478 _NC6479 _NC6480 DFFX1
X3069 Clk_i N3308 S_frac_rnd[5] _NC6481 _NC6482 _NC6483 DFFX1
X3070 Clk_i S_output_o[6] Output_o[6] _NC6484 _NC6485 _NC6486 DFFX1
X3071 Clk_i N3309 S_frac_rnd[6] _NC6487 _NC6488 _NC6489 DFFX1
X3072 Clk_i S_output_o[7] Output_o[7] _NC6490 _NC6491 _NC6492 DFFX1
X3073 Clk_i N3310 S_frac_rnd[7] _NC6493 _NC6494 _NC6495 DFFX1
X3074 Clk_i S_output_o[8] Output_o[8] _NC6496 _NC6497 _NC6498 DFFX1
X3075 Clk_i N3311 S_frac_rnd[8] _NC6499 _NC6500 _NC6501 DFFX1
X3076 Clk_i S_output_o[9] Output_o[9] _NC6502 _NC6503 _NC6504 DFFX1
X3077 Clk_i N3312 S_frac_rnd[9] _NC6505 _NC6506 _NC6507 DFFX1
X3078 Clk_i S_output_o[10] Output_o[10] _NC6508 _NC6509 _NC6510 DFFX1
X3079 Clk_i N3313 S_frac_rnd[10] _NC6511 _NC6512 _NC6513 DFFX1
X3080 Clk_i S_output_o[11] Output_o[11] _NC6514 _NC6515 _NC6516 DFFX1
X3081 Clk_i N3314 S_frac_rnd[11] _NC6517 _NC6518 _NC6519 DFFX1
X3082 Clk_i S_output_o[12] Output_o[12] _NC6520 _NC6521 _NC6522 DFFX1
X3083 Clk_i N3315 S_frac_rnd[12] _NC6523 _NC6524 _NC6525 DFFX1
X3084 Clk_i S_output_o[13] Output_o[13] _NC6526 _NC6527 _NC6528 DFFX1
X3085 Clk_i N3316 S_frac_rnd[13] _NC6529 _NC6530 _NC6531 DFFX1
X3086 Clk_i S_output_o[14] Output_o[14] _NC6532 _NC6533 _NC6534 DFFX1
X3087 Clk_i N3317 S_frac_rnd[14] _NC6535 _NC6536 _NC6537 DFFX1
X3088 Clk_i S_output_o[15] Output_o[15] _NC6538 _NC6539 _NC6540 DFFX1
X3089 Clk_i N3318 S_frac_rnd[15] _NC6541 _NC6542 _NC6543 DFFX1
X3090 Clk_i S_output_o[16] Output_o[16] _NC6544 _NC6545 _NC6546 DFFX1
X3091 Clk_i N3319 S_frac_rnd[16] _NC6547 _NC6548 _NC6549 DFFX1
X3092 Clk_i S_output_o[17] Output_o[17] _NC6550 _NC6551 _NC6552 DFFX1
X3093 Clk_i N3320 S_frac_rnd[17] _NC6553 _NC6554 _NC6555 DFFX1
X3094 Clk_i S_output_o[18] Output_o[18] _NC6556 _NC6557 _NC6558 DFFX1
X3095 Clk_i N3321 S_frac_rnd[18] _NC6559 _NC6560 _NC6561 DFFX1
X3096 Clk_i S_output_o[19] Output_o[19] _NC6562 _NC6563 _NC6564 DFFX1
X3097 Clk_i N3322 S_frac_rnd[19] _NC6565 _NC6566 _NC6567 DFFX1
X3098 Clk_i S_output_o[20] Output_o[20] _NC6568 _NC6569 _NC6570 DFFX1
X3099 Clk_i N3323 S_frac_rnd[20] _NC6571 _NC6572 _NC6573 DFFX1
X3100 Clk_i S_output_o[21] Output_o[21] _NC6574 _NC6575 _NC6576 DFFX1
X3101 Clk_i N3324 S_frac_rnd[21] _NC6577 _NC6578 _NC6579 DFFX1
X3102 Clk_i S_output_o[22] Output_o[22] _NC6580 _NC6581 _NC6582 DFFX1
X3103 Clk_i N3325 S_frac_rnd[22] _NC6583 _NC6584 _NC6585 DFFX1
X3104 Clk_i N3326 S_frac_rnd[23] _NC6586 _NC6587 _NC6588 DFFX1
X3105 Clk_i S_output_o[23] Output_o[23] _NC6589 _NC6590 _NC6591 DFFX1
X3106 Clk_i S_output_o[24] Output_o[24] _NC6592 _NC6593 _NC6594 DFFX1
X3107 Clk_i S_output_o[25] Output_o[25] _NC6595 _NC6596 _NC6597 DFFX1
X3108 Clk_i S_output_o[26] Output_o[26] _NC6598 _NC6599 _NC6600 DFFX1
X3109 Clk_i S_output_o[27] Output_o[27] _NC6601 _NC6602 _NC6603 DFFX1
X3110 Clk_i S_output_o[28] Output_o[28] _NC6604 _NC6605 _NC6606 DFFX1
X3111 Clk_i S_output_o[29] Output_o[29] _NC6607 _NC6608 _NC6609 DFFX1
X3112 Clk_i S_output_o[30] Output_o[30] _NC6610 _NC6611 _NC6612 DFFX1
X3113 Clk_i N3532 Ine_o _NC6613 _NC6614 _NC6615 DFFX1
X3114 Clk_i N3327 S_frac_rnd[24] N244 _NC6616 _NC6617 DFFX1
X3115 Clk_i N3189 S_frac2a[0] _NC6618 _NC6619 _NC6620 DFFX1
X3116 Clk_i N3190 S_frac2a[1] _NC6621 _NC6622 _NC6623 DFFX1
X3117 Clk_i N3191 S_frac2a[2] _NC6624 _NC6625 _NC6626 DFFX1
X3118 Clk_i N3192 S_frac2a[3] _NC6627 _NC6628 _NC6629 DFFX1
X3119 Clk_i N3193 S_frac2a[4] _NC6630 _NC6631 _NC6632 DFFX1
X3120 Clk_i N3194 S_frac2a[5] _NC6633 _NC6634 _NC6635 DFFX1
X3121 Clk_i N3195 S_frac2a[6] _NC6636 _NC6637 _NC6638 DFFX1
X3122 Clk_i N3196 S_frac2a[7] _NC6639 _NC6640 _NC6641 DFFX1
X3123 Clk_i N3197 S_frac2a[8] _NC6642 _NC6643 _NC6644 DFFX1
X3124 Clk_i N3198 S_frac2a[9] _NC6645 _NC6646 _NC6647 DFFX1
X3125 Clk_i N3199 S_frac2a[10] _NC6648 _NC6649 _NC6650 DFFX1
X3126 Clk_i N3200 S_frac2a[11] _NC6651 _NC6652 _NC6653 DFFX1
X3127 Clk_i N3201 S_frac2a[12] _NC6654 _NC6655 _NC6656 DFFX1
X3128 Clk_i N3202 S_frac2a[13] _NC6657 _NC6658 _NC6659 DFFX1
X3129 Clk_i N3203 S_frac2a[14] _NC6660 _NC6661 _NC6662 DFFX1
X3130 Clk_i N3204 S_frac2a[15] _NC6663 _NC6664 _NC6665 DFFX1
X3131 Clk_i N3205 S_frac2a[16] _NC6666 _NC6667 _NC6668 DFFX1
X3132 Clk_i N3206 S_frac2a[17] _NC6669 _NC6670 _NC6671 DFFX1
X3133 Clk_i N3207 S_frac2a[18] _NC6672 _NC6673 _NC6674 DFFX1
X3134 Clk_i N3208 S_frac2a[19] _NC6675 _NC6676 _NC6677 DFFX1
X3135 Clk_i N3209 S_frac2a[20] _NC6678 _NC6679 _NC6680 DFFX1
X3136 Clk_i N3210 S_frac2a[21] _NC6681 _NC6682 _NC6683 DFFX1
X3137 Clk_i N3211 S_frac2a[22] _NC6684 _NC6685 _NC6686 DFFX1
X3138 Clk_i N3212 S_frac2a[23] _NC6687 _NC6688 _NC6689 DFFX1
X3139 Clk_i N3213 S_frac2a[24] _NC6690 _NC6691 _NC6692 DFFX1
X3140 Clk_i N3214 S_frac2a[25] _NC6693 _NC6694 _NC6695 DFFX1
X3141 Clk_i N3215 S_frac2a[26] _NC6696 _NC6697 _NC6698 DFFX1
X3142 Clk_i N3216 S_frac2a[27] _NC6699 _NC6700 _NC6701 DFFX1
X3143 Clk_i N3217 S_frac2a[28] _NC6702 _NC6703 _NC6704 DFFX1
X3144 Clk_i N3218 S_frac2a[29] _NC6705 _NC6706 _NC6707 DFFX1
X3145 Clk_i N3219 S_frac2a[30] _NC6708 _NC6709 _NC6710 DFFX1
X3146 Clk_i N3220 S_frac2a[31] _NC6711 _NC6712 _NC6713 DFFX1
X3147 Clk_i N3221 S_frac2a[32] _NC6714 _NC6715 _NC6716 DFFX1
X3148 Clk_i N3222 S_frac2a[33] _NC6717 _NC6718 _NC6719 DFFX1
X3149 Clk_i N3223 S_frac2a[34] _NC6720 _NC6721 _NC6722 DFFX1
X3150 Clk_i N3224 S_frac2a[35] _NC6723 _NC6724 _NC6725 DFFX1
X3151 Clk_i N3225 S_frac2a[36] _NC6726 _NC6727 _NC6728 DFFX1
X3152 Clk_i N3226 S_frac2a[37] _NC6729 _NC6730 _NC6731 DFFX1
X3153 Clk_i N3227 S_frac2a[38] _NC6732 _NC6733 _NC6734 DFFX1
X3154 Clk_i N3228 S_frac2a[39] _NC6735 _NC6736 _NC6737 DFFX1
X3155 Clk_i N3229 S_frac2a[40] _NC6738 _NC6739 _NC6740 DFFX1
X3156 Clk_i N3230 S_frac2a[41] _NC6741 _NC6742 _NC6743 DFFX1
X3157 Clk_i N3231 S_frac2a[42] _NC6744 _NC6745 _NC6746 DFFX1
X3158 Clk_i N3232 S_frac2a[43] _NC6747 _NC6748 _NC6749 DFFX1
X3159 Clk_i N3233 S_frac2a[44] _NC6750 _NC6751 _NC6752 DFFX1
X3160 Clk_i N3234 S_frac2a[45] _NC6753 _NC6754 _NC6755 DFFX1
X3161 Clk_i N3235 S_frac2a[46] _NC6756 _NC6757 _NC6758 DFFX1
X3162 Clk_i N3236 S_frac2a[47] _NC6759 _NC6760 _NC6761 DFFX1
X3163 Clk_i N3065 N11 N40 _NC6762 _NC6763 DFFX1
X3164 Clk_i N3066 S_shl2[0] N9 _NC6764 _NC6765 DFFX1
X3165 Clk_i N3067 S_shl2[1] N12 _NC6766 _NC6767 DFFX1
X3166 Clk_i N3068 S_shl2[2] _NC6768 _NC6769 _NC6770 DFFX1
X3167 Clk_i N3069 S_shl2[3] _NC6771 _NC6772 _NC6773 DFFX1
X3168 Clk_i N3070 S_shl2[4] _NC6774 _NC6775 _NC6776 DFFX1
X3169 Clk_i N3081 S_shr2[0] N37 _NC6777 _NC6778 DFFX1
X3170 Clk_i N3082 S_shr2[1] N38 _NC6779 _NC6780 DFFX1
X3171 Clk_i N3084 S_shr2[3] N41 _NC6781 _NC6782 DFFX1
X3172 Clk_i N3085 S_shr2[4] N43 _NC6783 _NC6784 DFFX1
X3173 Clk_i N3086 S_shr2[5] _NC6785 _NC6786 _NC6787 DFFX1
X3174 Clk_i S_exp_10b[0] S_expo1[0] _NC6788 Vdd N318 _NC6789 _NC6790 DFFSSRX1
X3175 Clk_i N3072 S_expo1[1] _NC6791 _NC6792 _NC6793 DFFX1
X3176 Clk_i N3073 S_expo1[2] _NC6794 _NC6795 _NC6796 DFFX1
X3177 Clk_i N3074 S_expo1[3] _NC6797 _NC6798 _NC6799 DFFX1
X3178 Clk_i N3075 S_expo1[4] _NC6800 _NC6801 _NC6802 DFFX1
X3179 Clk_i N3076 S_expo1[5] _NC6803 _NC6804 _NC6805 DFFX1
X3180 Clk_i N3077 S_expo1[6] _NC6806 _NC6807 _NC6808 DFFX1
X3181 Clk_i N3078 S_expo1[7] _NC6809 _NC6810 _NC6811 DFFX1
X3182 Clk_i N2974 S_r_zeros[0] N238 _NC6812 _NC6813 DFFX1
X3183 Clk_i N2975 S_r_zeros[1] N39 _NC6814 _NC6815 DFFX1
X3184 Clk_i N2976 S_r_zeros[2] _NC6816 _NC6817 _NC6818 DFFX1
X3185 Clk_i N2977 S_r_zeros[3] N35 _NC6819 _NC6820 DFFX1
X3186 Clk_i N2978 S_r_zeros[4] N42 _NC6821 _NC6822 DFFX1
X3187 Clk_i N2979 S_r_zeros[5] N10 _NC6823 _NC6824 DFFX1
X3188 Clk_i N1632 S_zeros[0] _NC6825 _NC6826 _NC6827 DFFX1
X3189 Clk_i N1633 S_zeros[1] _NC6828 _NC6829 _NC6830 DFFX1
X3190 Clk_i N1634 S_zeros[2] _NC6831 _NC6832 _NC6833 DFFX1
X3191 Clk_i N1635 S_zeros[3] _NC6834 _NC6835 _NC6836 DFFX1
X3192 Clk_i N1636 S_zeros[4] _NC6837 _NC6838 _NC6839 DFFX1
X3193 Clk_i N1637 S_zeros[5] _NC6840 _NC6841 _NC6842 DFFX1
X3194 Clk_i S_output_o[31] Output_o[31] _NC6843 _NC6844 _NC6845 DFFX1
X3195 Clk_i Rmode_i[0] _NC6846 N236 _NC6847 _NC6848 DFFX1
X3196 Clk_i Rmode_i[1] S_rmode_i[1] N235 _NC6849 _NC6850 DFFX1
X3197 Clk_i Sign_i S_output_o[31] _NC6851 _NC6852 _NC6853 DFFX1
X3198 Clk_i Fract_48_i[0] S_fract_48_i[0] N233 _NC6854 _NC6855 DFFX1
X3199 Clk_i Fract_48_i[1] S_fract_48_i[1] N1065 _NC6856 _NC6857 DFFX1
X3200 Clk_i Fract_48_i[2] S_fract_48_i[2] N232 _NC6858 _NC6859 DFFX1
X3201 Clk_i Fract_48_i[3] S_fract_48_i[3] N231 _NC6860 _NC6861 DFFX1
X3202 Clk_i Fract_48_i[4] S_fract_48_i[4] N229 _NC6862 _NC6863 DFFX1
X3203 Clk_i Fract_48_i[7] S_fract_48_i[7] N225 _NC6864 _NC6865 DFFX1
X3204 Clk_i Fract_48_i[8] S_fract_48_i[8] N224 _NC6866 _NC6867 DFFX1
X3205 Clk_i Fract_48_i[9] S_fract_48_i[9] N223 _NC6868 _NC6869 DFFX1
X3206 Clk_i Fract_48_i[10] S_fract_48_i[10] N222 _NC6870 _NC6871 DFFX1
X3207 Clk_i Fract_48_i[11] S_fract_48_i[11] N221 _NC6872 _NC6873 DFFX1
X3208 Clk_i Fract_48_i[13] S_fract_48_i[13] N214 _NC6874 _NC6875 DFFX1
X3209 Clk_i Fract_48_i[14] S_fract_48_i[14] N212 _NC6876 _NC6877 DFFX1
X3210 Clk_i Fract_48_i[15] S_fract_48_i[15] N210 _NC6878 _NC6879 DFFX1
X3211 Clk_i Fract_48_i[16] S_fract_48_i[16] N208 _NC6880 _NC6881 DFFX1
X3212 Clk_i Fract_48_i[17] S_fract_48_i[17] N206 _NC6882 _NC6883 DFFX1
X3213 Clk_i Fract_48_i[19] S_fract_48_i[19] N198 _NC6884 _NC6885 DFFX1
X3214 Clk_i Fract_48_i[20] S_fract_48_i[20] N197 _NC6886 _NC6887 DFFX1
X3215 Clk_i Fract_48_i[21] S_fract_48_i[21] N196 _NC6888 _NC6889 DFFX1
X3216 Clk_i Fract_48_i[22] S_fract_48_i[22] N189 _NC6890 _NC6891 DFFX1
X3217 Clk_i Fract_48_i[23] S_fract_48_i[23] N182 _NC6892 _NC6893 DFFX1
X3218 Clk_i Fract_48_i[25] S_fract_48_i[25] N174 _NC6894 _NC6895 DFFX1
X3219 Clk_i Fract_48_i[26] S_fract_48_i[26] N173 _NC6896 _NC6897 DFFX1
X3220 Clk_i Fract_48_i[27] S_fract_48_i[27] N172 _NC6898 _NC6899 DFFX1
X3221 Clk_i Fract_48_i[28] S_fract_48_i[28] N171 _NC6900 _NC6901 DFFX1
X3222 Clk_i Fract_48_i[29] S_fract_48_i[29] N170 _NC6902 _NC6903 DFFX1
X3223 Clk_i Fract_48_i[31] S_fract_48_i[31] N162 _NC6904 _NC6905 DFFX1
X3224 Clk_i Fract_48_i[32] S_fract_48_i[32] N160 _NC6906 _NC6907 DFFX1
X3225 Clk_i Fract_48_i[33] S_fract_48_i[33] N158 _NC6908 _NC6909 DFFX1
X3226 Clk_i Fract_48_i[34] S_fract_48_i[34] N156 _NC6910 _NC6911 DFFX1
X3227 Clk_i Fract_48_i[35] S_fract_48_i[35] N154 _NC6912 _NC6913 DFFX1
X3228 Clk_i Fract_48_i[37] S_fract_48_i[37] N146 _NC6914 _NC6915 DFFX1
X3229 Clk_i Fract_48_i[38] S_fract_48_i[38] N145 _NC6916 _NC6917 DFFX1
X3230 Clk_i Fract_48_i[39] S_fract_48_i[39] N144 _NC6918 _NC6919 DFFX1
X3231 Clk_i Fract_48_i[40] S_fract_48_i[40] N137 _NC6920 _NC6921 DFFX1
X3232 Clk_i Fract_48_i[41] S_fract_48_i[41] N130 _NC6922 _NC6923 DFFX1
X3233 Clk_i Fract_48_i[43] S_fract_48_i[43] N122 _NC6924 _NC6925 DFFX1
X3234 Clk_i Fract_48_i[44] S_fract_48_i[44] N119 _NC6926 _NC6927 DFFX1
X3235 Clk_i Fract_48_i[45] S_fract_48_i[45] N118 _NC6928 _NC6929 DFFX1
X3236 Clk_i Fract_48_i[46] S_fract_48_i[46] N69 _NC6930 _NC6931 DFFX1
X3237 Clk_i Fract_48_i[47] N2993 N68 _NC6932 _NC6933 DFFX1
X3238 Clk_i Exp_10_i[0] S_exp_10_i[0] _NC6934 _NC6935 _NC6936 DFFX1
X3239 Clk_i Exp_10_i[1] S_exp_10_i[1] _NC6937 _NC6938 _NC6939 DFFX1
X3240 Clk_i Exp_10_i[2] S_exp_10_i[2] _NC6940 _NC6941 _NC6942 DFFX1
X3241 Clk_i Exp_10_i[3] S_exp_10_i[3] _NC6943 _NC6944 _NC6945 DFFX1
X3242 Clk_i Exp_10_i[4] S_exp_10_i[4] _NC6946 _NC6947 _NC6948 DFFX1
X3243 Clk_i Exp_10_i[5] S_exp_10_i[5] _NC6949 _NC6950 _NC6951 DFFX1
X3244 Clk_i Exp_10_i[6] S_exp_10_i[6] _NC6952 _NC6953 _NC6954 DFFX1
X3245 Clk_i Exp_10_i[7] S_exp_10_i[7] _NC6955 _NC6956 _NC6957 DFFX1
X3246 Clk_i Exp_10_i[8] S_exp_10_i[8] _NC6958 _NC6959 _NC6960 DFFX1
X3247 Clk_i Exp_10_i[9] S_exp_10_i[9] _NC6961 _NC6962 _NC6963 DFFX1
X3248 Clk_i Opb_i[23] S_expb[0] _NC6964 _NC6965 _NC6966 DFFX1
X3249 Clk_i Opb_i[24] S_expb[1] _NC6967 _NC6968 _NC6969 DFFX1
X3250 Clk_i Opb_i[25] S_expb[2] _NC6970 _NC6971 _NC6972 DFFX1
X3251 Clk_i Opb_i[26] S_expb[3] _NC6973 _NC6974 _NC6975 DFFX1
X3252 Clk_i Opb_i[27] S_expb[4] _NC6976 _NC6977 _NC6978 DFFX1
X3253 Clk_i Opb_i[28] S_expb[5] _NC6979 _NC6980 _NC6981 DFFX1
X3254 Clk_i Opb_i[29] S_expb[6] _NC6982 _NC6983 _NC6984 DFFX1
X3255 Clk_i Opb_i[30] S_expb[7] _NC6985 _NC6986 _NC6987 DFFX1
X3256 Clk_i Opa_i[23] S_expa[0] _NC6988 _NC6989 _NC6990 DFFX1
X3257 Clk_i Opa_i[24] S_expa[1] _NC6991 _NC6992 _NC6993 DFFX1
X3258 Clk_i Opa_i[25] S_expa[2] _NC6994 _NC6995 _NC6996 DFFX1
X3259 Clk_i Opa_i[26] S_expa[3] _NC6997 _NC6998 _NC6999 DFFX1
X3260 Clk_i Opa_i[27] S_expa[4] _NC7000 _NC7001 _NC7002 DFFX1
X3261 Clk_i Opa_i[28] S_expa[5] _NC7003 _NC7004 _NC7005 DFFX1
X3262 Clk_i Opa_i[29] S_expa[6] _NC7006 _NC7007 _NC7008 DFFX1
X3263 Clk_i Opa_i[30] S_expa[7] _NC7009 _NC7010 _NC7011 DFFX1
X3264 Clk_i Opb_i[0] S_opb_i[0] _NC7012 _NC7013 _NC7014 DFFX1
X3265 Clk_i Opb_i[1] S_opb_i[1] _NC7015 _NC7016 _NC7017 DFFX1
X3266 Clk_i Opb_i[2] S_opb_i[2] _NC7018 _NC7019 _NC7020 DFFX1
X3267 Clk_i Opb_i[3] S_opb_i[3] _NC7021 _NC7022 _NC7023 DFFX1
X3268 Clk_i Opb_i[4] S_opb_i[4] _NC7024 _NC7025 _NC7026 DFFX1
X3269 Clk_i Opb_i[5] S_opb_i[5] _NC7027 _NC7028 _NC7029 DFFX1
X3270 Clk_i Opb_i[6] S_opb_i[6] _NC7030 _NC7031 _NC7032 DFFX1
X3271 Clk_i Opb_i[7] S_opb_i[7] _NC7033 _NC7034 _NC7035 DFFX1
X3272 Clk_i Opb_i[8] S_opb_i[8] _NC7036 _NC7037 _NC7038 DFFX1
X3273 Clk_i Opb_i[9] S_opb_i[9] _NC7039 _NC7040 _NC7041 DFFX1
X3274 Clk_i Opb_i[10] S_opb_i[10] _NC7042 _NC7043 _NC7044 DFFX1
X3275 Clk_i Opb_i[11] S_opb_i[11] _NC7045 _NC7046 _NC7047 DFFX1
X3276 Clk_i Opb_i[12] S_opb_i[12] _NC7048 _NC7049 _NC7050 DFFX1
X3277 Clk_i Opb_i[13] S_opb_i[13] _NC7051 _NC7052 _NC7053 DFFX1
X3278 Clk_i Opb_i[14] S_opb_i[14] _NC7054 _NC7055 _NC7056 DFFX1
X3279 Clk_i Opb_i[15] S_opb_i[15] _NC7057 _NC7058 _NC7059 DFFX1
X3280 Clk_i Opb_i[16] S_opb_i[16] _NC7060 _NC7061 _NC7062 DFFX1
X3281 Clk_i Opb_i[17] S_opb_i[17] _NC7063 _NC7064 _NC7065 DFFX1
X3282 Clk_i Opb_i[18] S_opb_i[18] _NC7066 _NC7067 _NC7068 DFFX1
X3283 Clk_i Opb_i[19] S_opb_i[19] _NC7069 _NC7070 _NC7071 DFFX1
X3284 Clk_i Opb_i[20] S_opb_i[20] _NC7072 _NC7073 _NC7074 DFFX1
X3285 Clk_i Opb_i[21] S_opb_i[21] _NC7075 _NC7076 _NC7077 DFFX1
X3286 Clk_i Opb_i[22] S_opb_i[22] _NC7078 _NC7079 _NC7080 DFFX1
X3287 Clk_i Opb_i[23] S_opb_i[23] _NC7081 _NC7082 _NC7083 DFFX1
X3288 Clk_i Opb_i[24] S_opb_i[24] _NC7084 _NC7085 _NC7086 DFFX1
X3289 Clk_i Opb_i[25] S_opb_i[25] _NC7087 _NC7088 _NC7089 DFFX1
X3290 Clk_i Opb_i[26] S_opb_i[26] _NC7090 _NC7091 _NC7092 DFFX1
X3291 Clk_i Opb_i[27] S_opb_i[27] _NC7093 _NC7094 _NC7095 DFFX1
X3292 Clk_i Opb_i[28] S_opb_i[28] _NC7096 _NC7097 _NC7098 DFFX1
X3293 Clk_i Opb_i[29] S_opb_i[29] _NC7099 _NC7100 _NC7101 DFFX1
X3294 Clk_i Opb_i[30] S_opb_i[30] _NC7102 _NC7103 _NC7104 DFFX1
X3295 Clk_i Opa_i[0] S_opa_i[0] _NC7105 _NC7106 _NC7107 DFFX1
X3296 Clk_i Opa_i[1] S_opa_i[1] _NC7108 _NC7109 _NC7110 DFFX1
X3297 Clk_i Opa_i[2] S_opa_i[2] _NC7111 _NC7112 _NC7113 DFFX1
X3298 Clk_i Opa_i[3] S_opa_i[3] _NC7114 _NC7115 _NC7116 DFFX1
X3299 Clk_i Opa_i[4] S_opa_i[4] _NC7117 _NC7118 _NC7119 DFFX1
X3300 Clk_i Opa_i[5] S_opa_i[5] _NC7120 _NC7121 _NC7122 DFFX1
X3301 Clk_i Opa_i[6] S_opa_i[6] _NC7123 _NC7124 _NC7125 DFFX1
X3302 Clk_i Opa_i[7] S_opa_i[7] _NC7126 _NC7127 _NC7128 DFFX1
X3303 Clk_i Opa_i[8] S_opa_i[8] _NC7129 _NC7130 _NC7131 DFFX1
X3304 Clk_i Opa_i[9] S_opa_i[9] _NC7132 _NC7133 _NC7134 DFFX1
X3305 Clk_i Opa_i[10] S_opa_i[10] _NC7135 _NC7136 _NC7137 DFFX1
X3306 Clk_i Opa_i[11] S_opa_i[11] _NC7138 _NC7139 _NC7140 DFFX1
X3307 Clk_i Opa_i[12] S_opa_i[12] _NC7141 _NC7142 _NC7143 DFFX1
X3308 Clk_i Opa_i[13] S_opa_i[13] _NC7144 _NC7145 _NC7146 DFFX1
X3309 Clk_i Opa_i[14] S_opa_i[14] _NC7147 _NC7148 _NC7149 DFFX1
X3310 Clk_i Opa_i[15] S_opa_i[15] _NC7150 _NC7151 _NC7152 DFFX1
X3311 Clk_i Opa_i[16] S_opa_i[16] _NC7153 _NC7154 _NC7155 DFFX1
X3312 Clk_i Opa_i[17] S_opa_i[17] _NC7156 _NC7157 _NC7158 DFFX1
X3313 Clk_i Opa_i[18] S_opa_i[18] _NC7159 _NC7160 _NC7161 DFFX1
X3314 Clk_i Opa_i[19] S_opa_i[19] _NC7162 _NC7163 _NC7164 DFFX1
X3315 Clk_i Opa_i[20] S_opa_i[20] _NC7165 _NC7166 _NC7167 DFFX1
X3316 Clk_i Opa_i[21] S_opa_i[21] _NC7168 _NC7169 _NC7170 DFFX1
X3317 Clk_i Opa_i[22] S_opa_i[22] _NC7171 _NC7172 _NC7173 DFFX1
X3318 Clk_i Opa_i[23] S_opa_i[23] _NC7174 _NC7175 _NC7176 DFFX1
X3319 Clk_i Opa_i[24] S_opa_i[24] _NC7177 _NC7178 _NC7179 DFFX1
X3320 Clk_i Opa_i[25] S_opa_i[25] _NC7180 _NC7181 _NC7182 DFFX1
X3321 Clk_i Opa_i[26] S_opa_i[26] _NC7183 _NC7184 _NC7185 DFFX1
X3322 Clk_i Opa_i[27] S_opa_i[27] _NC7186 _NC7187 _NC7188 DFFX1
X3323 Clk_i Opa_i[28] S_opa_i[28] _NC7189 _NC7190 _NC7191 DFFX1
X3324 Clk_i Opa_i[29] S_opa_i[29] _NC7192 _NC7193 _NC7194 DFFX1
X3325 Clk_i Opa_i[30] S_opa_i[30] _NC7195 _NC7196 _NC7197 DFFX1
.ENDS post_norm_mul

.SUBCKT post_norm_mul_DW01_sub_2 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] DIFF[9] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 N2 A[8] DIFF[8] _NC2 _NC3 XOR2X1
X2 N1 A[7] DIFF[7] _NC4 _NC5 XOR2X1
X3 N4 A[6] DIFF[6] _NC6 _NC7 XOR2X1
X4 B[4] _NC8 _NC9 N9 INVX0
X5 A[0] _NC10 _NC11 N7 INVX0
X6 N7 B[0] Carry[0] _NC12 _NC13 NAND2X1
X7 B[1] _NC14 _NC15 N12 INVX0
X8 B[2] _NC16 _NC17 N11 INVX0
X9 B[3] _NC18 _NC19 N10 INVX0
X10 B[5] _NC20 _NC21 N8 INVX0
X11 A[8] _NC22 _NC23 N6 INVX0
X12 N6 N2 Carry[8] _NC24 _NC25 NAND2X1
X13 N5 N1 N2 _NC26 _NC27 AND2X1
X14 N3 N4 N1 _NC28 _NC29 AND2X1
X15 Carry[5] _NC30 _NC31 N4 INVX0
X16 Carry[8] A[9] DIFF[9] _NC32 _NC33 XNOR2X1
X17 A[6] _NC34 _NC35 N3 INVX0
X18 A[7] _NC36 _NC37 N5 INVX0
X19 A[1] N12 Carry[0] Carry[1] DIFF[1] _NC38 _NC39 FADDX1
X20 A[2] N11 Carry[1] Carry[2] DIFF[2] _NC40 _NC41 FADDX1
X21 A[3] N10 Carry[2] Carry[3] DIFF[3] _NC42 _NC43 FADDX1
X22 A[4] N9 Carry[3] Carry[4] DIFF[4] _NC44 _NC45 FADDX1
X23 A[5] N8 Carry[4] Carry[5] DIFF[5] _NC46 _NC47 FADDX1
.ENDS post_norm_mul_DW01_sub_2

.SUBCKT post_norm_mul_DW01_sub_1 A[0] A[1] A[2] A[3] A[4] A[5] B[0] B[1] B[2] B[3] B[4] B[5] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 A[0] _NC2 _NC3 N1 INVX0
X2 N1 B[0] Carry[0] _NC4 _NC5 NAND2X1
X3 B[1] _NC6 _NC7 N6 INVX0
X4 B[4] _NC8 _NC9 N3 INVX0
X5 B[3] _NC10 _NC11 N4 INVX0
X6 B[2] _NC12 _NC13 N5 INVX0
X7 B[5] _NC14 _NC15 N2 INVX0
X8 A[5] N2 Carry[4] DIFF[5] _NC16 _NC17 XOR3X1
X9 A[1] N6 Carry[0] Carry[1] DIFF[1] _NC18 _NC19 FADDX1
X10 A[2] N5 Carry[1] Carry[2] DIFF[2] _NC20 _NC21 FADDX1
X11 A[3] N4 Carry[2] Carry[3] DIFF[3] _NC22 _NC23 FADDX1
X12 A[4] N3 Carry[3] Carry[4] DIFF[4] _NC24 _NC25 FADDX1
.ENDS post_norm_mul_DW01_sub_1

.SUBCKT post_norm_mul_DW01_inc_1 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24]
X0 A[0] _NC0 _NC1 SUM[0] INVX0
X1 Carry[22] A[24] SUM[24] _NC2 _NC3 XOR2X1
X2 A[1] A[0] Carry[0] _NC4 _NC5 _NC6 HADDX1
X3 A[2] Carry[0] Carry[1] _NC7 _NC8 _NC9 HADDX1
X4 A[3] Carry[1] Carry[2] _NC10 _NC11 _NC12 HADDX1
X5 A[4] Carry[2] Carry[3] _NC13 _NC14 _NC15 HADDX1
X6 A[5] Carry[3] Carry[4] _NC16 _NC17 _NC18 HADDX1
X7 A[6] Carry[4] Carry[5] _NC19 _NC20 _NC21 HADDX1
X8 A[7] Carry[5] Carry[6] _NC22 _NC23 _NC24 HADDX1
X9 A[8] Carry[6] Carry[7] _NC25 _NC26 _NC27 HADDX1
X10 A[9] Carry[7] Carry[8] _NC28 _NC29 _NC30 HADDX1
X11 A[10] Carry[8] Carry[9] _NC31 _NC32 _NC33 HADDX1
X12 A[11] Carry[9] Carry[10] _NC34 _NC35 _NC36 HADDX1
X13 A[12] Carry[10] Carry[11] _NC37 _NC38 _NC39 HADDX1
X14 A[13] Carry[11] Carry[12] _NC40 _NC41 _NC42 HADDX1
X15 A[14] Carry[12] Carry[13] _NC43 _NC44 _NC45 HADDX1
X16 A[15] Carry[13] Carry[14] _NC46 _NC47 _NC48 HADDX1
X17 A[16] Carry[14] Carry[15] _NC49 _NC50 _NC51 HADDX1
X18 A[17] Carry[15] Carry[16] _NC52 _NC53 _NC54 HADDX1
X19 A[18] Carry[16] Carry[17] _NC55 _NC56 _NC57 HADDX1
X20 A[19] Carry[17] Carry[18] _NC58 _NC59 _NC60 HADDX1
X21 A[20] Carry[18] Carry[19] _NC61 _NC62 _NC63 HADDX1
X22 A[21] Carry[19] Carry[20] _NC64 _NC65 _NC66 HADDX1
X23 A[22] Carry[20] Carry[21] _NC67 _NC68 _NC69 HADDX1
X24 A[23] Carry[21] Carry[22] _NC70 _NC71 _NC72 HADDX1
.ENDS post_norm_mul_DW01_inc_1

.SUBCKT post_norm_mul_DW01_inc_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8]
X0 A[0] _NC0 _NC1 SUM[0] INVX0
X1 Carry[6] A[8] SUM[8] _NC2 _NC3 XOR2X1
X2 A[1] A[0] Carry[0] _NC4 _NC5 _NC6 HADDX1
X3 A[2] Carry[0] Carry[1] _NC7 _NC8 _NC9 HADDX1
X4 A[3] Carry[1] Carry[2] _NC10 _NC11 _NC12 HADDX1
X5 A[4] Carry[2] Carry[3] _NC13 _NC14 _NC15 HADDX1
X6 A[5] Carry[3] Carry[4] _NC16 _NC17 _NC18 HADDX1
X7 A[6] Carry[4] Carry[5] _NC19 _NC20 _NC21 HADDX1
X8 A[7] Carry[5] Carry[6] _NC22 _NC23 _NC24 HADDX1
.ENDS post_norm_mul_DW01_inc_0

.SUBCKT serial_mul Clk_i Fracta_i[0] Fracta_i[1] Fracta_i[2] Fracta_i[3] Fracta_i[4] Fracta_i[5] Fracta_i[6] Fracta_i[7] Fracta_i[8] Fracta_i[9] Fracta_i[10] Fracta_i[11] Fracta_i[12] Fracta_i[13] Fracta_i[14] Fracta_i[15] Fracta_i[16] Fracta_i[17] Fracta_i[18] Fracta_i[19] Fracta_i[20] Fracta_i[21] Fracta_i[22] Fracta_i[23] Fractb_i[0] Fractb_i[1] Fractb_i[2] Fractb_i[3] Fractb_i[4] Fractb_i[5] Fractb_i[6] Fractb_i[7] Fractb_i[8] Fractb_i[9] Fractb_i[10] Fractb_i[11] Fractb_i[12] Fractb_i[13] Fractb_i[14] Fractb_i[15] Fractb_i[16] Fractb_i[17] Fractb_i[18] Fractb_i[19] Fractb_i[20] Fractb_i[21] Fractb_i[22] Fractb_i[23] Signa_i Signb_i Start_i Fract_o[0] Fract_o[1] Fract_o[2] Fract_o[3] Fract_o[4] Fract_o[5] Fract_o[6] Fract_o[7] Fract_o[8] Fract_o[9] Fract_o[10] Fract_o[11] Fract_o[12] Fract_o[13] Fract_o[14] Fract_o[15] Fract_o[16] Fract_o[17] Fract_o[18] Fract_o[19] Fract_o[20] Fract_o[21] Fract_o[22] Fract_o[23] Fract_o[24] Fract_o[25] Fract_o[26] Fract_o[27] Fract_o[28] Fract_o[29] Fract_o[30] Fract_o[31] Fract_o[32] Fract_o[33] Fract_o[34] Fract_o[35] Fract_o[36] Fract_o[37] Fract_o[38] Fract_o[39] Fract_o[40] Fract_o[41] Fract_o[42] Fract_o[43] Fract_o[44] Fract_o[45] Fract_o[46] Fract_o[47] Sign_o Ready_o
X0 N104 N279 N2460 _NC0 _NC1 AND2X1
X1 N5 N278 N2459 _NC2 _NC3 AND2X1
X2 N5 N277 N2458 _NC4 _NC5 AND2X1
X3 N5 N276 N2457 _NC6 _NC7 AND2X1
X4 N275 N103 N2500 _NC8 _NC9 AND2X1
X5 N5 N267 N2456 _NC10 _NC11 AND2X1
X6 N265 N123 N2491 N103 _NC12 _NC13 MUX21X1
X7 N263 N125 N2490 N103 _NC14 _NC15 MUX21X1
X8 N261 N127 N2489 N103 _NC16 _NC17 MUX21X1
X9 N259 N258 N2488 N103 _NC18 _NC19 MUX21X1
X10 N256 N130 N2487 N102 _NC20 _NC21 MUX21X1
X11 N254 N132 N2486 N103 _NC22 _NC23 MUX21X1
X12 N252 N134 N2485 N103 _NC24 _NC25 MUX21X1
X13 N275 N136 N2484 N102 _NC26 _NC27 MUX21X1
X14 N274 N248 N249 N102 _NC28 _NC29 MUX21X1
X15 N264 N247 N274 S_count[3] _NC30 _NC31 MUX21X1
X16 N5 N245 N2455 _NC32 _NC33 AND2X1
X17 N273 N243 N244 N102 _NC34 _NC35 MUX21X1
X18 N262 N242 N273 S_count[3] _NC36 _NC37 MUX21X1
X19 N241 N4 N262 _NC38 _NC39 OR2X1
X20 N272 N239 N240 N102 _NC40 _NC41 MUX21X1
X21 N260 N238 N272 S_count[3] _NC42 _NC43 MUX21X1
X22 N4 N237 N260 _NC44 _NC45 OR2X1
X23 N271 N235 N236 N102 _NC46 _NC47 MUX21X1
X24 N257 N129 N271 S_count[3] _NC48 _NC49 MUX21X1
X25 N270 N231 N232 N102 _NC50 _NC51 MUX21X1
X26 N255 N230 N270 S_count[3] _NC52 _NC53 MUX21X1
X27 N122 N229 N255 N1 _NC54 _NC55 MUX21X1
X28 N269 N281 N227 N102 _NC56 _NC57 MUX21X1
X29 N226 N225 N281 N100 _NC58 _NC59 MUX21X1
X30 N253 N224 N269 N100 _NC60 _NC61 MUX21X1
X31 N241 N126 N253 N99 _NC62 _NC63 MUX21X1
X32 N268 N280 N222 N102 _NC64 _NC65 MUX21X1
X33 N221 N220 N280 N100 _NC66 _NC67 MUX21X1
X34 N251 N219 N268 N100 _NC68 _NC69 MUX21X1
X35 N237 N218 N251 N99 _NC70 _NC71 MUX21X1
X36 N228 N124 N237 N98 _NC72 _NC73 MUX21X1
X37 N120 N279 N2476 N102 _NC74 _NC75 MUX21X1
X38 N121 N137 N266 N100 _NC76 _NC77 MUX21X1
X39 N233 N216 N217 N99 _NC78 _NC79 MUX21X1
X40 N223 N215 N233 N98 _NC80 _NC81 MUX21X1
X41 S_tem_prod[23] S_tem_prod[22] N223 S_count[0] _NC82 _NC83 MUX21X1
X42 N123 N278 N2475 N102 _NC84 _NC85 MUX21X1
X43 N247 N212 N213 N100 _NC86 _NC87 MUX21X1
X44 N229 N211 N247 N99 _NC88 _NC89 MUX21X1
X45 N124 N128 N229 N98 _NC90 _NC91 MUX21X1
X46 S_tem_prod[22] S_tem_prod[21] N210 S_count[0] _NC92 _NC93 MUX21X1
X47 N125 N277 N2474 N102 _NC94 _NC95 MUX21X1
X48 N242 N207 N208 N100 _NC96 _NC97 MUX21X1
X49 N126 N133 N242 N99 _NC98 _NC99 MUX21X1
X50 N215 N205 N206 N98 _NC100 _NC101 MUX21X1
X51 S_tem_prod[21] S_tem_prod[20] N215 S_count[0] _NC102 _NC103 MUX21X1
X52 N127 N276 N2473 N102 _NC104 _NC105 MUX21X1
X53 N238 N202 N203 N100 _NC106 _NC107 MUX21X1
X54 N218 N201 N238 N99 _NC108 _NC109 MUX21X1
X55 N128 N131 N218 N98 _NC110 _NC111 MUX21X1
X56 S_tem_prod[20] S_tem_prod[19] N200 S_count[0] _NC112 _NC113 MUX21X1
X57 N5 N199 N2454 _NC114 _NC115 AND2X1
X58 N258 N267 N2472 N102 _NC116 _NC117 MUX21X1
X59 N197 N234 N258 N11 _NC118 _NC119 MUX21X1
X60 N216 N196 N234 N99 _NC120 _NC121 MUX21X1
X61 N205 N195 N216 N98 _NC122 _NC123 MUX21X1
X62 S_tem_prod[19] S_tem_prod[18] N205 S_count[0] _NC124 _NC125 MUX21X1
X63 N130 N245 N2471 N102 _NC126 _NC127 MUX21X1
X64 N230 N192 N193 N100 _NC128 _NC129 MUX21X1
X65 N211 N191 N230 N99 _NC130 _NC131 MUX21X1
X66 N131 N135 N211 N98 _NC132 _NC133 MUX21X1
X67 S_tem_prod[18] S_tem_prod[17] N190 S_count[0] _NC134 _NC135 MUX21X1
X68 N132 N199 N2470 N102 _NC136 _NC137 MUX21X1
X69 N189 N99 N225 _NC138 _NC139 OR2X1
X70 N224 N226 N188 N100 _NC140 _NC141 MUX21X1
X71 N143 N147 N226 N99 _NC142 _NC143 MUX21X1
X72 N133 N139 N224 N99 _NC144 _NC145 MUX21X1
X73 N195 N186 N187 N98 _NC146 _NC147 MUX21X1
X74 S_tem_prod[17] S_tem_prod[16] N195 S_count[0] _NC148 _NC149 MUX21X1
X75 N134 N185 N2469 N102 _NC150 _NC151 MUX21X1
X76 N219 N221 N184 N100 _NC152 _NC153 MUX21X1
X77 N183 N182 N221 N99 _NC154 _NC155 MUX21X1
X78 N201 N181 N219 N99 _NC156 _NC157 MUX21X1
X79 N135 N138 N201 N98 _NC158 _NC159 MUX21X1
X80 S_tem_prod[16] S_tem_prod[15] N180 S_count[0] _NC160 _NC161 MUX21X1
X81 N137 N145 N250 N100 _NC162 _NC163 MUX21X1
X82 N178 N177 N179 N99 _NC164 _NC165 MUX21X1
X83 N196 N175 N176 N99 _NC166 _NC167 MUX21X1
X84 N186 N174 N196 N98 _NC168 _NC169 MUX21X1
X85 S_tem_prod[15] S_tem_prod[14] N186 S_count[0] _NC170 _NC171 MUX21X1
X86 N212 N214 N248 N100 _NC172 _NC173 MUX21X1
X87 N173 N172 N214 N99 _NC174 _NC175 MUX21X1
X88 N191 N171 N212 N99 _NC176 _NC177 MUX21X1
X89 N138 N140 N191 N98 _NC178 _NC179 MUX21X1
X90 S_tem_prod[14] S_tem_prod[13] N170 S_count[0] _NC180 _NC181 MUX21X1
X91 N207 N209 N243 N100 _NC182 _NC183 MUX21X1
X92 N147 N189 N209 N99 _NC184 _NC185 MUX21X1
X93 N167 N166 N168 N98 _NC186 _NC187 MUX21X1
X94 N139 N143 N207 N99 _NC188 _NC189 MUX21X1
X95 N164 N163 N165 N98 _NC190 _NC191 MUX21X1
X96 N174 N161 N162 N98 _NC192 _NC193 MUX21X1
X97 S_tem_prod[13] S_tem_prod[12] N174 S_count[0] _NC194 _NC195 MUX21X1
X98 N202 N204 N239 N100 _NC196 _NC197 MUX21X1
X99 N182 N160 N204 N99 _NC198 _NC199 MUX21X1
X100 N148 N149 N182 N98 _NC200 _NC201 MUX21X1
X101 N181 N183 N202 N99 _NC202 _NC203 MUX21X1
X102 N144 N146 N183 N2 _NC204 _NC205 MUX21X1
X103 N140 N142 N181 N2 _NC206 _NC207 MUX21X1
X104 S_tem_prod[12] S_tem_prod[11] N159 S_count[0] _NC208 _NC209 MUX21X1
X105 N141 N198 N235 N100 _NC210 _NC211 MUX21X1
X106 N166 N169 N177 N2 _NC212 _NC213 MUX21X1
X107 S_tem_prod[1] S_tem_prod[0] N169 S_count[0] _NC214 _NC215 MUX21X1
X108 S_tem_prod[3] S_tem_prod[2] N166 S_count[0] _NC216 _NC217 MUX21X1
X109 N175 N178 N197 N99 _NC218 _NC219 MUX21X1
X110 N163 N167 N178 N2 _NC220 _NC221 MUX21X1
X111 S_tem_prod[5] S_tem_prod[4] N167 S_count[0] _NC222 _NC223 MUX21X1
X112 S_tem_prod[7] S_tem_prod[6] N163 S_count[0] _NC224 _NC225 MUX21X1
X113 N161 N164 N175 N2 _NC226 _NC227 MUX21X1
X114 S_tem_prod[9] S_tem_prod[8] N164 N97 _NC228 _NC229 MUX21X1
X115 S_tem_prod[11] S_tem_prod[10] N161 N97 _NC230 _NC231 MUX21X1
X116 N192 N194 N231 N100 _NC232 _NC233 MUX21X1
X117 N172 N99 N194 _NC234 _NC235 OR2X1
X118 N149 N158 N172 N2 _NC236 _NC237 MUX21X1
X119 S_tem_prod[2] S_tem_prod[1] N157 N97 _NC238 _NC239 MUX21X1
X120 N171 N173 N192 N99 _NC240 _NC241 MUX21X1
X121 N146 N148 N173 N2 _NC242 _NC243 MUX21X1
X122 S_tem_prod[4] S_tem_prod[3] N156 N97 _NC244 _NC245 MUX21X1
X123 S_tem_prod[6] S_tem_prod[5] N155 N97 _NC246 _NC247 MUX21X1
X124 N142 N144 N171 N2 _NC248 _NC249 MUX21X1
X125 S_tem_prod[8] S_tem_prod[7] N154 N97 _NC250 _NC251 MUX21X1
X126 S_tem_prod[10] S_tem_prod[9] N153 N97 _NC252 _NC253 MUX21X1
X127 N5 N185 N2453 _NC254 _NC255 AND2X1
X128 N160 N99 N220 _NC256 _NC257 OR2X1
X129 N158 N2 N160 _NC258 _NC259 OR2X1
X130 N119 N114 N2451 N102 _NC260 _NC261 MUX21X1
X131 N118 N117 N116 N115 N119 N100 N98 _NC262 _NC263 MUX41X1
X132 S_fractb_i[0] S_fractb_i[4] S_fractb_i[1] S_fractb_i[5] N118 N97 N1 _NC264 _NC265 MUX41X1
X133 S_fractb_i[2] S_fractb_i[6] S_fractb_i[3] S_fractb_i[7] N117 N97 N1 _NC266 _NC267 MUX41X1
X134 S_fractb_i[8] S_fractb_i[12] S_fractb_i[9] S_fractb_i[13] N116 N97 N1 _NC268 _NC269 MUX41X1
X135 S_fractb_i[10] S_fractb_i[14] S_fractb_i[11] S_fractb_i[15] N115 N97 N1 _NC270 _NC271 MUX41X1
X136 N113 N112 N114 N2 _NC272 _NC273 MUX21X1
X137 S_fractb_i[16] S_fractb_i[20] S_fractb_i[17] S_fractb_i[21] N113 N97 N1 _NC274 _NC275 MUX41X1
X138 S_fractb_i[18] S_fractb_i[22] S_fractb_i[19] S_fractb_i[23] N112 N97 N1 _NC276 _NC277 MUX41X1
X139 Add_118_carry[2] N103 N1836 _NC278 _NC279 XOR2X1
X140 N92 _NC280 _NC281 N108 INVX0
X141 N92 _NC282 _NC283 N107 INVX0
X142 N92 _NC284 _NC285 N106 INVX0
X143 N92 _NC286 _NC287 N105 INVX0
X144 N5 _NC288 _NC289 N103 INVX0
X145 N3 _NC290 _NC291 N97 INVX0
X146 S_state _NC292 _NC293 N111 INVX0
X147 S_state _NC294 _NC295 N110 INVX0
X148 S_state _NC296 _NC297 N109 INVX0
X149 N92 N94 N6 _NC298 _NC299 NAND2X1
X150 N96 N27 S_tem_prod[22] _NC300 _NC301 NOR2X0
X151 N96 N26 S_tem_prod[21] _NC302 _NC303 NOR2X0
X152 N96 N28 S_tem_prod[23] _NC304 _NC305 NOR2X0
X153 N96 N25 S_tem_prod[20] _NC306 _NC307 NOR2X0
X154 N95 N23 S_tem_prod[19] _NC308 _NC309 NOR2X0
X155 N95 N22 S_tem_prod[18] _NC310 _NC311 NOR2X0
X156 N95 N21 S_tem_prod[17] _NC312 _NC313 NOR2X0
X157 N95 N20 S_tem_prod[16] _NC314 _NC315 NOR2X0
X158 N95 N19 S_tem_prod[15] _NC316 _NC317 NOR2X0
X159 N95 N18 S_tem_prod[14] _NC318 _NC319 NOR2X0
X160 N95 N17 S_tem_prod[13] _NC320 _NC321 NOR2X0
X161 N95 N16 S_tem_prod[12] _NC322 _NC323 NOR2X0
X162 N95 N15 S_tem_prod[11] _NC324 _NC325 NOR2X0
X163 N95 N14 S_tem_prod[10] _NC326 _NC327 NOR2X0
X164 N96 N34 S_tem_prod[7] _NC328 _NC329 NOR2X0
X165 N96 N36 S_tem_prod[9] _NC330 _NC331 NOR2X0
X166 N96 N35 S_tem_prod[8] _NC332 _NC333 NOR2X0
X167 N96 N33 S_tem_prod[6] _NC334 _NC335 NOR2X0
X168 N96 N32 S_tem_prod[5] _NC336 _NC337 NOR2X0
X169 N96 N31 S_tem_prod[4] _NC338 _NC339 NOR2X0
X170 N96 N30 S_tem_prod[3] _NC340 _NC341 NOR2X0
X171 N11 N264 N265 _NC342 _NC343 NOR2X0
X172 N11 N262 N263 _NC344 _NC345 NOR2X0
X173 N11 N260 N261 _NC346 _NC347 NOR2X0
X174 N11 N257 N259 _NC348 _NC349 NOR2X0
X175 N253 N11 N254 _NC350 _NC351 NOR2X0
X176 N251 N11 N252 _NC352 _NC353 NOR2X0
X177 N255 N101 N256 _NC354 _NC355 NOR2X0
X178 N250 _NC356 _NC357 N136 INVX0
X179 N266 _NC358 _NC359 N120 INVX0
X180 N266 N5 N2492 _NC360 _NC361 NOR2X0
X181 N274 N104 N2499 _NC362 _NC363 NOR2X0
X182 N273 N5 N2498 _NC364 _NC365 NOR2X0
X183 N272 N5 N2497 _NC366 _NC367 NOR2X0
X184 N271 N5 N2496 _NC368 _NC369 NOR2X0
X185 N270 N5 N2495 _NC370 _NC371 NOR2X0
X186 N269 N104 N2494 _NC372 _NC373 NOR2X0
X187 N268 N5 N2493 _NC374 _NC375 NOR2X0
X188 N249 _NC376 _NC377 N2483 INVX0
X189 N244 _NC378 _NC379 N2482 INVX0
X190 N240 _NC380 _NC381 N2481 INVX0
X191 N236 _NC382 _NC383 N2480 INVX0
X192 N232 _NC384 _NC385 N2479 INVX0
X193 N227 _NC386 _NC387 N2478 INVX0
X194 N222 _NC388 _NC389 N2477 INVX0
X195 N103 N250 N2468 _NC390 _NC391 NOR2X0
X196 N103 N248 N2467 _NC392 _NC393 NOR2X0
X197 N103 N243 N2466 _NC394 _NC395 NOR2X0
X198 N103 N239 N2465 _NC396 _NC397 NOR2X0
X199 N103 N235 N2464 _NC398 _NC399 NOR2X0
X200 N103 N231 N2463 _NC400 _NC401 NOR2X0
X201 N103 N281 N2462 _NC402 _NC403 NOR2X0
X202 N103 N280 N2461 _NC404 _NC405 NOR2X0
X203 N96 N29 S_tem_prod[2] _NC406 _NC407 NOR2X0
X204 N95 N24 S_tem_prod[1] _NC408 _NC409 NOR2X0
X205 N95 N13 S_tem_prod[0] _NC410 _NC411 NOR2X0
X206 S_count[4] _NC412 _NC413 N104 INVX0
X207 S_count[3] _NC414 _NC415 N101 INVX0
X208 S_count[3] N3 N10 _NC416 _NC417 NOR2X0
X209 N101 N121 N275 _NC418 _NC419 NOR2X0
X210 N228 N93 N246 _NC420 _NC421 NOR2X0
X211 N210 _NC422 _NC423 N124 INVX0
X212 S_tem_prod[23] S_count[0] N228 _NC424 _NC425 NAND2X1
X213 N200 _NC426 _NC427 N128 INVX0
X214 N190 _NC428 _NC429 N131 INVX0
X215 N180 _NC430 _NC431 N135 INVX0
X216 N170 _NC432 _NC433 N138 INVX0
X217 N159 _NC434 _NC435 N140 INVX0
X218 N153 _NC436 _NC437 N142 INVX0
X219 N154 _NC438 _NC439 N144 INVX0
X220 N155 _NC440 _NC441 N146 INVX0
X221 N4 _NC442 _NC443 N99 INVX0
X222 N156 _NC444 _NC445 N148 INVX0
X223 N177 N4 N198 _NC446 _NC447 NAND2X1
X224 S_tem_prod[0] N3 N158 _NC448 _NC449 NAND2X1
X225 N169 N93 N189 _NC450 _NC451 NAND2X1
X226 N2451 _NC452 _NC453 N150 INVX0
X227 N157 _NC454 _NC455 N149 INVX0
X228 N93 _NC456 _NC457 N98 INVX0
X229 N104 _NC458 _NC459 N102 INVX0
X230 N101 _NC460 _NC461 N100 INVX0
X231 N9 _NC462 _NC463 N151 INVX0
X232 N246 N1 N264 _NC464 _NC465 NAND2X1
X233 N246 _NC466 _NC467 N122 INVX0
X234 N234 _NC468 _NC469 N129 INVX0
X235 N98 N223 N241 _NC470 _NC471 NAND2X1
X236 N1 N233 N257 _NC472 _NC473 NAND2X1
X237 N213 _NC474 _NC475 N123 INVX0
X238 N217 _NC476 _NC477 N121 INVX0
X239 N208 _NC478 _NC479 N125 INVX0
X240 N203 _NC480 _NC481 N127 INVX0
X241 N193 _NC482 _NC483 N130 INVX0
X242 N206 _NC484 _NC485 N126 INVX0
X243 N188 _NC486 _NC487 N132 INVX0
X244 N184 _NC488 _NC489 N134 INVX0
X245 N176 _NC490 _NC491 N137 INVX0
X246 N187 _NC492 _NC493 N133 INVX0
X247 N162 _NC494 _NC495 N139 INVX0
X248 N197 _NC496 _NC497 N141 INVX0
X249 N165 _NC498 _NC499 N143 INVX0
X250 N179 _NC500 _NC501 N145 INVX0
X251 N145 S_count[3] N279 _NC502 _NC503 NOR2X0
X252 N214 S_count[3] N278 _NC504 _NC505 NOR2X0
X253 N168 _NC506 _NC507 N147 INVX0
X254 N209 S_count[3] N277 _NC508 _NC509 NOR2X0
X255 N204 S_count[3] N276 _NC510 _NC511 NOR2X0
X256 N198 S_count[3] N267 _NC512 _NC513 NOR2X0
X257 N194 S_count[3] N245 _NC514 _NC515 NOR2X0
X258 N225 S_count[3] N199 _NC516 _NC517 NOR2X0
X259 N220 S_count[3] N185 _NC518 _NC519 NOR2X0
X260 N150 _NC520 _NC521 N96 NBUFFX2
X261 N150 _NC522 _NC523 N95 NBUFFX2
X262 N100 Add_118_carry[1] Add_118_carry[2] _NC524 _NC525 _NC526 HADDX1
X263 N99 Add_118_carry[0] Add_118_carry[1] _NC527 _NC528 _NC529 HADDX1
X264 N2 N97 Add_118_carry[0] _NC530 _NC531 _NC532 HADDX1
X265 N2453 N2454 N2455 N2456 N2457 N2458 N2459 N2460 N2461 N2462 N2463 N2464 N2465 N2466 N2467 N2468 N2469 N2470 N2471 N2472 N2473 N2474 N2475 N2476 N2477 N2478 N2479 N2480 N2481 N2482 N2483 N2484 N2485 N2486 N2487 N2488 N2489 N2490 N2491 N2492 N2493 N2494 N2495 N2496 N2497 N2498 N2499 N2500 N2564 N2565 N2566 N2567 N2568 N2569 N2570 N2571 N2572 N2573 N2574 N2575 N2576 N2577 N2578 N2579 N2580 N2581 N2582 N2583 N2584 N2585 N2586 N2587 N2588 N2589 N2590 N2591 N2592 N2593 N2594 N2595 N2596 N2597 N2598 N2599 N2600 N2601 N2602 N2603 N2604 N2605 N2606 N2607 N2608 N2609 N2610 N2611 Vss N2503 N2504 N2505 N2506 N2507 N2508 N2509 N2510 N2511 N2512 N2513 N2514 N2515 N2516 N2517 N2518 N2519 N2520 N2521 N2522 N2523 N2524 N2525 N2526 N2527 N2528 N2529 N2530 N2531 N2532 N2533 N2534 N2535 N2536 N2537 N2538 N2539 N2540 N2541 N2542 N2543 N2544 N2545 N2546 N2547 N2548 N2549 N2550 _NC533 serial_mul_DW01_add_0
X266 S_fract_o[0] S_fract_o[1] S_fract_o[2] S_fract_o[3] S_fract_o[4] S_fract_o[5] S_fract_o[6] S_fract_o[7] S_fract_o[8] S_fract_o[9] S_fract_o[10] S_fract_o[11] S_fract_o[12] S_fract_o[13] S_fract_o[14] S_fract_o[15] S_fract_o[16] S_fract_o[17] S_fract_o[18] S_fract_o[19] S_fract_o[20] S_fract_o[21] S_fract_o[22] S_fract_o[23] S_fract_o[24] S_fract_o[25] S_fract_o[26] S_fract_o[27] S_fract_o[28] S_fract_o[29] S_fract_o[30] S_fract_o[31] S_fract_o[32] S_fract_o[33] S_fract_o[34] S_fract_o[35] S_fract_o[36] S_fract_o[37] S_fract_o[38] S_fract_o[39] S_fract_o[40] S_fract_o[41] S_fract_o[42] S_fract_o[43] S_fract_o[44] S_fract_o[45] S_fract_o[46] S_fract_o[47] N2554 N2564 N2565 N2566 N2567 N2568 N2569 N2570 N2571 N2572 N2573 N2574 N2575 N2576 N2577 N2578 N2579 N2580 N2581 N2582 N2583 N2584 N2585 N2586 N2587 N2588 N2589 N2590 N2591 N2592 N2593 N2594 N2595 N2596 N2597 N2598 N2599 N2600 N2601 N2602 N2603 N2604 N2605 N2606 N2607 N2608 N2609 N2610 N2611 SYNOPSYS_UNCONNECTED__0 serial_mul_DW_mult_uns_0
X267 N103 N100 N12 _NC534 _NC535 OR2X1
X268 N97 N2 N12 N99 N2554 _NC536 _NC537 OR4X1
X269 N103 N99 N10 N2 N9 _NC538 _NC539 NAND4X0
X270 N94 N92 N9 N7 _NC540 _NC541 AND3X1
X271 N7 S_start_i N151 N8 _NC542 _NC543 NOR3X0
X272 N7 N97 N3 N8 N91 _NC544 _NC545 AO22X1
X273 N108 N9 S_start_i N90 _NC546 _NC547 AO21X1
X274 N7 N2 N1833 N8 N89 _NC548 _NC549 AO22X1
X275 N7 N99 N1834 N8 N88 _NC550 _NC551 AO22X1
X276 S_count[3] N7 N1835 N8 N87 _NC552 _NC553 AO22X1
X277 N7 N103 N1836 N8 N86 _NC554 _NC555 AO22X1
X278 N151 N94 S_ready_o N6 N85 _NC556 _NC557 AO22X1
X279 S_fract_o[47] N109 N2550 N105 N84 _NC558 _NC559 AO22X1
X280 S_fract_o[46] N110 N2549 N105 N83 _NC560 _NC561 AO22X1
X281 S_fract_o[45] N109 N2548 N105 N82 _NC562 _NC563 AO22X1
X282 S_fract_o[44] N110 N2547 N105 N81 _NC564 _NC565 AO22X1
X283 S_fract_o[43] N111 N2546 N105 N80 _NC566 _NC567 AO22X1
X284 S_fract_o[42] N109 N2545 N105 N79 _NC568 _NC569 AO22X1
X285 S_fract_o[41] N110 N2544 N105 N78 _NC570 _NC571 AO22X1
X286 S_fract_o[40] N111 N2543 N105 N77 _NC572 _NC573 AO22X1
X287 S_fract_o[39] N109 N2542 N105 N76 _NC574 _NC575 AO22X1
X288 S_fract_o[38] N110 N2541 N105 N75 _NC576 _NC577 AO22X1
X289 S_fract_o[37] N111 N2540 N105 N74 _NC578 _NC579 AO22X1
X290 S_fract_o[36] N111 N2539 N106 N73 _NC580 _NC581 AO22X1
X291 S_fract_o[35] N111 N2538 N105 N72 _NC582 _NC583 AO22X1
X292 S_fract_o[34] N111 N2537 N106 N71 _NC584 _NC585 AO22X1
X293 S_fract_o[33] N111 N2536 N106 N70 _NC586 _NC587 AO22X1
X294 S_fract_o[32] N111 N2535 N106 N69 _NC588 _NC589 AO22X1
X295 S_fract_o[31] N111 N2534 N106 N68 _NC590 _NC591 AO22X1
X296 S_fract_o[30] N111 N2533 N106 N67 _NC592 _NC593 AO22X1
X297 S_fract_o[29] N111 N2532 N106 N66 _NC594 _NC595 AO22X1
X298 S_fract_o[28] N111 N2531 N106 N65 _NC596 _NC597 AO22X1
X299 S_fract_o[27] N109 N2530 N106 N64 _NC598 _NC599 AO22X1
X300 S_fract_o[26] N110 N2529 N106 N63 _NC600 _NC601 AO22X1
X301 S_fract_o[25] N111 N2528 N106 N62 _NC602 _NC603 AO22X1
X302 S_fract_o[24] N110 N2527 N106 N61 _NC604 _NC605 AO22X1
X303 S_fract_o[23] N111 N2526 N107 N60 _NC606 _NC607 AO22X1
X304 S_fract_o[22] N109 N2525 N107 N59 _NC608 _NC609 AO22X1
X305 S_fract_o[21] N110 N2524 N107 N58 _NC610 _NC611 AO22X1
X306 S_fract_o[20] N111 N2523 N107 N57 _NC612 _NC613 AO22X1
X307 S_fract_o[19] N110 N2522 N107 N56 _NC614 _NC615 AO22X1
X308 S_fract_o[18] N110 N2521 N107 N55 _NC616 _NC617 AO22X1
X309 S_fract_o[17] N110 N2520 N107 N54 _NC618 _NC619 AO22X1
X310 S_fract_o[16] N110 N2519 N107 N53 _NC620 _NC621 AO22X1
X311 S_fract_o[15] N110 N2518 N107 N52 _NC622 _NC623 AO22X1
X312 S_fract_o[14] N110 N2517 N107 N51 _NC624 _NC625 AO22X1
X313 S_fract_o[13] N110 N2516 N107 N50 _NC626 _NC627 AO22X1
X314 S_fract_o[12] N110 N2515 N107 N49 _NC628 _NC629 AO22X1
X315 S_fract_o[11] N110 N2514 N108 N48 _NC630 _NC631 AO22X1
X316 S_fract_o[10] N109 N2513 N108 N47 _NC632 _NC633 AO22X1
X317 S_fract_o[9] N109 N2512 N108 N46 _NC634 _NC635 AO22X1
X318 S_fract_o[8] N109 N2511 N108 N45 _NC636 _NC637 AO22X1
X319 S_fract_o[7] N109 N2510 N108 N44 _NC638 _NC639 AO22X1
X320 S_fract_o[6] N109 N2509 N108 N43 _NC640 _NC641 AO22X1
X321 S_fract_o[5] N109 N2508 N108 N42 _NC642 _NC643 AO22X1
X322 S_fract_o[4] N109 N2507 N108 N41 _NC644 _NC645 AO22X1
X323 S_fract_o[3] N109 N2506 N108 N40 _NC646 _NC647 AO22X1
X324 S_fract_o[2] N109 N2505 N108 N39 _NC648 _NC649 AO22X1
X325 S_fract_o[1] N111 N2504 N108 N38 _NC650 _NC651 AO22X1
X326 S_fract_o[0] N109 N106 N2503 N37 _NC652 _NC653 AO22X1
X327 Signb_i Signa_i S_sign_o _NC654 _NC655 XOR2X1
X328 Clk_i S_fract_o[0] Fract_o[0] _NC656 _NC657 _NC658 DFFX1
X329 Clk_i N37 S_fract_o[0] _NC659 _NC660 _NC661 DFFX1
X330 Clk_i S_fract_o[1] Fract_o[1] _NC662 _NC663 _NC664 DFFX1
X331 Clk_i N38 S_fract_o[1] _NC665 _NC666 _NC667 DFFX1
X332 Clk_i S_fract_o[2] Fract_o[2] _NC668 _NC669 _NC670 DFFX1
X333 Clk_i N39 S_fract_o[2] _NC671 _NC672 _NC673 DFFX1
X334 Clk_i S_fract_o[3] Fract_o[3] _NC674 _NC675 _NC676 DFFX1
X335 Clk_i N40 S_fract_o[3] _NC677 _NC678 _NC679 DFFX1
X336 Clk_i S_fract_o[4] Fract_o[4] _NC680 _NC681 _NC682 DFFX1
X337 Clk_i N41 S_fract_o[4] _NC683 _NC684 _NC685 DFFX1
X338 Clk_i S_fract_o[5] Fract_o[5] _NC686 _NC687 _NC688 DFFX1
X339 Clk_i N42 S_fract_o[5] _NC689 _NC690 _NC691 DFFX1
X340 Clk_i S_fract_o[6] Fract_o[6] _NC692 _NC693 _NC694 DFFX1
X341 Clk_i N43 S_fract_o[6] _NC695 _NC696 _NC697 DFFX1
X342 Clk_i S_fract_o[7] Fract_o[7] _NC698 _NC699 _NC700 DFFX1
X343 Clk_i N44 S_fract_o[7] _NC701 _NC702 _NC703 DFFX1
X344 Clk_i S_fract_o[8] Fract_o[8] _NC704 _NC705 _NC706 DFFX1
X345 Clk_i N45 S_fract_o[8] _NC707 _NC708 _NC709 DFFX1
X346 Clk_i S_fract_o[9] Fract_o[9] _NC710 _NC711 _NC712 DFFX1
X347 Clk_i N46 S_fract_o[9] _NC713 _NC714 _NC715 DFFX1
X348 Clk_i S_fract_o[10] Fract_o[10] _NC716 _NC717 _NC718 DFFX1
X349 Clk_i N47 S_fract_o[10] _NC719 _NC720 _NC721 DFFX1
X350 Clk_i S_fract_o[11] Fract_o[11] _NC722 _NC723 _NC724 DFFX1
X351 Clk_i N48 S_fract_o[11] _NC725 _NC726 _NC727 DFFX1
X352 Clk_i S_fract_o[12] Fract_o[12] _NC728 _NC729 _NC730 DFFX1
X353 Clk_i N49 S_fract_o[12] _NC731 _NC732 _NC733 DFFX1
X354 Clk_i S_fract_o[13] Fract_o[13] _NC734 _NC735 _NC736 DFFX1
X355 Clk_i N50 S_fract_o[13] _NC737 _NC738 _NC739 DFFX1
X356 Clk_i S_fract_o[14] Fract_o[14] _NC740 _NC741 _NC742 DFFX1
X357 Clk_i N51 S_fract_o[14] _NC743 _NC744 _NC745 DFFX1
X358 Clk_i S_fract_o[15] Fract_o[15] _NC746 _NC747 _NC748 DFFX1
X359 Clk_i N52 S_fract_o[15] _NC749 _NC750 _NC751 DFFX1
X360 Clk_i S_fract_o[16] Fract_o[16] _NC752 _NC753 _NC754 DFFX1
X361 Clk_i N53 S_fract_o[16] _NC755 _NC756 _NC757 DFFX1
X362 Clk_i S_fract_o[17] Fract_o[17] _NC758 _NC759 _NC760 DFFX1
X363 Clk_i N54 S_fract_o[17] _NC761 _NC762 _NC763 DFFX1
X364 Clk_i S_fract_o[18] Fract_o[18] _NC764 _NC765 _NC766 DFFX1
X365 Clk_i N55 S_fract_o[18] _NC767 _NC768 _NC769 DFFX1
X366 Clk_i S_fract_o[19] Fract_o[19] _NC770 _NC771 _NC772 DFFX1
X367 Clk_i N56 S_fract_o[19] _NC773 _NC774 _NC775 DFFX1
X368 Clk_i S_fract_o[20] Fract_o[20] _NC776 _NC777 _NC778 DFFX1
X369 Clk_i N57 S_fract_o[20] _NC779 _NC780 _NC781 DFFX1
X370 Clk_i S_fract_o[21] Fract_o[21] _NC782 _NC783 _NC784 DFFX1
X371 Clk_i N58 S_fract_o[21] _NC785 _NC786 _NC787 DFFX1
X372 Clk_i S_fract_o[22] Fract_o[22] _NC788 _NC789 _NC790 DFFX1
X373 Clk_i N59 S_fract_o[22] _NC791 _NC792 _NC793 DFFX1
X374 Clk_i S_fract_o[23] Fract_o[23] _NC794 _NC795 _NC796 DFFX1
X375 Clk_i N60 S_fract_o[23] _NC797 _NC798 _NC799 DFFX1
X376 Clk_i S_fract_o[24] Fract_o[24] _NC800 _NC801 _NC802 DFFX1
X377 Clk_i N61 S_fract_o[24] _NC803 _NC804 _NC805 DFFX1
X378 Clk_i S_fract_o[25] Fract_o[25] _NC806 _NC807 _NC808 DFFX1
X379 Clk_i N62 S_fract_o[25] _NC809 _NC810 _NC811 DFFX1
X380 Clk_i S_fract_o[26] Fract_o[26] _NC812 _NC813 _NC814 DFFX1
X381 Clk_i N63 S_fract_o[26] _NC815 _NC816 _NC817 DFFX1
X382 Clk_i S_fract_o[27] Fract_o[27] _NC818 _NC819 _NC820 DFFX1
X383 Clk_i N64 S_fract_o[27] _NC821 _NC822 _NC823 DFFX1
X384 Clk_i S_fract_o[28] Fract_o[28] _NC824 _NC825 _NC826 DFFX1
X385 Clk_i N65 S_fract_o[28] _NC827 _NC828 _NC829 DFFX1
X386 Clk_i S_fract_o[29] Fract_o[29] _NC830 _NC831 _NC832 DFFX1
X387 Clk_i N66 S_fract_o[29] _NC833 _NC834 _NC835 DFFX1
X388 Clk_i S_fract_o[30] Fract_o[30] _NC836 _NC837 _NC838 DFFX1
X389 Clk_i N67 S_fract_o[30] _NC839 _NC840 _NC841 DFFX1
X390 Clk_i S_fract_o[31] Fract_o[31] _NC842 _NC843 _NC844 DFFX1
X391 Clk_i N68 S_fract_o[31] _NC845 _NC846 _NC847 DFFX1
X392 Clk_i S_fract_o[32] Fract_o[32] _NC848 _NC849 _NC850 DFFX1
X393 Clk_i N69 S_fract_o[32] _NC851 _NC852 _NC853 DFFX1
X394 Clk_i S_fract_o[33] Fract_o[33] _NC854 _NC855 _NC856 DFFX1
X395 Clk_i N70 S_fract_o[33] _NC857 _NC858 _NC859 DFFX1
X396 Clk_i S_fract_o[34] Fract_o[34] _NC860 _NC861 _NC862 DFFX1
X397 Clk_i N71 S_fract_o[34] _NC863 _NC864 _NC865 DFFX1
X398 Clk_i S_fract_o[35] Fract_o[35] _NC866 _NC867 _NC868 DFFX1
X399 Clk_i N72 S_fract_o[35] _NC869 _NC870 _NC871 DFFX1
X400 Clk_i S_fract_o[36] Fract_o[36] _NC872 _NC873 _NC874 DFFX1
X401 Clk_i N73 S_fract_o[36] _NC875 _NC876 _NC877 DFFX1
X402 Clk_i S_fract_o[37] Fract_o[37] _NC878 _NC879 _NC880 DFFX1
X403 Clk_i N74 S_fract_o[37] _NC881 _NC882 _NC883 DFFX1
X404 Clk_i S_fract_o[38] Fract_o[38] _NC884 _NC885 _NC886 DFFX1
X405 Clk_i N75 S_fract_o[38] _NC887 _NC888 _NC889 DFFX1
X406 Clk_i S_fract_o[39] Fract_o[39] _NC890 _NC891 _NC892 DFFX1
X407 Clk_i N76 S_fract_o[39] _NC893 _NC894 _NC895 DFFX1
X408 Clk_i S_fract_o[40] Fract_o[40] _NC896 _NC897 _NC898 DFFX1
X409 Clk_i N77 S_fract_o[40] _NC899 _NC900 _NC901 DFFX1
X410 Clk_i S_fract_o[41] Fract_o[41] _NC902 _NC903 _NC904 DFFX1
X411 Clk_i N78 S_fract_o[41] _NC905 _NC906 _NC907 DFFX1
X412 Clk_i S_fract_o[42] Fract_o[42] _NC908 _NC909 _NC910 DFFX1
X413 Clk_i N79 S_fract_o[42] _NC911 _NC912 _NC913 DFFX1
X414 Clk_i S_fract_o[43] Fract_o[43] _NC914 _NC915 _NC916 DFFX1
X415 Clk_i N80 S_fract_o[43] _NC917 _NC918 _NC919 DFFX1
X416 Clk_i S_fract_o[44] Fract_o[44] _NC920 _NC921 _NC922 DFFX1
X417 Clk_i N81 S_fract_o[44] _NC923 _NC924 _NC925 DFFX1
X418 Clk_i S_fract_o[45] Fract_o[45] _NC926 _NC927 _NC928 DFFX1
X419 Clk_i N82 S_fract_o[45] _NC929 _NC930 _NC931 DFFX1
X420 Clk_i S_fract_o[46] Fract_o[46] _NC932 _NC933 _NC934 DFFX1
X421 Clk_i N83 S_fract_o[46] _NC935 _NC936 _NC937 DFFX1
X422 Clk_i S_fract_o[47] Fract_o[47] _NC938 _NC939 _NC940 DFFX1
X423 Clk_i N84 S_fract_o[47] _NC941 _NC942 _NC943 DFFX1
X424 Clk_i N86 S_count[4] N5 _NC944 _NC945 DFFX1
X425 Clk_i N87 S_count[3] N11 _NC946 _NC947 DFFX1
X426 Clk_i N88 N1 N4 _NC948 _NC949 DFFX1
X427 Clk_i N89 N2 N93 _NC950 _NC951 DFFX1
X428 Clk_i S_ready_o Ready_o _NC952 _NC953 _NC954 DFFX1
X429 Clk_i N85 S_ready_o _NC955 _NC956 _NC957 DFFX1
X430 Clk_i N90 S_state N92 _NC958 _NC959 DFFX1
X431 Clk_i N91 S_count[0] N3 _NC960 _NC961 DFFX1
X432 Clk_i S_sign_o Sign_o _NC962 _NC963 _NC964 DFFX1
X433 Clk_i Start_i S_start_i N94 _NC965 _NC966 DFFX1
X434 Clk_i Fractb_i[0] S_fractb_i[0] _NC967 _NC968 _NC969 DFFX1
X435 Clk_i Fractb_i[1] S_fractb_i[1] _NC970 _NC971 _NC972 DFFX1
X436 Clk_i Fractb_i[2] S_fractb_i[2] _NC973 _NC974 _NC975 DFFX1
X437 Clk_i Fractb_i[3] S_fractb_i[3] _NC976 _NC977 _NC978 DFFX1
X438 Clk_i Fractb_i[4] S_fractb_i[4] _NC979 _NC980 _NC981 DFFX1
X439 Clk_i Fractb_i[5] S_fractb_i[5] _NC982 _NC983 _NC984 DFFX1
X440 Clk_i Fractb_i[6] S_fractb_i[6] _NC985 _NC986 _NC987 DFFX1
X441 Clk_i Fractb_i[7] S_fractb_i[7] _NC988 _NC989 _NC990 DFFX1
X442 Clk_i Fractb_i[8] S_fractb_i[8] _NC991 _NC992 _NC993 DFFX1
X443 Clk_i Fractb_i[9] S_fractb_i[9] _NC994 _NC995 _NC996 DFFX1
X444 Clk_i Fractb_i[10] S_fractb_i[10] _NC997 _NC998 _NC999 DFFX1
X445 Clk_i Fractb_i[11] S_fractb_i[11] _NC1000 _NC1001 _NC1002 DFFX1
X446 Clk_i Fractb_i[12] S_fractb_i[12] _NC1003 _NC1004 _NC1005 DFFX1
X447 Clk_i Fractb_i[13] S_fractb_i[13] _NC1006 _NC1007 _NC1008 DFFX1
X448 Clk_i Fractb_i[14] S_fractb_i[14] _NC1009 _NC1010 _NC1011 DFFX1
X449 Clk_i Fractb_i[15] S_fractb_i[15] _NC1012 _NC1013 _NC1014 DFFX1
X450 Clk_i Fractb_i[16] S_fractb_i[16] _NC1015 _NC1016 _NC1017 DFFX1
X451 Clk_i Fractb_i[17] S_fractb_i[17] _NC1018 _NC1019 _NC1020 DFFX1
X452 Clk_i Fractb_i[18] S_fractb_i[18] _NC1021 _NC1022 _NC1023 DFFX1
X453 Clk_i Fractb_i[19] S_fractb_i[19] _NC1024 _NC1025 _NC1026 DFFX1
X454 Clk_i Fractb_i[20] S_fractb_i[20] _NC1027 _NC1028 _NC1029 DFFX1
X455 Clk_i Fractb_i[21] S_fractb_i[21] _NC1030 _NC1031 _NC1032 DFFX1
X456 Clk_i Fractb_i[22] S_fractb_i[22] _NC1033 _NC1034 _NC1035 DFFX1
X457 Clk_i Fractb_i[23] S_fractb_i[23] _NC1036 _NC1037 _NC1038 DFFX1
X458 Clk_i Fracta_i[0] _NC1039 N13 _NC1040 _NC1041 DFFX1
X459 Clk_i Fracta_i[1] _NC1042 N24 _NC1043 _NC1044 DFFX1
X460 Clk_i Fracta_i[2] _NC1045 N29 _NC1046 _NC1047 DFFX1
X461 Clk_i Fracta_i[3] _NC1048 N30 _NC1049 _NC1050 DFFX1
X462 Clk_i Fracta_i[4] _NC1051 N31 _NC1052 _NC1053 DFFX1
X463 Clk_i Fracta_i[5] _NC1054 N32 _NC1055 _NC1056 DFFX1
X464 Clk_i Fracta_i[6] _NC1057 N33 _NC1058 _NC1059 DFFX1
X465 Clk_i Fracta_i[7] _NC1060 N34 _NC1061 _NC1062 DFFX1
X466 Clk_i Fracta_i[8] _NC1063 N35 _NC1064 _NC1065 DFFX1
X467 Clk_i Fracta_i[9] _NC1066 N36 _NC1067 _NC1068 DFFX1
X468 Clk_i Fracta_i[10] _NC1069 N14 _NC1070 _NC1071 DFFX1
X469 Clk_i Fracta_i[11] _NC1072 N15 _NC1073 _NC1074 DFFX1
X470 Clk_i Fracta_i[12] _NC1075 N16 _NC1076 _NC1077 DFFX1
X471 Clk_i Fracta_i[13] _NC1078 N17 _NC1079 _NC1080 DFFX1
X472 Clk_i Fracta_i[14] _NC1081 N18 _NC1082 _NC1083 DFFX1
X473 Clk_i Fracta_i[15] _NC1084 N19 _NC1085 _NC1086 DFFX1
X474 Clk_i Fracta_i[16] _NC1087 N20 _NC1088 _NC1089 DFFX1
X475 Clk_i Fracta_i[17] _NC1090 N21 _NC1091 _NC1092 DFFX1
X476 Clk_i Fracta_i[18] _NC1093 N22 _NC1094 _NC1095 DFFX1
X477 Clk_i Fracta_i[19] _NC1096 N23 _NC1097 _NC1098 DFFX1
X478 Clk_i Fracta_i[20] _NC1099 N25 _NC1100 _NC1101 DFFX1
X479 Clk_i Fracta_i[21] _NC1102 N26 _NC1103 _NC1104 DFFX1
X480 Clk_i Fracta_i[22] _NC1105 N27 _NC1106 _NC1107 DFFX1
X481 Clk_i Fracta_i[23] _NC1108 N28 _NC1109 _NC1110 DFFX1
.ENDS serial_mul

.SUBCKT serial_mul_DW01_add_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] SUM[28] SUM[29] SUM[30] SUM[31] SUM[32] SUM[33] SUM[34] SUM[35] SUM[36] SUM[37] SUM[38] SUM[39] SUM[40] SUM[41] SUM[42] SUM[43] SUM[44] SUM[45] SUM[46] SUM[47] CO
X0 A[0] B[0] SUM[0] _NC0 _NC1 XOR2X1
X1 A[0] B[0] N1 _NC2 _NC3 AND2X1
X2 A[47] B[47] Carry[45] SUM[47] _NC4 _NC5 XOR3X1
X3 A[1] B[1] N1 Carry[0] SUM[1] _NC6 _NC7 FADDX1
X4 A[2] B[2] Carry[0] Carry[1] SUM[2] _NC8 _NC9 FADDX1
X5 A[3] B[3] Carry[1] Carry[2] SUM[3] _NC10 _NC11 FADDX1
X6 A[4] B[4] Carry[2] Carry[3] SUM[4] _NC12 _NC13 FADDX1
X7 A[5] B[5] Carry[3] Carry[4] SUM[5] _NC14 _NC15 FADDX1
X8 A[6] B[6] Carry[4] Carry[5] SUM[6] _NC16 _NC17 FADDX1
X9 A[7] B[7] Carry[5] Carry[6] SUM[7] _NC18 _NC19 FADDX1
X10 A[8] B[8] Carry[6] Carry[7] SUM[8] _NC20 _NC21 FADDX1
X11 A[9] B[9] Carry[7] Carry[8] SUM[9] _NC22 _NC23 FADDX1
X12 A[10] B[10] Carry[8] Carry[9] SUM[10] _NC24 _NC25 FADDX1
X13 A[11] B[11] Carry[9] Carry[10] SUM[11] _NC26 _NC27 FADDX1
X14 A[12] B[12] Carry[10] Carry[11] SUM[12] _NC28 _NC29 FADDX1
X15 A[13] B[13] Carry[11] Carry[12] SUM[13] _NC30 _NC31 FADDX1
X16 A[14] B[14] Carry[12] Carry[13] SUM[14] _NC32 _NC33 FADDX1
X17 A[15] B[15] Carry[13] Carry[14] SUM[15] _NC34 _NC35 FADDX1
X18 A[16] B[16] Carry[14] Carry[15] SUM[16] _NC36 _NC37 FADDX1
X19 A[17] B[17] Carry[15] Carry[16] SUM[17] _NC38 _NC39 FADDX1
X20 A[18] B[18] Carry[16] Carry[17] SUM[18] _NC40 _NC41 FADDX1
X21 A[19] B[19] Carry[17] Carry[18] SUM[19] _NC42 _NC43 FADDX1
X22 A[20] B[20] Carry[18] Carry[19] SUM[20] _NC44 _NC45 FADDX1
X23 A[21] B[21] Carry[19] Carry[20] SUM[21] _NC46 _NC47 FADDX1
X24 A[22] B[22] Carry[20] Carry[21] SUM[22] _NC48 _NC49 FADDX1
X25 A[23] B[23] Carry[21] Carry[22] SUM[23] _NC50 _NC51 FADDX1
X26 A[24] B[24] Carry[22] Carry[23] SUM[24] _NC52 _NC53 FADDX1
X27 A[25] B[25] Carry[23] Carry[24] SUM[25] _NC54 _NC55 FADDX1
X28 A[26] B[26] Carry[24] Carry[25] SUM[26] _NC56 _NC57 FADDX1
X29 A[27] B[27] Carry[25] Carry[26] SUM[27] _NC58 _NC59 FADDX1
X30 A[28] B[28] Carry[26] Carry[27] SUM[28] _NC60 _NC61 FADDX1
X31 A[29] B[29] Carry[27] Carry[28] SUM[29] _NC62 _NC63 FADDX1
X32 A[30] B[30] Carry[28] Carry[29] SUM[30] _NC64 _NC65 FADDX1
X33 A[31] B[31] Carry[29] Carry[30] SUM[31] _NC66 _NC67 FADDX1
X34 A[32] B[32] Carry[30] Carry[31] SUM[32] _NC68 _NC69 FADDX1
X35 A[33] B[33] Carry[31] Carry[32] SUM[33] _NC70 _NC71 FADDX1
X36 A[34] B[34] Carry[32] Carry[33] SUM[34] _NC72 _NC73 FADDX1
X37 A[35] B[35] Carry[33] Carry[34] SUM[35] _NC74 _NC75 FADDX1
X38 A[36] B[36] Carry[34] Carry[35] SUM[36] _NC76 _NC77 FADDX1
X39 A[37] B[37] Carry[35] Carry[36] SUM[37] _NC78 _NC79 FADDX1
X40 A[38] B[38] Carry[36] Carry[37] SUM[38] _NC80 _NC81 FADDX1
X41 A[39] B[39] Carry[37] Carry[38] SUM[39] _NC82 _NC83 FADDX1
X42 A[40] B[40] Carry[38] Carry[39] SUM[40] _NC84 _NC85 FADDX1
X43 A[41] B[41] Carry[39] Carry[40] SUM[41] _NC86 _NC87 FADDX1
X44 A[42] B[42] Carry[40] Carry[41] SUM[42] _NC88 _NC89 FADDX1
X45 A[43] B[43] Carry[41] Carry[42] SUM[43] _NC90 _NC91 FADDX1
X46 A[44] B[44] Carry[42] Carry[43] SUM[44] _NC92 _NC93 FADDX1
X47 A[45] B[45] Carry[43] Carry[44] SUM[45] _NC94 _NC95 FADDX1
X48 A[46] B[46] Carry[44] Carry[45] SUM[46] _NC96 _NC97 FADDX1
.ENDS serial_mul_DW01_add_0

.SUBCKT serial_mul_DW_mult_uns_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] B Product[0] Product[1] Product[2] Product[3] Product[4] Product[5] Product[6] Product[7] Product[8] Product[9] Product[10] Product[11] Product[12] Product[13] Product[14] Product[15] Product[16] Product[17] Product[18] Product[19] Product[20] Product[21] Product[22] Product[23] Product[24] Product[25] Product[26] Product[27] Product[28] Product[29] Product[30] Product[31] Product[32] Product[33] Product[34] Product[35] Product[36] Product[37] Product[38] Product[39] Product[40] Product[41] Product[42] Product[43] Product[44] Product[45] Product[46] Product[47] Product[48]
X0 A[0] N154 Product[0] _NC0 _NC1 AND2X1
X1 A[10] N154 Product[10] _NC2 _NC3 AND2X1
X2 A[11] N154 Product[11] _NC4 _NC5 AND2X1
X3 A[12] N154 Product[12] _NC6 _NC7 AND2X1
X4 A[13] N154 Product[13] _NC8 _NC9 AND2X1
X5 A[14] N154 Product[14] _NC10 _NC11 AND2X1
X6 A[15] N154 Product[15] _NC12 _NC13 AND2X1
X7 A[16] N154 Product[16] _NC14 _NC15 AND2X1
X8 A[17] N154 Product[17] _NC16 _NC17 AND2X1
X9 A[18] N154 Product[18] _NC18 _NC19 AND2X1
X10 A[19] N154 Product[19] _NC20 _NC21 AND2X1
X11 A[1] N154 Product[1] _NC22 _NC23 AND2X1
X12 A[20] N155 Product[20] _NC24 _NC25 AND2X1
X13 A[21] N155 Product[21] _NC26 _NC27 AND2X1
X14 A[22] N155 Product[22] _NC28 _NC29 AND2X1
X15 A[23] N155 Product[23] _NC30 _NC31 AND2X1
X16 A[24] N155 Product[24] _NC32 _NC33 AND2X1
X17 A[25] N155 Product[25] _NC34 _NC35 AND2X1
X18 A[26] N155 Product[26] _NC36 _NC37 AND2X1
X19 A[27] N155 Product[27] _NC38 _NC39 AND2X1
X20 A[28] N155 Product[28] _NC40 _NC41 AND2X1
X21 A[29] N155 Product[29] _NC42 _NC43 AND2X1
X22 A[2] N155 Product[2] _NC44 _NC45 AND2X1
X23 A[30] N155 Product[30] _NC46 _NC47 AND2X1
X24 A[31] N156 Product[31] _NC48 _NC49 AND2X1
X25 A[32] N156 Product[32] _NC50 _NC51 AND2X1
X26 A[33] N156 Product[33] _NC52 _NC53 AND2X1
X27 A[34] N156 Product[34] _NC54 _NC55 AND2X1
X28 A[35] N156 Product[35] _NC56 _NC57 AND2X1
X29 A[36] N156 Product[36] _NC58 _NC59 AND2X1
X30 A[37] N156 Product[37] _NC60 _NC61 AND2X1
X31 A[38] N156 Product[38] _NC62 _NC63 AND2X1
X32 A[39] N156 Product[39] _NC64 _NC65 AND2X1
X33 A[3] N156 Product[3] _NC66 _NC67 AND2X1
X34 A[40] N156 Product[40] _NC68 _NC69 AND2X1
X35 A[41] N156 Product[41] _NC70 _NC71 AND2X1
X36 A[42] N157 Product[42] _NC72 _NC73 AND2X1
X37 A[43] N157 Product[43] _NC74 _NC75 AND2X1
X38 A[44] N157 Product[44] _NC76 _NC77 AND2X1
X39 A[45] N157 Product[45] _NC78 _NC79 AND2X1
X40 A[46] N157 Product[46] _NC80 _NC81 AND2X1
X41 A[47] N157 Product[47] _NC82 _NC83 AND2X1
X42 A[4] N157 Product[4] _NC84 _NC85 AND2X1
X43 A[5] N157 Product[5] _NC86 _NC87 AND2X1
X44 A[6] N157 Product[6] _NC88 _NC89 AND2X1
X45 A[7] N157 Product[7] _NC90 _NC91 AND2X1
X46 A[8] N157 Product[8] _NC92 _NC93 AND2X1
X47 N157 A[9] Product[9] _NC94 _NC95 AND2X1
X48 B _NC96 _NC97 N157 NBUFFX2
X49 B _NC98 _NC99 N156 NBUFFX2
X50 B _NC100 _NC101 N155 NBUFFX2
X51 B _NC102 _NC103 N154 NBUFFX2
.ENDS serial_mul_DW_mult_uns_0

.SUBCKT mul_24 Clk_i Fracta_i[0] Fracta_i[1] Fracta_i[2] Fracta_i[3] Fracta_i[4] Fracta_i[5] Fracta_i[6] Fracta_i[7] Fracta_i[8] Fracta_i[9] Fracta_i[10] Fracta_i[11] Fracta_i[12] Fracta_i[13] Fracta_i[14] Fracta_i[15] Fracta_i[16] Fracta_i[17] Fracta_i[18] Fracta_i[19] Fracta_i[20] Fracta_i[21] Fracta_i[22] Fracta_i[23] Fractb_i[0] Fractb_i[1] Fractb_i[2] Fractb_i[3] Fractb_i[4] Fractb_i[5] Fractb_i[6] Fractb_i[7] Fractb_i[8] Fractb_i[9] Fractb_i[10] Fractb_i[11] Fractb_i[12] Fractb_i[13] Fractb_i[14] Fractb_i[15] Fractb_i[16] Fractb_i[17] Fractb_i[18] Fractb_i[19] Fractb_i[20] Fractb_i[21] Fractb_i[22] Fractb_i[23] Signa_i Signb_i Start_i Fract_o[0] Fract_o[1] Fract_o[2] Fract_o[3] Fract_o[4] Fract_o[5] Fract_o[6] Fract_o[7] Fract_o[8] Fract_o[9] Fract_o[10] Fract_o[11] Fract_o[12] Fract_o[13] Fract_o[14] Fract_o[15] Fract_o[16] Fract_o[17] Fract_o[18] Fract_o[19] Fract_o[20] Fract_o[21] Fract_o[22] Fract_o[23] Fract_o[24] Fract_o[25] Fract_o[26] Fract_o[27] Fract_o[28] Fract_o[29] Fract_o[30] Fract_o[31] Fract_o[32] Fract_o[33] Fract_o[34] Fract_o[35] Fract_o[36] Fract_o[37] Fract_o[38] Fract_o[39] Fract_o[40] Fract_o[41] Fract_o[42] Fract_o[43] Fract_o[44] Fract_o[45] Fract_o[46] Fract_o[47] Sign_o Ready_o
X0 Prod2[0][3][11] Prod2[1][3][11] Prod2[2][3][11] Prod2[3][3][11] N288 N3650 N3690 _NC0 _NC1 MUX41X1
X1 Prod2[0][3][10] Prod2[1][3][10] Prod2[2][3][10] Prod2[3][3][10] N289 N3650 N3700 _NC2 _NC3 MUX41X1
X2 Prod2[0][3][9] Prod2[1][3][9] Prod2[2][3][9] Prod2[3][3][9] N290 N3650 N3700 _NC4 _NC5 MUX41X1
X3 Prod2[0][3][8] Prod2[1][3][8] Prod2[2][3][8] Prod2[3][3][8] N291 N3650 N1 _NC6 _NC7 MUX41X1
X4 Prod2[0][3][7] Prod2[1][3][7] Prod2[2][3][7] Prod2[3][3][7] N292 N3650 N1 _NC8 _NC9 MUX41X1
X5 Prod2[0][3][6] Prod2[1][3][6] Prod2[2][3][6] Prod2[3][3][6] N293 N3650 N1 _NC10 _NC11 MUX41X1
X6 Prod2[0][3][5] Prod2[1][3][5] Prod2[2][3][5] Prod2[3][3][5] N205 N3650 N3700 _NC12 _NC13 MUX41X1
X7 Prod2[0][3][4] Prod2[1][3][4] Prod2[2][3][4] Prod2[3][3][4] N204 N3650 N3700 _NC14 _NC15 MUX41X1
X8 Prod2[0][3][3] Prod2[1][3][3] Prod2[2][3][3] Prod2[3][3][3] N203 N3650 N3700 _NC16 _NC17 MUX41X1
X9 Prod2[0][3][2] Prod2[1][3][2] Prod2[2][3][2] Prod2[3][3][2] N202 N3650 N3700 _NC18 _NC19 MUX41X1
X10 Prod2[0][3][1] Prod2[1][3][1] Prod2[2][3][1] Prod2[3][3][1] N201 N3650 N3700 _NC20 _NC21 MUX41X1
X11 Prod2[0][3][0] Prod2[1][3][0] Prod2[2][3][0] Prod2[3][3][0] N200 N3650 N3700 _NC22 _NC23 MUX41X1
X12 Prod2[0][2][17] Prod2[1][2][17] Prod2[2][2][17] Prod2[3][2][17] N232 N3660 N3690 _NC24 _NC25 MUX41X1
X13 Prod2[0][2][16] Prod2[1][2][16] Prod2[2][2][16] Prod2[3][2][16] N233 N3660 N3690 _NC26 _NC27 MUX41X1
X14 Prod2[0][2][15] Prod2[1][2][15] Prod2[2][2][15] Prod2[3][2][15] N234 N3660 N3690 _NC28 _NC29 MUX41X1
X15 Prod2[0][2][14] Prod2[1][2][14] Prod2[2][2][14] Prod2[3][2][14] N235 N3660 N3690 _NC30 _NC31 MUX41X1
X16 Prod2[0][2][13] Prod2[1][2][13] Prod2[2][2][13] Prod2[3][2][13] N236 N3660 N3690 _NC32 _NC33 MUX41X1
X17 Prod2[0][2][12] Prod2[1][2][12] Prod2[2][2][12] Prod2[3][2][12] N237 N3660 N3690 _NC34 _NC35 MUX41X1
X18 Prod2[0][2][11] Prod2[1][2][11] Prod2[2][2][11] Prod2[3][2][11] N261 N3660 N3690 _NC36 _NC37 MUX41X1
X19 Prod2[0][2][10] Prod2[1][2][10] Prod2[2][2][10] Prod2[3][2][10] N260 N3660 N3690 _NC38 _NC39 MUX41X1
X20 Prod2[0][2][9] Prod2[1][2][9] Prod2[2][2][9] Prod2[3][2][9] N259 N3660 N3690 _NC40 _NC41 MUX41X1
X21 Prod2[0][2][8] Prod2[1][2][8] Prod2[2][2][8] Prod2[3][2][8] N258 N3660 N3690 _NC42 _NC43 MUX41X1
X22 Prod2[0][2][7] Prod2[1][2][7] Prod2[2][2][7] Prod2[3][2][7] N257 N3660 N3690 _NC44 _NC45 MUX41X1
X23 Prod2[0][2][6] Prod2[1][2][6] Prod2[2][2][6] Prod2[3][2][6] N256 N3660 N3690 _NC46 _NC47 MUX41X1
X24 Prod2[0][1][17] Prod2[1][1][17] Prod2[2][1][17] Prod2[3][1][17] N182 N3670 N3700 _NC48 _NC49 MUX41X1
X25 Prod2[0][1][16] Prod2[1][1][16] Prod2[2][1][16] Prod2[3][1][16] N183 N3670 N3700 _NC50 _NC51 MUX41X1
X26 Prod2[0][1][15] Prod2[1][1][15] Prod2[2][1][15] Prod2[3][1][15] N184 N3670 N1 _NC52 _NC53 MUX41X1
X27 Prod2[0][1][14] Prod2[1][1][14] Prod2[2][1][14] Prod2[3][1][14] N185 N3670 N3690 _NC54 _NC55 MUX41X1
X28 Prod2[0][1][13] Prod2[1][1][13] Prod2[2][1][13] Prod2[3][1][13] N186 N3670 N3700 _NC56 _NC57 MUX41X1
X29 Prod2[0][1][12] Prod2[1][1][12] Prod2[2][1][12] Prod2[3][1][12] N187 N3670 N1 _NC58 _NC59 MUX41X1
X30 Prod2[0][1][11] Prod2[1][1][11] Prod2[2][1][11] Prod2[3][1][11] N188 N3670 N1 _NC60 _NC61 MUX41X1
X31 Prod2[0][1][10] Prod2[1][1][10] Prod2[2][1][10] Prod2[3][1][10] N189 N3670 N3700 _NC62 _NC63 MUX41X1
X32 Prod2[0][1][9] Prod2[1][1][9] Prod2[2][1][9] Prod2[3][1][9] N190 N3670 N1 _NC64 _NC65 MUX41X1
X33 Prod2[0][1][8] Prod2[1][1][8] Prod2[2][1][8] Prod2[3][1][8] N191 N3670 N1 _NC66 _NC67 MUX41X1
X34 Prod2[0][1][7] Prod2[1][1][7] Prod2[2][1][7] Prod2[3][1][7] N192 N3670 N1 _NC68 _NC69 MUX41X1
X35 Prod2[0][1][6] Prod2[1][1][6] Prod2[2][1][6] Prod2[3][1][6] N193 N3670 N1 _NC70 _NC71 MUX41X1
X36 Prod2[0][0][23] Prod2[1][0][23] Prod2[2][0][23] Prod2[3][0][23] N152 N3680 N3700 _NC72 _NC73 MUX41X1
X37 Prod2[0][0][22] Prod2[1][0][22] Prod2[2][0][22] Prod2[3][0][22] N153 N3680 N3700 _NC74 _NC75 MUX41X1
X38 Prod2[0][0][21] Prod2[1][0][21] Prod2[2][0][21] Prod2[3][0][21] N154 N3680 N1 _NC76 _NC77 MUX41X1
X39 Prod2[0][0][20] Prod2[1][0][20] Prod2[2][0][20] Prod2[3][0][20] N155 N3680 N1 _NC78 _NC79 MUX41X1
X40 Prod2[0][0][19] Prod2[1][0][19] Prod2[2][0][19] Prod2[3][0][19] N156 N3680 N3700 _NC80 _NC81 MUX41X1
X41 Prod2[0][0][18] Prod2[1][0][18] Prod2[2][0][18] Prod2[3][0][18] N157 N3680 N1 _NC82 _NC83 MUX41X1
X42 Prod2[0][0][17] Prod2[1][0][17] Prod2[2][0][17] Prod2[3][0][17] N158 N3680 N1 _NC84 _NC85 MUX41X1
X43 Prod2[0][0][16] Prod2[1][0][16] Prod2[2][0][16] Prod2[3][0][16] N159 N3680 N3700 _NC86 _NC87 MUX41X1
X44 Prod2[0][0][15] Prod2[1][0][15] Prod2[2][0][15] Prod2[3][0][15] N160 N3680 N3700 _NC88 _NC89 MUX41X1
X45 Prod2[0][0][14] Prod2[1][0][14] Prod2[2][0][14] Prod2[3][0][14] N161 N3680 N1 _NC90 _NC91 MUX41X1
X46 Prod2[0][0][13] Prod2[1][0][13] Prod2[2][0][13] Prod2[3][0][13] N162 N3680 N1 _NC92 _NC93 MUX41X1
X47 Prod2[0][0][12] Prod2[1][0][12] Prod2[2][0][12] Prod2[3][0][12] N163 N3680 N1 _NC94 _NC95 MUX41X1
X48 N163 N237 N262 _NC96 _NC97 XOR2X1
X49 N237 N163 Add_2_root_add_0_root_add_208_3_carry[0] _NC98 _NC99 AND2X1
X50 N157 Add_2_root_add_0_root_add_208_3_carry[5] N268 _NC100 _NC101 XOR2X1
X51 Add_2_root_add_0_root_add_208_3_carry[5] N157 Add_2_root_add_0_root_add_208_3_carry[6] _NC102 _NC103 AND2X1
X52 N156 Add_2_root_add_0_root_add_208_3_carry[6] N269 _NC104 _NC105 XOR2X1
X53 Add_2_root_add_0_root_add_208_3_carry[6] N156 Add_2_root_add_0_root_add_208_3_carry[7] _NC106 _NC107 AND2X1
X54 N155 Add_2_root_add_0_root_add_208_3_carry[7] N270 _NC108 _NC109 XOR2X1
X55 Add_2_root_add_0_root_add_208_3_carry[7] N155 Add_2_root_add_0_root_add_208_3_carry[8] _NC110 _NC111 AND2X1
X56 N154 Add_2_root_add_0_root_add_208_3_carry[8] N271 _NC112 _NC113 XOR2X1
X57 Add_2_root_add_0_root_add_208_3_carry[8] N154 Add_2_root_add_0_root_add_208_3_carry[9] _NC114 _NC115 AND2X1
X58 N153 Add_2_root_add_0_root_add_208_3_carry[9] N272 _NC116 _NC117 XOR2X1
X59 Add_2_root_add_0_root_add_208_3_carry[9] N153 Add_2_root_add_0_root_add_208_3_carry[10] _NC118 _NC119 AND2X1
X60 N152 Add_2_root_add_0_root_add_208_3_carry[10] N273 _NC120 _NC121 XOR2X1
X61 N193 N293 N206 _NC122 _NC123 XOR2X1
X62 N293 N193 Add_1_root_add_0_root_add_208_3_carry[7] _NC124 _NC125 AND2X1
X63 N187 Add_1_root_add_0_root_add_208_3_carry[12] N212 _NC126 _NC127 XOR2X1
X64 Add_1_root_add_0_root_add_208_3_carry[12] N187 Add_1_root_add_0_root_add_208_3_carry[13] _NC128 _NC129 AND2X1
X65 N186 Add_1_root_add_0_root_add_208_3_carry[13] N213 _NC130 _NC131 XOR2X1
X66 Add_1_root_add_0_root_add_208_3_carry[13] N186 Add_1_root_add_0_root_add_208_3_carry[14] _NC132 _NC133 AND2X1
X67 N185 Add_1_root_add_0_root_add_208_3_carry[14] N214 _NC134 _NC135 XOR2X1
X68 Add_1_root_add_0_root_add_208_3_carry[14] N185 Add_1_root_add_0_root_add_208_3_carry[15] _NC136 _NC137 AND2X1
X69 N184 Add_1_root_add_0_root_add_208_3_carry[15] N215 _NC138 _NC139 XOR2X1
X70 Add_1_root_add_0_root_add_208_3_carry[15] N184 Add_1_root_add_0_root_add_208_3_carry[16] _NC140 _NC141 AND2X1
X71 N183 Add_1_root_add_0_root_add_208_3_carry[16] N216 _NC142 _NC143 XOR2X1
X72 Add_1_root_add_0_root_add_208_3_carry[16] N183 Add_1_root_add_0_root_add_208_3_carry[17] _NC144 _NC145 AND2X1
X73 N182 Add_1_root_add_0_root_add_208_3_carry[17] N217 _NC146 _NC147 XOR2X1
X74 Add_1_root_add_0_root_add_208_3_carry[17] N182 N218 _NC148 _NC149 AND2X1
X75 N25 _NC150 _NC151 N3700 INVX0
X76 N25 _NC152 _NC153 N3690 INVX0
X77 N3570 _NC154 _NC155 N3640 INVX0
X78 N35 _NC156 _NC157 N3560 INVX0
X79 N35 _NC158 _NC159 N3550 INVX0
X80 N35 _NC160 _NC161 N3540 INVX0
X81 N3411 _NC162 _NC163 N32 INVX0
X82 N30 _NC164 _NC165 N29 INVX0
X83 N22 _NC166 _NC167 N28 INVX0
X84 N22 _NC168 _NC169 N27 INVX0
X85 N20 _NC170 _NC171 N19 INVX0
X86 N15 _NC172 _NC173 N14 INVX0
X87 N15 _NC174 _NC175 N13 INVX0
X88 N18 _NC176 _NC177 N12 INVX0
X89 N8 _NC178 _NC179 N7 INVX0
X90 N8 _NC180 _NC181 N6 INVX0
X91 N11 _NC182 _NC183 N5 INVX0
X92 S_fracta_i[23] S_fracta_i[11] N69 N2 _NC184 _NC185 MUX21X1
X93 S_fracta_i[22] S_fracta_i[10] N70 N2 _NC186 _NC187 MUX21X1
X94 S_fracta_i[21] S_fracta_i[9] N71 N2 _NC188 _NC189 MUX21X1
X95 S_fracta_i[20] S_fracta_i[8] N72 N2 _NC190 _NC191 MUX21X1
X96 S_fracta_i[19] S_fracta_i[7] N73 N2 _NC192 _NC193 MUX21X1
X97 S_fracta_i[18] S_fracta_i[6] N74 N2 _NC194 _NC195 MUX21X1
X98 S_fractb_i[23] S_fractb_i[11] N87 N25 _NC196 _NC197 MUX21X1
X99 S_fractb_i[22] S_fractb_i[10] N88 N25 _NC198 _NC199 MUX21X1
X100 S_fractb_i[21] S_fractb_i[9] N89 N25 _NC200 _NC201 MUX21X1
X101 S_fractb_i[20] S_fractb_i[8] N90 N25 _NC202 _NC203 MUX21X1
X102 S_fractb_i[19] S_fractb_i[7] N91 N25 _NC204 _NC205 MUX21X1
X103 S_fractb_i[18] S_fractb_i[6] N92 N25 _NC206 _NC207 MUX21X1
X104 S_fractb_i[17] S_fractb_i[5] N111 N25 _NC208 _NC209 MUX21X1
X105 S_fractb_i[16] S_fractb_i[4] N112 N25 _NC210 _NC211 MUX21X1
X106 S_fractb_i[15] S_fractb_i[3] N113 N25 _NC212 _NC213 MUX21X1
X107 S_fractb_i[14] S_fractb_i[2] N114 N25 _NC214 _NC215 MUX21X1
X108 S_fractb_i[13] S_fractb_i[1] N115 N25 _NC216 _NC217 MUX21X1
X109 S_fractb_i[12] S_fractb_i[0] N116 N25 _NC218 _NC219 MUX21X1
X110 S_fracta_i[17] S_fracta_i[5] N105 N2 _NC220 _NC221 MUX21X1
X111 S_fracta_i[16] S_fracta_i[4] N106 N2 _NC222 _NC223 MUX21X1
X112 S_fracta_i[15] S_fracta_i[3] N107 N2 _NC224 _NC225 MUX21X1
X113 S_fracta_i[14] S_fracta_i[2] N108 N2 _NC226 _NC227 MUX21X1
X114 S_fracta_i[13] S_fracta_i[1] N109 N2 _NC228 _NC229 MUX21X1
X115 S_fracta_i[12] S_fracta_i[0] N110 N2 _NC230 _NC231 MUX21X1
X116 S_state S_start_i N580 _NC232 _NC233 NOR2X0
X117 N26 N3730 N54 N56 _NC234 _NC235 OA21X1
X118 N54 _NC236 _NC237 N3710 INVX0
X119 N3760 S_start_i N53 _NC238 _NC239 NOR2X0
X120 N46 Count[2] N144 _NC240 _NC241 NOR2X0
X121 N43 N38 N50 _NC242 _NC243 NAND2X1
X122 N3700 N26 N43 _NC244 _NC245 NOR2X0
X123 S_state N3640 N47 _NC246 _NC247 NAND2X1
X124 N3750 Count[2] N132 _NC248 _NC249 NOR2X0
X125 N26 _NC250 _NC251 N2 NBUFFX2
X126 N26 N25 N46 _NC252 _NC253 NAND2X1
X127 N25 N26 N49 _NC254 _NC255 NOR2X0
X128 N580 _NC256 _NC257 N3720 INVX0
X129 N51 _NC258 _NC259 N11 INVX0
X130 N51 _NC260 _NC261 N10 INVX0
X131 N51 _NC262 _NC263 N9 INVX0
X132 N51 _NC264 _NC265 N8 INVX0
X133 N53 _NC266 _NC267 N3730 INVX0
X134 N25 N580 N590 _NC268 _NC269 NOR2X0
X135 N3730 N25 N3720 N54 _NC270 _NC271 OA21X1
X136 N55 _NC272 _NC273 N3760 INVX0
X137 N144 _NC274 _NC275 N3530 NBUFFX2
X138 N132 _NC276 _NC277 N3580 NBUFFX2
X139 N132 _NC278 _NC279 N3590 NBUFFX2
X140 N132 _NC280 _NC281 N3600 NBUFFX2
X141 N132 _NC282 _NC283 N3610 NBUFFX2
X142 N132 _NC284 _NC285 N3620 NBUFFX2
X143 N132 _NC286 _NC287 N3630 NBUFFX2
X144 N144 _NC288 _NC289 N35 NBUFFX2
X145 N144 _NC290 _NC291 N36 NBUFFX2
X146 N144 _NC292 _NC293 N39 NBUFFX2
X147 N144 _NC294 _NC295 N37 NBUFFX2
X148 N144 _NC296 _NC297 N40 NBUFFX2
X149 N144 _NC298 _NC299 N41 NBUFFX2
X150 N50 _NC300 _NC301 N18 INVX0
X151 N50 _NC302 _NC303 N17 INVX0
X152 N50 _NC304 _NC305 N16 INVX0
X153 N50 _NC306 _NC307 N15 INVX0
X154 N46 N47 N45 _NC308 _NC309 NOR2X0
X155 N47 _NC310 _NC311 N3740 INVX0
X156 N132 _NC312 _NC313 N3570 NBUFFX2
X157 N3740 N49 N48 _NC314 _NC315 NAND2X1
X158 N44 _NC316 _NC317 N31 INVX0
X159 N44 _NC318 _NC319 N30 INVX0
X160 N3740 N43 N42 _NC320 _NC321 NAND2X1
X161 N3750 N46 N34 _NC322 _NC323 NAND2X1
X162 N49 _NC324 _NC325 N3750 INVX0
X163 N48 _NC326 _NC327 N21 INVX0
X164 N48 _NC328 _NC329 N20 INVX0
X165 N45 _NC330 _NC331 N2611 NBUFFX2
X166 N42 _NC332 _NC333 N3411 INVX0
X167 N42 _NC334 _NC335 N33 INVX0
X168 N45 _NC336 _NC337 N23 NBUFFX2
X169 N45 _NC338 _NC339 N24 NBUFFX2
X170 N45 _NC340 _NC341 N22 NBUFFX2
X171 N34 _NC342 _NC343 N3680 NBUFFX2
X172 N34 _NC344 _NC345 N3650 NBUFFX2
X173 N34 _NC346 _NC347 N3660 NBUFFX2
X174 N34 _NC348 _NC349 N3670 NBUFFX2
X175 N3640 _NC350 _NC351 N4 NBUFFX2
X176 N3640 _NC352 _NC353 N3 NBUFFX2
X177 N188 N288 Add_1_root_add_0_root_add_208_3_carry[11] Add_1_root_add_0_root_add_208_3_carry[12] N211 _NC354 _NC355 FADDX1
X178 N189 N289 Add_1_root_add_0_root_add_208_3_carry[10] Add_1_root_add_0_root_add_208_3_carry[11] N210 _NC356 _NC357 FADDX1
X179 N190 N290 Add_1_root_add_0_root_add_208_3_carry[9] Add_1_root_add_0_root_add_208_3_carry[10] N209 _NC358 _NC359 FADDX1
X180 N191 N291 Add_1_root_add_0_root_add_208_3_carry[8] Add_1_root_add_0_root_add_208_3_carry[9] N208 _NC360 _NC361 FADDX1
X181 N192 N292 Add_1_root_add_0_root_add_208_3_carry[7] Add_1_root_add_0_root_add_208_3_carry[8] N207 _NC362 _NC363 FADDX1
X182 N158 N232 Add_2_root_add_0_root_add_208_3_carry[4] Add_2_root_add_0_root_add_208_3_carry[5] N267 _NC364 _NC365 FADDX1
X183 N159 N233 Add_2_root_add_0_root_add_208_3_carry[3] Add_2_root_add_0_root_add_208_3_carry[4] N266 _NC366 _NC367 FADDX1
X184 N160 N234 Add_2_root_add_0_root_add_208_3_carry[2] Add_2_root_add_0_root_add_208_3_carry[3] N265 _NC368 _NC369 FADDX1
X185 N161 N235 Add_2_root_add_0_root_add_208_3_carry[1] Add_2_root_add_0_root_add_208_3_carry[2] N264 _NC370 _NC371 FADDX1
X186 N162 N236 Add_2_root_add_0_root_add_208_3_carry[0] Add_2_root_add_0_root_add_208_3_carry[1] N263 _NC372 _NC373 FADDX1
X187 Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss N340 N341 N342 N343 N344 N345 N346 N347 N348 N349 N350 N351 N352 N353 N354 N355 N356 N357 N358 N359 N360 N361 N362 N363 N364 N365 N366 N367 N368 N369 N370 N371 N372 N373 N374 N375 N376 N377 N378 N379 N380 N381 N382 N383 N384 N385 N386 N387 N388 N389 N390 N391 N392 N393 N394 N395 N396 N397 N398 N399 N400 N401 N402 N403 N404 N405 N406 N407 N408 N409 N410 N411 N412 Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Fract_o[0] Fract_o[1] Fract_o[2] Fract_o[3] Fract_o[4] Fract_o[5] Fract_o[6] Fract_o[7] Fract_o[8] Fract_o[9] Fract_o[10] Fract_o[11] Fract_o[12] Fract_o[13] Fract_o[14] Fract_o[15] Fract_o[16] Fract_o[17] Fract_o[18] Fract_o[19] Fract_o[20] Fract_o[21] Fract_o[22] Fract_o[23] Fract_o[24] Fract_o[25] Fract_o[26] Fract_o[27] Fract_o[28] Fract_o[29] Fract_o[30] Fract_o[31] Fract_o[32] Fract_o[33] Fract_o[34] Fract_o[35] Fract_o[36] Fract_o[37] Fract_o[38] Fract_o[39] Fract_o[40] Fract_o[41] Fract_o[42] Fract_o[43] Fract_o[44] Fract_o[45] Fract_o[46] Fract_o[47] _NC374 mul_24_DW01_add_0
X188 Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Sum[24] Sum[25] Sum[26] Sum[27] Sum[28] Sum[29] Sum[30] Sum[31] Sum[32] Sum[33] Sum[34] Sum[35] Sum[36] Sum[37] Sum[38] Sum[39] Sum[40] Sum[41] Sum[42] Sum[43] Sum[44] Sum[45] Sum[46] Sum[47] Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Sum[0] Sum[1] Sum[2] Sum[3] Sum[4] Sum[5] Sum[6] Sum[7] Sum[8] Sum[9] Sum[10] Sum[11] Sum[12] Sum[13] Sum[14] Sum[15] Sum[16] Sum[17] Sum[18] Sum[19] Sum[20] Sum[21] Sum[22] Sum[23] Vss SYNOPSYS_UNCONNECTED__22 SYNOPSYS_UNCONNECTED__21 SYNOPSYS_UNCONNECTED__20 SYNOPSYS_UNCONNECTED__19 SYNOPSYS_UNCONNECTED__18 SYNOPSYS_UNCONNECTED__17 SYNOPSYS_UNCONNECTED__16 SYNOPSYS_UNCONNECTED__15 SYNOPSYS_UNCONNECTED__14 SYNOPSYS_UNCONNECTED__13 SYNOPSYS_UNCONNECTED__12 SYNOPSYS_UNCONNECTED__11 N340 N341 N342 N343 N344 N345 N346 N347 N348 N349 N350 N351 N352 N353 N354 N355 N356 N357 N358 N359 N360 N361 N362 N363 N364 N365 N366 N367 N368 N369 N370 N371 N372 N373 N374 N375 _NC375 mul_24_DW01_add_1
X189 Sum[72] Sum[73] Sum[74] Sum[75] Sum[76] Sum[77] Sum[78] Sum[79] Sum[80] Sum[81] Sum[82] Sum[83] Sum[84] Sum[85] Sum[86] Sum[87] Sum[88] Sum[89] Sum[90] Sum[91] Sum[92] Sum[93] Sum[94] Sum[95] Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Sum[48] Sum[49] Sum[50] Sum[51] Sum[52] Sum[53] Sum[54] Sum[55] Sum[56] Sum[57] Sum[58] Sum[59] Sum[60] Sum[61] Sum[62] Sum[63] Sum[64] Sum[65] Sum[66] Sum[67] Sum[68] Sum[69] Sum[70] Sum[71] Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss N376 N377 N378 N379 N380 N381 N382 N383 N384 N385 N386 N387 N388 N389 N390 N391 N392 N393 N394 N395 N396 N397 N398 N399 N400 N401 N402 N403 N404 N405 N406 N407 N408 N409 N410 N411 N412 SYNOPSYS_UNCONNECTED__10 SYNOPSYS_UNCONNECTED__9 SYNOPSYS_UNCONNECTED__8 SYNOPSYS_UNCONNECTED__7 SYNOPSYS_UNCONNECTED__6 SYNOPSYS_UNCONNECTED__5 SYNOPSYS_UNCONNECTED__4 SYNOPSYS_UNCONNECTED__3 SYNOPSYS_UNCONNECTED__2 SYNOPSYS_UNCONNECTED__1 SYNOPSYS_UNCONNECTED__0 _NC376 mul_24_DW01_add_2
X190 N110 N109 N108 N107 N106 N105 N116 N115 N114 N113 N112 N111 N117 N118 N119 N120 N121 N122 N123 N124 N125 N126 N127 N128 mul_24_DW_mult_uns_0
X191 N110 N109 N108 N107 N106 N105 N92 N91 N90 N89 N88 N87 N93 N94 N95 N96 N97 N98 N99 N100 N101 N102 N103 N104 mul_24_DW_mult_uns_1
X192 N74 N73 N72 N71 N70 N69 N116 N115 N114 N113 N112 N111 N75 N76 N77 N78 N79 N80 N81 N82 N83 N84 N85 N86 mul_24_DW_mult_uns_2
X193 N74 N73 N72 N71 N70 N69 N92 N91 N90 N89 N88 N87 N57 N58 N59 N60 N61 N62 N63 N64 N65 N66 N67 N68 mul_24_DW_mult_uns_3
X194 Vss Vss Vss Vss Vss Vss N256 N257 N258 N259 N260 N261 N262 N263 N264 N265 N266 N267 N268 N269 N270 N271 N272 N273 N200 N201 N202 N203 N204 N205 N206 N207 N208 N209 N210 N211 N212 N213 N214 N215 N216 N217 N218 Vss Vss Vss Vss Vss Vss N300 N301 N302 N303 N304 N305 N306 N307 N308 N309 N310 N311 N312 N313 N314 N315 N316 N317 N318 N319 N320 N321 N322 N323 _NC377 mul_24_DW01_add_3
X195 N3700 N38 N26 N51 _NC378 _NC379 NAND3X0
X196 S_state N49 Count[2] N55 _NC380 _NC381 NAND3X0
X197 N580 N25 N590 N53 N3520 _NC382 _NC383 AO22X1
X198 N35 N3720 N53 N570 _NC384 _NC385 NAND3X0
X199 N56 N38 N570 N3510 _NC386 _NC387 OAI21X1
X200 S_state N55 S_start_i N3500 _NC388 _NC389 AO21X1
X201 N3760 N250 Ready_o N3720 N3490 _NC390 _NC391 AO22X1
X202 N3720 N43 N52 _NC392 _NC393 AND2X1
X203 N26 N3710 N52 N53 N3480 _NC394 _NC395 AO22X1
X204 N35 N128 Prod2[3][3][11] N3560 N3470 _NC396 _NC397 AO22X1
X205 N36 N127 Prod2[3][3][10] N3560 N3460 _NC398 _NC399 AO22X1
X206 N36 N126 Prod2[3][3][9] N3560 N3450 _NC400 _NC401 AO22X1
X207 N36 N125 Prod2[3][3][8] N3560 N3440 _NC402 _NC403 AO22X1
X208 N36 N124 Prod2[3][3][7] N3560 N3430 _NC404 _NC405 AO22X1
X209 N36 N123 Prod2[3][3][6] N3560 N3420 _NC406 _NC407 AO22X1
X210 N36 N122 Prod2[3][3][5] N3560 N3410 _NC408 _NC409 AO22X1
X211 N39 N121 Prod2[3][3][4] N3560 N3400 _NC410 _NC411 AO22X1
X212 N36 N120 Prod2[3][3][3] N3560 N3390 _NC412 _NC413 AO22X1
X213 N36 N119 Prod2[3][3][2] N3560 N3380 _NC414 _NC415 AO22X1
X214 N37 N118 Prod2[3][3][1] N3560 N3370 _NC416 _NC417 AO22X1
X215 N37 N117 Prod2[3][3][0] N3560 N3360 _NC418 _NC419 AO22X1
X216 N37 N104 Prod2[3][2][17] N3550 N3350 _NC420 _NC421 AO22X1
X217 N37 N103 Prod2[3][2][16] N3550 N3340 _NC422 _NC423 AO22X1
X218 N37 N102 Prod2[3][2][15] N3550 N3330 _NC424 _NC425 AO22X1
X219 N37 N101 Prod2[3][2][14] N3550 N3320 _NC426 _NC427 AO22X1
X220 N37 N100 Prod2[3][2][13] N3550 N3310 _NC428 _NC429 AO22X1
X221 N37 N99 Prod2[3][2][12] N3550 N3300 _NC430 _NC431 AO22X1
X222 N39 N98 Prod2[3][2][11] N3550 N3290 _NC432 _NC433 AO22X1
X223 N39 N97 Prod2[3][2][10] N3550 N3280 _NC434 _NC435 AO22X1
X224 N39 N96 Prod2[3][2][9] N3550 N327 _NC436 _NC437 AO22X1
X225 N39 N95 Prod2[3][2][8] N3550 N326 _NC438 _NC439 AO22X1
X226 N39 N94 Prod2[3][2][7] N3550 N325 _NC440 _NC441 AO22X1
X227 N39 N93 Prod2[3][2][6] N3550 N324 _NC442 _NC443 AO22X1
X228 N39 N86 Prod2[3][1][17] N3540 N3230 _NC444 _NC445 AO22X1
X229 N40 N85 Prod2[3][1][16] N3540 N3220 _NC446 _NC447 AO22X1
X230 N40 N84 Prod2[3][1][15] N3540 N3210 _NC448 _NC449 AO22X1
X231 N40 N83 Prod2[3][1][14] N3540 N3200 _NC450 _NC451 AO22X1
X232 N40 N82 Prod2[3][1][13] N3540 N3190 _NC452 _NC453 AO22X1
X233 N40 N81 Prod2[3][1][12] N3540 N3180 _NC454 _NC455 AO22X1
X234 N40 N80 Prod2[3][1][11] N3540 N3170 _NC456 _NC457 AO22X1
X235 N40 N79 Prod2[3][1][10] N3540 N3160 _NC458 _NC459 AO22X1
X236 N40 N78 Prod2[3][1][9] N3540 N3150 _NC460 _NC461 AO22X1
X237 N41 N77 Prod2[3][1][8] N3540 N3140 _NC462 _NC463 AO22X1
X238 N41 N76 Prod2[3][1][7] N3540 N3130 _NC464 _NC465 AO22X1
X239 N41 N75 Prod2[3][1][6] N3540 N3120 _NC466 _NC467 AO22X1
X240 N41 N68 Prod2[3][0][23] N3540 N3110 _NC468 _NC469 AO22X1
X241 N41 N67 Prod2[3][0][22] N3550 N3100 _NC470 _NC471 AO22X1
X242 N41 N66 Prod2[3][0][21] N3560 N3090 _NC472 _NC473 AO22X1
X243 N41 N65 Prod2[3][0][20] N3540 N3080 _NC474 _NC475 AO22X1
X244 N41 N64 Prod2[3][0][19] N3550 N3070 _NC476 _NC477 AO22X1
X245 N3530 N63 Prod2[3][0][18] N3560 N3060 _NC478 _NC479 AO22X1
X246 N3530 N62 Prod2[3][0][17] N3540 N3050 _NC480 _NC481 AO22X1
X247 N3530 N61 Prod2[3][0][16] N3550 N3040 _NC482 _NC483 AO22X1
X248 N3530 N60 Prod2[3][0][15] N3560 N3030 _NC484 _NC485 AO22X1
X249 N3530 N59 Prod2[3][0][14] N3540 N3020 _NC486 _NC487 AO22X1
X250 N3530 N58 Prod2[3][0][13] N3550 N3010 _NC488 _NC489 AO22X1
X251 N35 N57 Prod2[3][0][12] N3560 N3000 _NC490 _NC491 AO22X1
X252 N10 N128 Prod2[2][3][11] N5 N299 _NC492 _NC493 AO22X1
X253 N8 N127 Prod2[2][3][10] N5 N298 _NC494 _NC495 AO22X1
X254 N9 N126 Prod2[2][3][9] N5 N297 _NC496 _NC497 AO22X1
X255 N10 N125 Prod2[2][3][8] N5 N296 _NC498 _NC499 AO22X1
X256 N11 N124 Prod2[2][3][7] N5 N295 _NC500 _NC501 AO22X1
X257 N11 N123 Prod2[2][3][6] N5 N294 _NC502 _NC503 AO22X1
X258 N11 N122 Prod2[2][3][5] N5 N2930 _NC504 _NC505 AO22X1
X259 N11 N121 Prod2[2][3][4] N5 N2920 _NC506 _NC507 AO22X1
X260 N11 N120 Prod2[2][3][3] N5 N2910 _NC508 _NC509 AO22X1
X261 N11 N119 Prod2[2][3][2] N5 N2900 _NC510 _NC511 AO22X1
X262 N11 N118 Prod2[2][3][1] N5 N2890 _NC512 _NC513 AO22X1
X263 N9 N117 Prod2[2][3][0] N5 N2880 _NC514 _NC515 AO22X1
X264 N10 N104 Prod2[2][2][17] N6 N287 _NC516 _NC517 AO22X1
X265 N9 N103 Prod2[2][2][16] N6 N286 _NC518 _NC519 AO22X1
X266 N10 N102 Prod2[2][2][15] N6 N285 _NC520 _NC521 AO22X1
X267 N9 N101 Prod2[2][2][14] N6 N284 _NC522 _NC523 AO22X1
X268 N10 N100 Prod2[2][2][13] N6 N283 _NC524 _NC525 AO22X1
X269 N9 N99 Prod2[2][2][12] N6 N282 _NC526 _NC527 AO22X1
X270 N10 N98 Prod2[2][2][11] N6 N281 _NC528 _NC529 AO22X1
X271 N10 N97 Prod2[2][2][10] N6 N280 _NC530 _NC531 AO22X1
X272 N10 N96 Prod2[2][2][9] N6 N279 _NC532 _NC533 AO22X1
X273 N10 N95 Prod2[2][2][8] N6 N278 _NC534 _NC535 AO22X1
X274 N10 N94 Prod2[2][2][7] N6 N277 _NC536 _NC537 AO22X1
X275 N10 N93 Prod2[2][2][6] N6 N276 _NC538 _NC539 AO22X1
X276 N10 N86 Prod2[2][1][17] N7 N275 _NC540 _NC541 AO22X1
X277 N9 N85 Prod2[2][1][16] N7 N274 _NC542 _NC543 AO22X1
X278 N9 N84 Prod2[2][1][15] N7 N2730 _NC544 _NC545 AO22X1
X279 N9 N83 Prod2[2][1][14] N7 N2720 _NC546 _NC547 AO22X1
X280 N9 N82 Prod2[2][1][13] N7 N2710 _NC548 _NC549 AO22X1
X281 N9 N81 Prod2[2][1][12] N7 N2700 _NC550 _NC551 AO22X1
X282 N9 N80 Prod2[2][1][11] N7 N2690 _NC552 _NC553 AO22X1
X283 N9 N79 Prod2[2][1][10] N7 N2680 _NC554 _NC555 AO22X1
X284 N8 N78 Prod2[2][1][9] N7 N2670 _NC556 _NC557 AO22X1
X285 N8 N77 Prod2[2][1][8] N7 N2660 _NC558 _NC559 AO22X1
X286 N8 N76 Prod2[2][1][7] N7 N2650 _NC560 _NC561 AO22X1
X287 N8 N75 Prod2[2][1][6] N7 N2640 _NC562 _NC563 AO22X1
X288 N8 N68 Prod2[2][0][23] N51 N2630 _NC564 _NC565 AO22X1
X289 N8 N67 Prod2[2][0][22] N51 N2620 _NC566 _NC567 AO22X1
X290 N8 N66 Prod2[2][0][21] N51 N2610 _NC568 _NC569 AO22X1
X291 N10 N65 Prod2[2][0][20] N6 N2600 _NC570 _NC571 AO22X1
X292 N9 N64 Prod2[2][0][19] N51 N2590 _NC572 _NC573 AO22X1
X293 N10 N63 Prod2[2][0][18] N7 N2580 _NC574 _NC575 AO22X1
X294 N9 N62 Prod2[2][0][17] N51 N2570 _NC576 _NC577 AO22X1
X295 N10 N61 Prod2[2][0][16] N5 N2560 _NC578 _NC579 AO22X1
X296 N9 N60 Prod2[2][0][15] N51 N255 _NC580 _NC581 AO22X1
X297 N10 N59 Prod2[2][0][14] N5 N254 _NC582 _NC583 AO22X1
X298 N9 N58 Prod2[2][0][13] N51 N253 _NC584 _NC585 AO22X1
X299 N10 N57 Prod2[2][0][12] N5 N252 _NC586 _NC587 AO22X1
X300 N17 N128 Prod2[1][3][11] N12 N251 _NC588 _NC589 AO22X1
X301 N15 N127 Prod2[1][3][10] N12 N2500 _NC590 _NC591 AO22X1
X302 N16 N126 Prod2[1][3][9] N12 N249 _NC592 _NC593 AO22X1
X303 N17 N125 Prod2[1][3][8] N12 N248 _NC594 _NC595 AO22X1
X304 N18 N124 Prod2[1][3][7] N12 N247 _NC596 _NC597 AO22X1
X305 N18 N123 Prod2[1][3][6] N12 N246 _NC598 _NC599 AO22X1
X306 N18 N122 Prod2[1][3][5] N12 N245 _NC600 _NC601 AO22X1
X307 N18 N121 Prod2[1][3][4] N12 N244 _NC602 _NC603 AO22X1
X308 N18 N120 Prod2[1][3][3] N12 N243 _NC604 _NC605 AO22X1
X309 N18 N119 Prod2[1][3][2] N12 N242 _NC606 _NC607 AO22X1
X310 N18 N118 Prod2[1][3][1] N12 N241 _NC608 _NC609 AO22X1
X311 N16 N117 Prod2[1][3][0] N12 N240 _NC610 _NC611 AO22X1
X312 N17 N104 Prod2[1][2][17] N13 N239 _NC612 _NC613 AO22X1
X313 N16 N103 Prod2[1][2][16] N13 N238 _NC614 _NC615 AO22X1
X314 N17 N102 Prod2[1][2][15] N13 N2370 _NC616 _NC617 AO22X1
X315 N16 N101 Prod2[1][2][14] N13 N2360 _NC618 _NC619 AO22X1
X316 N17 N100 Prod2[1][2][13] N13 N2350 _NC620 _NC621 AO22X1
X317 N16 N99 Prod2[1][2][12] N13 N2340 _NC622 _NC623 AO22X1
X318 N17 N98 Prod2[1][2][11] N13 N2330 _NC624 _NC625 AO22X1
X319 N17 N97 Prod2[1][2][10] N13 N2320 _NC626 _NC627 AO22X1
X320 N17 N96 Prod2[1][2][9] N13 N231 _NC628 _NC629 AO22X1
X321 N17 N95 Prod2[1][2][8] N13 N230 _NC630 _NC631 AO22X1
X322 N17 N94 Prod2[1][2][7] N13 N229 _NC632 _NC633 AO22X1
X323 N17 N93 Prod2[1][2][6] N13 N228 _NC634 _NC635 AO22X1
X324 N17 N86 Prod2[1][1][17] N14 N227 _NC636 _NC637 AO22X1
X325 N16 N85 Prod2[1][1][16] N14 N226 _NC638 _NC639 AO22X1
X326 N16 N84 Prod2[1][1][15] N14 N225 _NC640 _NC641 AO22X1
X327 N16 N83 Prod2[1][1][14] N14 N224 _NC642 _NC643 AO22X1
X328 N16 N82 Prod2[1][1][13] N14 N223 _NC644 _NC645 AO22X1
X329 N16 N81 Prod2[1][1][12] N14 N222 _NC646 _NC647 AO22X1
X330 N16 N80 Prod2[1][1][11] N14 N221 _NC648 _NC649 AO22X1
X331 N16 N79 Prod2[1][1][10] N14 N220 _NC650 _NC651 AO22X1
X332 N15 N78 Prod2[1][1][9] N14 N219 _NC652 _NC653 AO22X1
X333 N15 N77 Prod2[1][1][8] N14 N2180 _NC654 _NC655 AO22X1
X334 N15 N76 Prod2[1][1][7] N14 N2170 _NC656 _NC657 AO22X1
X335 N15 N75 Prod2[1][1][6] N14 N2160 _NC658 _NC659 AO22X1
X336 N15 N68 Prod2[1][0][23] N50 N2150 _NC660 _NC661 AO22X1
X337 N15 N67 Prod2[1][0][22] N50 N2140 _NC662 _NC663 AO22X1
X338 N15 N66 Prod2[1][0][21] N50 N2130 _NC664 _NC665 AO22X1
X339 N17 N65 Prod2[1][0][20] N50 N2120 _NC666 _NC667 AO22X1
X340 N16 N64 Prod2[1][0][19] N50 N2110 _NC668 _NC669 AO22X1
X341 N17 N63 Prod2[1][0][18] N50 N2100 _NC670 _NC671 AO22X1
X342 N16 N62 Prod2[1][0][17] N50 N2090 _NC672 _NC673 AO22X1
X343 N17 N61 Prod2[1][0][16] N50 N2080 _NC674 _NC675 AO22X1
X344 N16 N60 Prod2[1][0][15] N50 N2070 _NC676 _NC677 AO22X1
X345 N17 N59 Prod2[1][0][14] N12 N2060 _NC678 _NC679 AO22X1
X346 N16 N58 Prod2[1][0][13] N50 N2050 _NC680 _NC681 AO22X1
X347 N17 N57 Prod2[1][0][12] N12 N2040 _NC682 _NC683 AO22X1
X348 N128 N3570 Prod2[0][3][11] N3640 N2030 _NC684 _NC685 AO22X1
X349 N127 N3570 Prod2[0][3][10] N3640 N2020 _NC686 _NC687 AO22X1
X350 N126 N3570 Prod2[0][3][9] N3640 N2010 _NC688 _NC689 AO22X1
X351 N125 N3570 Prod2[0][3][8] N3640 N2000 _NC690 _NC691 AO22X1
X352 N124 N3570 Prod2[0][3][7] N3640 N199 _NC692 _NC693 AO22X1
X353 N123 N3580 Prod2[0][3][6] N3640 N198 _NC694 _NC695 AO22X1
X354 N122 N3580 Prod2[0][3][5] N3640 N197 _NC696 _NC697 AO22X1
X355 N121 N3580 Prod2[0][3][4] N3640 N196 _NC698 _NC699 AO22X1
X356 N120 N3580 Prod2[0][3][3] N3640 N195 _NC700 _NC701 AO22X1
X357 N119 N3580 Prod2[0][3][2] N3640 N194 _NC702 _NC703 AO22X1
X358 N118 N3580 Prod2[0][3][1] N3640 N1930 _NC704 _NC705 AO22X1
X359 N117 N3580 Prod2[0][3][0] N3640 N1920 _NC706 _NC707 AO22X1
X360 N104 N3590 Prod2[0][2][17] N3640 N1910 _NC708 _NC709 AO22X1
X361 N103 N3590 Prod2[0][2][16] N3640 N1900 _NC710 _NC711 AO22X1
X362 N102 N3590 Prod2[0][2][15] N3640 N1890 _NC712 _NC713 AO22X1
X363 N101 N3590 Prod2[0][2][14] N3640 N1880 _NC714 _NC715 AO22X1
X364 N100 N3590 Prod2[0][2][13] N4 N1870 _NC716 _NC717 AO22X1
X365 N99 N3590 Prod2[0][2][12] N3 N1860 _NC718 _NC719 AO22X1
X366 N98 N3590 Prod2[0][2][11] N4 N1850 _NC720 _NC721 AO22X1
X367 N97 N3600 Prod2[0][2][10] N3 N1840 _NC722 _NC723 AO22X1
X368 N96 N3600 Prod2[0][2][9] N4 N1830 _NC724 _NC725 AO22X1
X369 N95 N3600 Prod2[0][2][8] N3 N1820 _NC726 _NC727 AO22X1
X370 N94 N3600 Prod2[0][2][7] N4 N181 _NC728 _NC729 AO22X1
X371 N93 N3600 Prod2[0][2][6] N3 N180 _NC730 _NC731 AO22X1
X372 N86 N3600 Prod2[0][1][17] N4 N179 _NC732 _NC733 AO22X1
X373 N85 N3600 Prod2[0][1][16] N3 N178 _NC734 _NC735 AO22X1
X374 N84 N3610 Prod2[0][1][15] N4 N177 _NC736 _NC737 AO22X1
X375 N83 N3610 Prod2[0][1][14] N3 N176 _NC738 _NC739 AO22X1
X376 N82 N3610 Prod2[0][1][13] N4 N175 _NC740 _NC741 AO22X1
X377 N81 N3610 Prod2[0][1][12] N3 N174 _NC742 _NC743 AO22X1
X378 N80 N3610 Prod2[0][1][11] N4 N173 _NC744 _NC745 AO22X1
X379 N79 N3610 Prod2[0][1][10] N3 N172 _NC746 _NC747 AO22X1
X380 N78 N3610 Prod2[0][1][9] N4 N171 _NC748 _NC749 AO22X1
X381 N77 N3620 Prod2[0][1][8] N3 N170 _NC750 _NC751 AO22X1
X382 N76 N3620 Prod2[0][1][7] N4 N169 _NC752 _NC753 AO22X1
X383 N75 N3620 Prod2[0][1][6] N3 N168 _NC754 _NC755 AO22X1
X384 N68 N3620 Prod2[0][0][23] N4 N167 _NC756 _NC757 AO22X1
X385 N67 N3620 Prod2[0][0][22] N3 N166 _NC758 _NC759 AO22X1
X386 N66 N3620 Prod2[0][0][21] N4 N165 _NC760 _NC761 AO22X1
X387 N65 N3620 Prod2[0][0][20] N3 N164 _NC762 _NC763 AO22X1
X388 N64 N3630 Prod2[0][0][19] N4 N1630 _NC764 _NC765 AO22X1
X389 N63 N3630 Prod2[0][0][18] N3 N1620 _NC766 _NC767 AO22X1
X390 N62 N3630 Prod2[0][0][17] N4 N1610 _NC768 _NC769 AO22X1
X391 N61 N3630 Prod2[0][0][16] N3 N1600 _NC770 _NC771 AO22X1
X392 N60 N3630 Prod2[0][0][15] N4 N1590 _NC772 _NC773 AO22X1
X393 N59 N3630 Prod2[0][0][14] N3 N1580 _NC774 _NC775 AO22X1
X394 N58 N3630 Prod2[0][0][13] N4 N1570 _NC776 _NC777 AO22X1
X395 N57 N3590 Prod2[0][0][12] N3 N1560 _NC778 _NC779 AO22X1
X396 N20 N323 Sum[95] N19 N1550 _NC780 _NC781 AO22X1
X397 N21 N322 Sum[94] N19 N1540 _NC782 _NC783 AO22X1
X398 N20 N321 Sum[93] N19 N1530 _NC784 _NC785 AO22X1
X399 N21 N320 Sum[92] N19 N1520 _NC786 _NC787 AO22X1
X400 N20 N319 Sum[91] N19 N151 _NC788 _NC789 AO22X1
X401 N21 N318 Sum[90] N19 N150 _NC790 _NC791 AO22X1
X402 N21 N317 Sum[89] N19 N149 _NC792 _NC793 AO22X1
X403 N21 N316 Sum[88] N19 N148 _NC794 _NC795 AO22X1
X404 N21 N315 Sum[87] N19 N147 _NC796 _NC797 AO22X1
X405 N21 N314 Sum[86] N19 N146 _NC798 _NC799 AO22X1
X406 N21 N313 Sum[85] N19 N145 _NC800 _NC801 AO22X1
X407 N21 N312 Sum[84] N19 N1440 _NC802 _NC803 AO22X1
X408 N20 N311 Sum[83] N48 N143 _NC804 _NC805 AO22X1
X409 N20 N310 Sum[82] N48 N142 _NC806 _NC807 AO22X1
X410 N20 N309 Sum[81] N48 N141 _NC808 _NC809 AO22X1
X411 N20 N308 Sum[80] N48 N140 _NC810 _NC811 AO22X1
X412 N20 N307 Sum[79] N48 N139 _NC812 _NC813 AO22X1
X413 N20 N306 Sum[78] N48 N138 _NC814 _NC815 AO22X1
X414 N20 N305 Sum[77] N48 N137 _NC816 _NC817 AO22X1
X415 N21 N304 Sum[76] N48 N136 _NC818 _NC819 AO22X1
X416 N20 N303 Sum[75] N48 N135 _NC820 _NC821 AO22X1
X417 N21 N302 Sum[74] N48 N134 _NC822 _NC823 AO22X1
X418 N20 N301 Sum[73] N48 N133 _NC824 _NC825 AO22X1
X419 N21 N300 Sum[72] N48 N1320 _NC826 _NC827 AO22X1
X420 N22 N323 Sum[71] N28 N131 _NC828 _NC829 AO22X1
X421 N22 N322 Sum[70] N28 N130 _NC830 _NC831 AO22X1
X422 N22 N321 Sum[69] N28 N129 _NC832 _NC833 AO22X1
X423 N22 N320 Sum[68] N28 N1280 _NC834 _NC835 AO22X1
X424 N22 N319 Sum[67] N28 N1270 _NC836 _NC837 AO22X1
X425 N23 N318 Sum[66] N28 N1260 _NC838 _NC839 AO22X1
X426 N23 N317 Sum[65] N28 N1250 _NC840 _NC841 AO22X1
X427 N23 N316 Sum[64] N28 N1240 _NC842 _NC843 AO22X1
X428 N23 N315 Sum[63] N28 N1230 _NC844 _NC845 AO22X1
X429 N23 N314 Sum[62] N28 N1220 _NC846 _NC847 AO22X1
X430 N23 N313 Sum[61] N28 N1210 _NC848 _NC849 AO22X1
X431 N23 N312 Sum[60] N28 N1200 _NC850 _NC851 AO22X1
X432 N24 N311 Sum[59] N27 N1190 _NC852 _NC853 AO22X1
X433 N24 N310 Sum[58] N27 N1180 _NC854 _NC855 AO22X1
X434 N24 N309 Sum[57] N27 N1170 _NC856 _NC857 AO22X1
X435 N24 N308 Sum[56] N27 N1160 _NC858 _NC859 AO22X1
X436 N24 N307 Sum[55] N27 N1150 _NC860 _NC861 AO22X1
X437 N24 N306 Sum[54] N27 N1140 _NC862 _NC863 AO22X1
X438 N24 N305 Sum[53] N27 N1130 _NC864 _NC865 AO22X1
X439 N2611 N304 Sum[52] N27 N1120 _NC866 _NC867 AO22X1
X440 N2611 N303 Sum[51] N27 N1110 _NC868 _NC869 AO22X1
X441 N2611 N302 Sum[50] N27 N1100 _NC870 _NC871 AO22X1
X442 N2611 N301 Sum[49] N27 N1090 _NC872 _NC873 AO22X1
X443 N2611 N300 Sum[48] N27 N1080 _NC874 _NC875 AO22X1
X444 N3740 N3700 N26 N44 _NC876 _NC877 NAND3X0
X445 N30 N323 Sum[47] N29 N1070 _NC878 _NC879 AO22X1
X446 N31 N322 Sum[46] N29 N1060 _NC880 _NC881 AO22X1
X447 N30 N321 Sum[45] N29 N1050 _NC882 _NC883 AO22X1
X448 N31 N320 Sum[44] N29 N1040 _NC884 _NC885 AO22X1
X449 N30 N319 Sum[43] N29 N1030 _NC886 _NC887 AO22X1
X450 N31 N318 Sum[42] N29 N1020 _NC888 _NC889 AO22X1
X451 N31 N317 Sum[41] N29 N1010 _NC890 _NC891 AO22X1
X452 N31 N316 Sum[40] N29 N1000 _NC892 _NC893 AO22X1
X453 N31 N315 Sum[39] N29 N990 _NC894 _NC895 AO22X1
X454 N31 N314 Sum[38] N29 N980 _NC896 _NC897 AO22X1
X455 N31 N313 Sum[37] N29 N970 _NC898 _NC899 AO22X1
X456 N31 N312 Sum[36] N29 N960 _NC900 _NC901 AO22X1
X457 N30 N311 Sum[35] N44 N950 _NC902 _NC903 AO22X1
X458 N30 N310 Sum[34] N44 N940 _NC904 _NC905 AO22X1
X459 N30 N309 Sum[33] N44 N930 _NC906 _NC907 AO22X1
X460 N30 N308 Sum[32] N44 N920 _NC908 _NC909 AO22X1
X461 N30 N307 Sum[31] N44 N910 _NC910 _NC911 AO22X1
X462 N30 N306 Sum[30] N44 N900 _NC912 _NC913 AO22X1
X463 N30 N305 Sum[29] N44 N890 _NC914 _NC915 AO22X1
X464 N31 N304 Sum[28] N44 N880 _NC916 _NC917 AO22X1
X465 N30 N303 Sum[27] N44 N870 _NC918 _NC919 AO22X1
X466 N31 N302 Sum[26] N44 N860 _NC920 _NC921 AO22X1
X467 N30 N301 Sum[25] N44 N850 _NC922 _NC923 AO22X1
X468 N31 N300 Sum[24] N44 N840 _NC924 _NC925 AO22X1
X469 N323 N33 Sum[23] N32 N830 _NC926 _NC927 AO22X1
X470 N322 N3411 Sum[22] N32 N820 _NC928 _NC929 AO22X1
X471 N321 N33 Sum[21] N32 N810 _NC930 _NC931 AO22X1
X472 N320 N3411 Sum[20] N32 N800 _NC932 _NC933 AO22X1
X473 N319 N33 Sum[19] N32 N790 _NC934 _NC935 AO22X1
X474 N318 N3411 Sum[18] N32 N780 _NC936 _NC937 AO22X1
X475 N317 N3411 Sum[17] N32 N770 _NC938 _NC939 AO22X1
X476 N316 N3411 Sum[16] N32 N760 _NC940 _NC941 AO22X1
X477 N315 N3411 Sum[15] N32 N750 _NC942 _NC943 AO22X1
X478 N314 N3411 Sum[14] N32 N740 _NC944 _NC945 AO22X1
X479 N313 N3411 Sum[13] N32 N730 _NC946 _NC947 AO22X1
X480 N312 N3411 Sum[12] N32 N720 _NC948 _NC949 AO22X1
X481 N311 N33 Sum[11] N42 N710 _NC950 _NC951 AO22X1
X482 N310 N33 Sum[10] N42 N700 _NC952 _NC953 AO22X1
X483 N309 N33 Sum[9] N42 N690 _NC954 _NC955 AO22X1
X484 N308 N33 Sum[8] N42 N680 _NC956 _NC957 AO22X1
X485 N307 N33 Sum[7] N42 N670 _NC958 _NC959 AO22X1
X486 N306 N33 Sum[6] N42 N660 _NC960 _NC961 AO22X1
X487 N305 N33 Sum[5] N42 N650 _NC962 _NC963 AO22X1
X488 N304 N3411 Sum[4] N42 N640 _NC964 _NC965 AO22X1
X489 N303 N33 Sum[3] N42 N630 _NC966 _NC967 AO22X1
X490 N302 N3411 Sum[2] N42 N620 _NC968 _NC969 AO22X1
X491 N301 N33 Sum[1] N42 N610 _NC970 _NC971 AO22X1
X492 N300 N3411 Sum[0] N42 N600 _NC972 _NC973 AO22X1
X493 S_signb_i S_signa_i Sign_o _NC974 _NC975 XOR2X1
X494 Clk_i N600 Sum[0] _NC976 _NC977 _NC978 DFFX1
X495 Clk_i N610 Sum[1] _NC979 _NC980 _NC981 DFFX1
X496 Clk_i N620 Sum[2] _NC982 _NC983 _NC984 DFFX1
X497 Clk_i N630 Sum[3] _NC985 _NC986 _NC987 DFFX1
X498 Clk_i N640 Sum[4] _NC988 _NC989 _NC990 DFFX1
X499 Clk_i N650 Sum[5] _NC991 _NC992 _NC993 DFFX1
X500 Clk_i N660 Sum[6] _NC994 _NC995 _NC996 DFFX1
X501 Clk_i N670 Sum[7] _NC997 _NC998 _NC999 DFFX1
X502 Clk_i N680 Sum[8] _NC1000 _NC1001 _NC1002 DFFX1
X503 Clk_i N690 Sum[9] _NC1003 _NC1004 _NC1005 DFFX1
X504 Clk_i N700 Sum[10] _NC1006 _NC1007 _NC1008 DFFX1
X505 Clk_i N710 Sum[11] _NC1009 _NC1010 _NC1011 DFFX1
X506 Clk_i N720 Sum[12] _NC1012 _NC1013 _NC1014 DFFX1
X507 Clk_i N730 Sum[13] _NC1015 _NC1016 _NC1017 DFFX1
X508 Clk_i N740 Sum[14] _NC1018 _NC1019 _NC1020 DFFX1
X509 Clk_i N750 Sum[15] _NC1021 _NC1022 _NC1023 DFFX1
X510 Clk_i N760 Sum[16] _NC1024 _NC1025 _NC1026 DFFX1
X511 Clk_i N770 Sum[17] _NC1027 _NC1028 _NC1029 DFFX1
X512 Clk_i N780 Sum[18] _NC1030 _NC1031 _NC1032 DFFX1
X513 Clk_i N790 Sum[19] _NC1033 _NC1034 _NC1035 DFFX1
X514 Clk_i N800 Sum[20] _NC1036 _NC1037 _NC1038 DFFX1
X515 Clk_i N810 Sum[21] _NC1039 _NC1040 _NC1041 DFFX1
X516 Clk_i N820 Sum[22] _NC1042 _NC1043 _NC1044 DFFX1
X517 Clk_i N830 Sum[23] _NC1045 _NC1046 _NC1047 DFFX1
X518 Clk_i N840 Sum[24] _NC1048 _NC1049 _NC1050 DFFX1
X519 Clk_i N850 Sum[25] _NC1051 _NC1052 _NC1053 DFFX1
X520 Clk_i N860 Sum[26] _NC1054 _NC1055 _NC1056 DFFX1
X521 Clk_i N870 Sum[27] _NC1057 _NC1058 _NC1059 DFFX1
X522 Clk_i N880 Sum[28] _NC1060 _NC1061 _NC1062 DFFX1
X523 Clk_i N890 Sum[29] _NC1063 _NC1064 _NC1065 DFFX1
X524 Clk_i N900 Sum[30] _NC1066 _NC1067 _NC1068 DFFX1
X525 Clk_i N910 Sum[31] _NC1069 _NC1070 _NC1071 DFFX1
X526 Clk_i N920 Sum[32] _NC1072 _NC1073 _NC1074 DFFX1
X527 Clk_i N930 Sum[33] _NC1075 _NC1076 _NC1077 DFFX1
X528 Clk_i N940 Sum[34] _NC1078 _NC1079 _NC1080 DFFX1
X529 Clk_i N950 Sum[35] _NC1081 _NC1082 _NC1083 DFFX1
X530 Clk_i N960 Sum[36] _NC1084 _NC1085 _NC1086 DFFX1
X531 Clk_i N970 Sum[37] _NC1087 _NC1088 _NC1089 DFFX1
X532 Clk_i N980 Sum[38] _NC1090 _NC1091 _NC1092 DFFX1
X533 Clk_i N990 Sum[39] _NC1093 _NC1094 _NC1095 DFFX1
X534 Clk_i N1000 Sum[40] _NC1096 _NC1097 _NC1098 DFFX1
X535 Clk_i N1010 Sum[41] _NC1099 _NC1100 _NC1101 DFFX1
X536 Clk_i N1020 Sum[42] _NC1102 _NC1103 _NC1104 DFFX1
X537 Clk_i N1030 Sum[43] _NC1105 _NC1106 _NC1107 DFFX1
X538 Clk_i N1040 Sum[44] _NC1108 _NC1109 _NC1110 DFFX1
X539 Clk_i N1050 Sum[45] _NC1111 _NC1112 _NC1113 DFFX1
X540 Clk_i N1060 Sum[46] _NC1114 _NC1115 _NC1116 DFFX1
X541 Clk_i N1070 Sum[47] _NC1117 _NC1118 _NC1119 DFFX1
X542 Clk_i N1080 Sum[48] _NC1120 _NC1121 _NC1122 DFFX1
X543 Clk_i N1090 Sum[49] _NC1123 _NC1124 _NC1125 DFFX1
X544 Clk_i N1100 Sum[50] _NC1126 _NC1127 _NC1128 DFFX1
X545 Clk_i N1110 Sum[51] _NC1129 _NC1130 _NC1131 DFFX1
X546 Clk_i N1120 Sum[52] _NC1132 _NC1133 _NC1134 DFFX1
X547 Clk_i N1130 Sum[53] _NC1135 _NC1136 _NC1137 DFFX1
X548 Clk_i N1140 Sum[54] _NC1138 _NC1139 _NC1140 DFFX1
X549 Clk_i N1150 Sum[55] _NC1141 _NC1142 _NC1143 DFFX1
X550 Clk_i N1160 Sum[56] _NC1144 _NC1145 _NC1146 DFFX1
X551 Clk_i N1170 Sum[57] _NC1147 _NC1148 _NC1149 DFFX1
X552 Clk_i N1180 Sum[58] _NC1150 _NC1151 _NC1152 DFFX1
X553 Clk_i N1190 Sum[59] _NC1153 _NC1154 _NC1155 DFFX1
X554 Clk_i N1200 Sum[60] _NC1156 _NC1157 _NC1158 DFFX1
X555 Clk_i N1210 Sum[61] _NC1159 _NC1160 _NC1161 DFFX1
X556 Clk_i N1220 Sum[62] _NC1162 _NC1163 _NC1164 DFFX1
X557 Clk_i N1230 Sum[63] _NC1165 _NC1166 _NC1167 DFFX1
X558 Clk_i N1240 Sum[64] _NC1168 _NC1169 _NC1170 DFFX1
X559 Clk_i N1250 Sum[65] _NC1171 _NC1172 _NC1173 DFFX1
X560 Clk_i N1260 Sum[66] _NC1174 _NC1175 _NC1176 DFFX1
X561 Clk_i N1270 Sum[67] _NC1177 _NC1178 _NC1179 DFFX1
X562 Clk_i N1280 Sum[68] _NC1180 _NC1181 _NC1182 DFFX1
X563 Clk_i N129 Sum[69] _NC1183 _NC1184 _NC1185 DFFX1
X564 Clk_i N130 Sum[70] _NC1186 _NC1187 _NC1188 DFFX1
X565 Clk_i N131 Sum[71] _NC1189 _NC1190 _NC1191 DFFX1
X566 Clk_i N1320 Sum[72] _NC1192 _NC1193 _NC1194 DFFX1
X567 Clk_i N133 Sum[73] _NC1195 _NC1196 _NC1197 DFFX1
X568 Clk_i N134 Sum[74] _NC1198 _NC1199 _NC1200 DFFX1
X569 Clk_i N135 Sum[75] _NC1201 _NC1202 _NC1203 DFFX1
X570 Clk_i N136 Sum[76] _NC1204 _NC1205 _NC1206 DFFX1
X571 Clk_i N137 Sum[77] _NC1207 _NC1208 _NC1209 DFFX1
X572 Clk_i N138 Sum[78] _NC1210 _NC1211 _NC1212 DFFX1
X573 Clk_i N139 Sum[79] _NC1213 _NC1214 _NC1215 DFFX1
X574 Clk_i N140 Sum[80] _NC1216 _NC1217 _NC1218 DFFX1
X575 Clk_i N141 Sum[81] _NC1219 _NC1220 _NC1221 DFFX1
X576 Clk_i N142 Sum[82] _NC1222 _NC1223 _NC1224 DFFX1
X577 Clk_i N143 Sum[83] _NC1225 _NC1226 _NC1227 DFFX1
X578 Clk_i N1440 Sum[84] _NC1228 _NC1229 _NC1230 DFFX1
X579 Clk_i N145 Sum[85] _NC1231 _NC1232 _NC1233 DFFX1
X580 Clk_i N146 Sum[86] _NC1234 _NC1235 _NC1236 DFFX1
X581 Clk_i N147 Sum[87] _NC1237 _NC1238 _NC1239 DFFX1
X582 Clk_i N148 Sum[88] _NC1240 _NC1241 _NC1242 DFFX1
X583 Clk_i N149 Sum[89] _NC1243 _NC1244 _NC1245 DFFX1
X584 Clk_i N150 Sum[90] _NC1246 _NC1247 _NC1248 DFFX1
X585 Clk_i N151 Sum[91] _NC1249 _NC1250 _NC1251 DFFX1
X586 Clk_i N1520 Sum[92] _NC1252 _NC1253 _NC1254 DFFX1
X587 Clk_i N1530 Sum[93] _NC1255 _NC1256 _NC1257 DFFX1
X588 Clk_i N1540 Sum[94] _NC1258 _NC1259 _NC1260 DFFX1
X589 Clk_i N1550 Sum[95] _NC1261 _NC1262 _NC1263 DFFX1
X590 Clk_i N1560 Prod2[0][0][12] _NC1264 _NC1265 _NC1266 DFFX1
X591 Clk_i N1570 Prod2[0][0][13] _NC1267 _NC1268 _NC1269 DFFX1
X592 Clk_i N1580 Prod2[0][0][14] _NC1270 _NC1271 _NC1272 DFFX1
X593 Clk_i N1590 Prod2[0][0][15] _NC1273 _NC1274 _NC1275 DFFX1
X594 Clk_i N1600 Prod2[0][0][16] _NC1276 _NC1277 _NC1278 DFFX1
X595 Clk_i N1610 Prod2[0][0][17] _NC1279 _NC1280 _NC1281 DFFX1
X596 Clk_i N1620 Prod2[0][0][18] _NC1282 _NC1283 _NC1284 DFFX1
X597 Clk_i N1630 Prod2[0][0][19] _NC1285 _NC1286 _NC1287 DFFX1
X598 Clk_i N164 Prod2[0][0][20] _NC1288 _NC1289 _NC1290 DFFX1
X599 Clk_i N165 Prod2[0][0][21] _NC1291 _NC1292 _NC1293 DFFX1
X600 Clk_i N166 Prod2[0][0][22] _NC1294 _NC1295 _NC1296 DFFX1
X601 Clk_i N167 Prod2[0][0][23] _NC1297 _NC1298 _NC1299 DFFX1
X602 Clk_i N168 Prod2[0][1][6] _NC1300 _NC1301 _NC1302 DFFX1
X603 Clk_i N169 Prod2[0][1][7] _NC1303 _NC1304 _NC1305 DFFX1
X604 Clk_i N170 Prod2[0][1][8] _NC1306 _NC1307 _NC1308 DFFX1
X605 Clk_i N171 Prod2[0][1][9] _NC1309 _NC1310 _NC1311 DFFX1
X606 Clk_i N172 Prod2[0][1][10] _NC1312 _NC1313 _NC1314 DFFX1
X607 Clk_i N173 Prod2[0][1][11] _NC1315 _NC1316 _NC1317 DFFX1
X608 Clk_i N174 Prod2[0][1][12] _NC1318 _NC1319 _NC1320 DFFX1
X609 Clk_i N175 Prod2[0][1][13] _NC1321 _NC1322 _NC1323 DFFX1
X610 Clk_i N176 Prod2[0][1][14] _NC1324 _NC1325 _NC1326 DFFX1
X611 Clk_i N177 Prod2[0][1][15] _NC1327 _NC1328 _NC1329 DFFX1
X612 Clk_i N178 Prod2[0][1][16] _NC1330 _NC1331 _NC1332 DFFX1
X613 Clk_i N179 Prod2[0][1][17] _NC1333 _NC1334 _NC1335 DFFX1
X614 Clk_i N180 Prod2[0][2][6] _NC1336 _NC1337 _NC1338 DFFX1
X615 Clk_i N181 Prod2[0][2][7] _NC1339 _NC1340 _NC1341 DFFX1
X616 Clk_i N1820 Prod2[0][2][8] _NC1342 _NC1343 _NC1344 DFFX1
X617 Clk_i N1830 Prod2[0][2][9] _NC1345 _NC1346 _NC1347 DFFX1
X618 Clk_i N1840 Prod2[0][2][10] _NC1348 _NC1349 _NC1350 DFFX1
X619 Clk_i N1850 Prod2[0][2][11] _NC1351 _NC1352 _NC1353 DFFX1
X620 Clk_i N1860 Prod2[0][2][12] _NC1354 _NC1355 _NC1356 DFFX1
X621 Clk_i N1870 Prod2[0][2][13] _NC1357 _NC1358 _NC1359 DFFX1
X622 Clk_i N1880 Prod2[0][2][14] _NC1360 _NC1361 _NC1362 DFFX1
X623 Clk_i N1890 Prod2[0][2][15] _NC1363 _NC1364 _NC1365 DFFX1
X624 Clk_i N1900 Prod2[0][2][16] _NC1366 _NC1367 _NC1368 DFFX1
X625 Clk_i N1910 Prod2[0][2][17] _NC1369 _NC1370 _NC1371 DFFX1
X626 Clk_i N1920 Prod2[0][3][0] _NC1372 _NC1373 _NC1374 DFFX1
X627 Clk_i N1930 Prod2[0][3][1] _NC1375 _NC1376 _NC1377 DFFX1
X628 Clk_i N194 Prod2[0][3][2] _NC1378 _NC1379 _NC1380 DFFX1
X629 Clk_i N195 Prod2[0][3][3] _NC1381 _NC1382 _NC1383 DFFX1
X630 Clk_i N196 Prod2[0][3][4] _NC1384 _NC1385 _NC1386 DFFX1
X631 Clk_i N197 Prod2[0][3][5] _NC1387 _NC1388 _NC1389 DFFX1
X632 Clk_i N198 Prod2[0][3][6] _NC1390 _NC1391 _NC1392 DFFX1
X633 Clk_i N199 Prod2[0][3][7] _NC1393 _NC1394 _NC1395 DFFX1
X634 Clk_i N2000 Prod2[0][3][8] _NC1396 _NC1397 _NC1398 DFFX1
X635 Clk_i N2010 Prod2[0][3][9] _NC1399 _NC1400 _NC1401 DFFX1
X636 Clk_i N2020 Prod2[0][3][10] _NC1402 _NC1403 _NC1404 DFFX1
X637 Clk_i N2030 Prod2[0][3][11] _NC1405 _NC1406 _NC1407 DFFX1
X638 Clk_i N2040 Prod2[1][0][12] _NC1408 _NC1409 _NC1410 DFFX1
X639 Clk_i N2050 Prod2[1][0][13] _NC1411 _NC1412 _NC1413 DFFX1
X640 Clk_i N2060 Prod2[1][0][14] _NC1414 _NC1415 _NC1416 DFFX1
X641 Clk_i N2070 Prod2[1][0][15] _NC1417 _NC1418 _NC1419 DFFX1
X642 Clk_i N2080 Prod2[1][0][16] _NC1420 _NC1421 _NC1422 DFFX1
X643 Clk_i N2090 Prod2[1][0][17] _NC1423 _NC1424 _NC1425 DFFX1
X644 Clk_i N2100 Prod2[1][0][18] _NC1426 _NC1427 _NC1428 DFFX1
X645 Clk_i N2110 Prod2[1][0][19] _NC1429 _NC1430 _NC1431 DFFX1
X646 Clk_i N2120 Prod2[1][0][20] _NC1432 _NC1433 _NC1434 DFFX1
X647 Clk_i N2130 Prod2[1][0][21] _NC1435 _NC1436 _NC1437 DFFX1
X648 Clk_i N2140 Prod2[1][0][22] _NC1438 _NC1439 _NC1440 DFFX1
X649 Clk_i N2150 Prod2[1][0][23] _NC1441 _NC1442 _NC1443 DFFX1
X650 Clk_i N2160 Prod2[1][1][6] _NC1444 _NC1445 _NC1446 DFFX1
X651 Clk_i N2170 Prod2[1][1][7] _NC1447 _NC1448 _NC1449 DFFX1
X652 Clk_i N2180 Prod2[1][1][8] _NC1450 _NC1451 _NC1452 DFFX1
X653 Clk_i N219 Prod2[1][1][9] _NC1453 _NC1454 _NC1455 DFFX1
X654 Clk_i N220 Prod2[1][1][10] _NC1456 _NC1457 _NC1458 DFFX1
X655 Clk_i N221 Prod2[1][1][11] _NC1459 _NC1460 _NC1461 DFFX1
X656 Clk_i N222 Prod2[1][1][12] _NC1462 _NC1463 _NC1464 DFFX1
X657 Clk_i N223 Prod2[1][1][13] _NC1465 _NC1466 _NC1467 DFFX1
X658 Clk_i N224 Prod2[1][1][14] _NC1468 _NC1469 _NC1470 DFFX1
X659 Clk_i N225 Prod2[1][1][15] _NC1471 _NC1472 _NC1473 DFFX1
X660 Clk_i N226 Prod2[1][1][16] _NC1474 _NC1475 _NC1476 DFFX1
X661 Clk_i N227 Prod2[1][1][17] _NC1477 _NC1478 _NC1479 DFFX1
X662 Clk_i N228 Prod2[1][2][6] _NC1480 _NC1481 _NC1482 DFFX1
X663 Clk_i N229 Prod2[1][2][7] _NC1483 _NC1484 _NC1485 DFFX1
X664 Clk_i N230 Prod2[1][2][8] _NC1486 _NC1487 _NC1488 DFFX1
X665 Clk_i N231 Prod2[1][2][9] _NC1489 _NC1490 _NC1491 DFFX1
X666 Clk_i N2320 Prod2[1][2][10] _NC1492 _NC1493 _NC1494 DFFX1
X667 Clk_i N2330 Prod2[1][2][11] _NC1495 _NC1496 _NC1497 DFFX1
X668 Clk_i N2340 Prod2[1][2][12] _NC1498 _NC1499 _NC1500 DFFX1
X669 Clk_i N2350 Prod2[1][2][13] _NC1501 _NC1502 _NC1503 DFFX1
X670 Clk_i N2360 Prod2[1][2][14] _NC1504 _NC1505 _NC1506 DFFX1
X671 Clk_i N2370 Prod2[1][2][15] _NC1507 _NC1508 _NC1509 DFFX1
X672 Clk_i N238 Prod2[1][2][16] _NC1510 _NC1511 _NC1512 DFFX1
X673 Clk_i N239 Prod2[1][2][17] _NC1513 _NC1514 _NC1515 DFFX1
X674 Clk_i N240 Prod2[1][3][0] _NC1516 _NC1517 _NC1518 DFFX1
X675 Clk_i N241 Prod2[1][3][1] _NC1519 _NC1520 _NC1521 DFFX1
X676 Clk_i N242 Prod2[1][3][2] _NC1522 _NC1523 _NC1524 DFFX1
X677 Clk_i N243 Prod2[1][3][3] _NC1525 _NC1526 _NC1527 DFFX1
X678 Clk_i N244 Prod2[1][3][4] _NC1528 _NC1529 _NC1530 DFFX1
X679 Clk_i N245 Prod2[1][3][5] _NC1531 _NC1532 _NC1533 DFFX1
X680 Clk_i N246 Prod2[1][3][6] _NC1534 _NC1535 _NC1536 DFFX1
X681 Clk_i N247 Prod2[1][3][7] _NC1537 _NC1538 _NC1539 DFFX1
X682 Clk_i N248 Prod2[1][3][8] _NC1540 _NC1541 _NC1542 DFFX1
X683 Clk_i N249 Prod2[1][3][9] _NC1543 _NC1544 _NC1545 DFFX1
X684 Clk_i N2500 Prod2[1][3][10] _NC1546 _NC1547 _NC1548 DFFX1
X685 Clk_i N251 Prod2[1][3][11] _NC1549 _NC1550 _NC1551 DFFX1
X686 Clk_i N252 Prod2[2][0][12] _NC1552 _NC1553 _NC1554 DFFX1
X687 Clk_i N253 Prod2[2][0][13] _NC1555 _NC1556 _NC1557 DFFX1
X688 Clk_i N254 Prod2[2][0][14] _NC1558 _NC1559 _NC1560 DFFX1
X689 Clk_i N255 Prod2[2][0][15] _NC1561 _NC1562 _NC1563 DFFX1
X690 Clk_i N2560 Prod2[2][0][16] _NC1564 _NC1565 _NC1566 DFFX1
X691 Clk_i N2570 Prod2[2][0][17] _NC1567 _NC1568 _NC1569 DFFX1
X692 Clk_i N2580 Prod2[2][0][18] _NC1570 _NC1571 _NC1572 DFFX1
X693 Clk_i N2590 Prod2[2][0][19] _NC1573 _NC1574 _NC1575 DFFX1
X694 Clk_i N2600 Prod2[2][0][20] _NC1576 _NC1577 _NC1578 DFFX1
X695 Clk_i N2610 Prod2[2][0][21] _NC1579 _NC1580 _NC1581 DFFX1
X696 Clk_i N2620 Prod2[2][0][22] _NC1582 _NC1583 _NC1584 DFFX1
X697 Clk_i N2630 Prod2[2][0][23] _NC1585 _NC1586 _NC1587 DFFX1
X698 Clk_i N2640 Prod2[2][1][6] _NC1588 _NC1589 _NC1590 DFFX1
X699 Clk_i N2650 Prod2[2][1][7] _NC1591 _NC1592 _NC1593 DFFX1
X700 Clk_i N2660 Prod2[2][1][8] _NC1594 _NC1595 _NC1596 DFFX1
X701 Clk_i N2670 Prod2[2][1][9] _NC1597 _NC1598 _NC1599 DFFX1
X702 Clk_i N2680 Prod2[2][1][10] _NC1600 _NC1601 _NC1602 DFFX1
X703 Clk_i N2690 Prod2[2][1][11] _NC1603 _NC1604 _NC1605 DFFX1
X704 Clk_i N2700 Prod2[2][1][12] _NC1606 _NC1607 _NC1608 DFFX1
X705 Clk_i N2710 Prod2[2][1][13] _NC1609 _NC1610 _NC1611 DFFX1
X706 Clk_i N2720 Prod2[2][1][14] _NC1612 _NC1613 _NC1614 DFFX1
X707 Clk_i N2730 Prod2[2][1][15] _NC1615 _NC1616 _NC1617 DFFX1
X708 Clk_i N274 Prod2[2][1][16] _NC1618 _NC1619 _NC1620 DFFX1
X709 Clk_i N275 Prod2[2][1][17] _NC1621 _NC1622 _NC1623 DFFX1
X710 Clk_i N276 Prod2[2][2][6] _NC1624 _NC1625 _NC1626 DFFX1
X711 Clk_i N277 Prod2[2][2][7] _NC1627 _NC1628 _NC1629 DFFX1
X712 Clk_i N278 Prod2[2][2][8] _NC1630 _NC1631 _NC1632 DFFX1
X713 Clk_i N279 Prod2[2][2][9] _NC1633 _NC1634 _NC1635 DFFX1
X714 Clk_i N280 Prod2[2][2][10] _NC1636 _NC1637 _NC1638 DFFX1
X715 Clk_i N281 Prod2[2][2][11] _NC1639 _NC1640 _NC1641 DFFX1
X716 Clk_i N282 Prod2[2][2][12] _NC1642 _NC1643 _NC1644 DFFX1
X717 Clk_i N283 Prod2[2][2][13] _NC1645 _NC1646 _NC1647 DFFX1
X718 Clk_i N284 Prod2[2][2][14] _NC1648 _NC1649 _NC1650 DFFX1
X719 Clk_i N285 Prod2[2][2][15] _NC1651 _NC1652 _NC1653 DFFX1
X720 Clk_i N286 Prod2[2][2][16] _NC1654 _NC1655 _NC1656 DFFX1
X721 Clk_i N287 Prod2[2][2][17] _NC1657 _NC1658 _NC1659 DFFX1
X722 Clk_i N2880 Prod2[2][3][0] _NC1660 _NC1661 _NC1662 DFFX1
X723 Clk_i N2890 Prod2[2][3][1] _NC1663 _NC1664 _NC1665 DFFX1
X724 Clk_i N2900 Prod2[2][3][2] _NC1666 _NC1667 _NC1668 DFFX1
X725 Clk_i N2910 Prod2[2][3][3] _NC1669 _NC1670 _NC1671 DFFX1
X726 Clk_i N2920 Prod2[2][3][4] _NC1672 _NC1673 _NC1674 DFFX1
X727 Clk_i N2930 Prod2[2][3][5] _NC1675 _NC1676 _NC1677 DFFX1
X728 Clk_i N294 Prod2[2][3][6] _NC1678 _NC1679 _NC1680 DFFX1
X729 Clk_i N295 Prod2[2][3][7] _NC1681 _NC1682 _NC1683 DFFX1
X730 Clk_i N296 Prod2[2][3][8] _NC1684 _NC1685 _NC1686 DFFX1
X731 Clk_i N297 Prod2[2][3][9] _NC1687 _NC1688 _NC1689 DFFX1
X732 Clk_i N298 Prod2[2][3][10] _NC1690 _NC1691 _NC1692 DFFX1
X733 Clk_i N299 Prod2[2][3][11] _NC1693 _NC1694 _NC1695 DFFX1
X734 Clk_i N3000 Prod2[3][0][12] _NC1696 _NC1697 _NC1698 DFFX1
X735 Clk_i N3010 Prod2[3][0][13] _NC1699 _NC1700 _NC1701 DFFX1
X736 Clk_i N3020 Prod2[3][0][14] _NC1702 _NC1703 _NC1704 DFFX1
X737 Clk_i N3030 Prod2[3][0][15] _NC1705 _NC1706 _NC1707 DFFX1
X738 Clk_i N3040 Prod2[3][0][16] _NC1708 _NC1709 _NC1710 DFFX1
X739 Clk_i N3050 Prod2[3][0][17] _NC1711 _NC1712 _NC1713 DFFX1
X740 Clk_i N3060 Prod2[3][0][18] _NC1714 _NC1715 _NC1716 DFFX1
X741 Clk_i N3070 Prod2[3][0][19] _NC1717 _NC1718 _NC1719 DFFX1
X742 Clk_i N3080 Prod2[3][0][20] _NC1720 _NC1721 _NC1722 DFFX1
X743 Clk_i N3090 Prod2[3][0][21] _NC1723 _NC1724 _NC1725 DFFX1
X744 Clk_i N3100 Prod2[3][0][22] _NC1726 _NC1727 _NC1728 DFFX1
X745 Clk_i N3110 Prod2[3][0][23] _NC1729 _NC1730 _NC1731 DFFX1
X746 Clk_i N3120 Prod2[3][1][6] _NC1732 _NC1733 _NC1734 DFFX1
X747 Clk_i N3130 Prod2[3][1][7] _NC1735 _NC1736 _NC1737 DFFX1
X748 Clk_i N3140 Prod2[3][1][8] _NC1738 _NC1739 _NC1740 DFFX1
X749 Clk_i N3150 Prod2[3][1][9] _NC1741 _NC1742 _NC1743 DFFX1
X750 Clk_i N3160 Prod2[3][1][10] _NC1744 _NC1745 _NC1746 DFFX1
X751 Clk_i N3170 Prod2[3][1][11] _NC1747 _NC1748 _NC1749 DFFX1
X752 Clk_i N3180 Prod2[3][1][12] _NC1750 _NC1751 _NC1752 DFFX1
X753 Clk_i N3190 Prod2[3][1][13] _NC1753 _NC1754 _NC1755 DFFX1
X754 Clk_i N3200 Prod2[3][1][14] _NC1756 _NC1757 _NC1758 DFFX1
X755 Clk_i N3210 Prod2[3][1][15] _NC1759 _NC1760 _NC1761 DFFX1
X756 Clk_i N3220 Prod2[3][1][16] _NC1762 _NC1763 _NC1764 DFFX1
X757 Clk_i N3230 Prod2[3][1][17] _NC1765 _NC1766 _NC1767 DFFX1
X758 Clk_i N324 Prod2[3][2][6] _NC1768 _NC1769 _NC1770 DFFX1
X759 Clk_i N325 Prod2[3][2][7] _NC1771 _NC1772 _NC1773 DFFX1
X760 Clk_i N326 Prod2[3][2][8] _NC1774 _NC1775 _NC1776 DFFX1
X761 Clk_i N327 Prod2[3][2][9] _NC1777 _NC1778 _NC1779 DFFX1
X762 Clk_i N3280 Prod2[3][2][10] _NC1780 _NC1781 _NC1782 DFFX1
X763 Clk_i N3290 Prod2[3][2][11] _NC1783 _NC1784 _NC1785 DFFX1
X764 Clk_i N3300 Prod2[3][2][12] _NC1786 _NC1787 _NC1788 DFFX1
X765 Clk_i N3310 Prod2[3][2][13] _NC1789 _NC1790 _NC1791 DFFX1
X766 Clk_i N3320 Prod2[3][2][14] _NC1792 _NC1793 _NC1794 DFFX1
X767 Clk_i N3330 Prod2[3][2][15] _NC1795 _NC1796 _NC1797 DFFX1
X768 Clk_i N3340 Prod2[3][2][16] _NC1798 _NC1799 _NC1800 DFFX1
X769 Clk_i N3350 Prod2[3][2][17] _NC1801 _NC1802 _NC1803 DFFX1
X770 Clk_i N3360 Prod2[3][3][0] _NC1804 _NC1805 _NC1806 DFFX1
X771 Clk_i N3370 Prod2[3][3][1] _NC1807 _NC1808 _NC1809 DFFX1
X772 Clk_i N3380 Prod2[3][3][2] _NC1810 _NC1811 _NC1812 DFFX1
X773 Clk_i N3390 Prod2[3][3][3] _NC1813 _NC1814 _NC1815 DFFX1
X774 Clk_i N3400 Prod2[3][3][4] _NC1816 _NC1817 _NC1818 DFFX1
X775 Clk_i N3410 Prod2[3][3][5] _NC1819 _NC1820 _NC1821 DFFX1
X776 Clk_i N3420 Prod2[3][3][6] _NC1822 _NC1823 _NC1824 DFFX1
X777 Clk_i N3430 Prod2[3][3][7] _NC1825 _NC1826 _NC1827 DFFX1
X778 Clk_i N3440 Prod2[3][3][8] _NC1828 _NC1829 _NC1830 DFFX1
X779 Clk_i N3450 Prod2[3][3][9] _NC1831 _NC1832 _NC1833 DFFX1
X780 Clk_i N3460 Prod2[3][3][10] _NC1834 _NC1835 _NC1836 DFFX1
X781 Clk_i N3470 Prod2[3][3][11] _NC1837 _NC1838 _NC1839 DFFX1
X782 Clk_i N3510 Count[2] N38 _NC1840 _NC1841 DFFX1
X783 Clk_i N3480 N26 _NC1842 _NC1843 _NC1844 DFFX1
X784 Clk_i N3490 Ready_o _NC1845 _NC1846 _NC1847 DFFX1
X785 Clk_i N3500 S_state _NC1848 _NC1849 _NC1850 DFFX1
X786 Clk_i N3520 N25 N1 _NC1851 _NC1852 DFFX1
X787 Clk_i Start_i S_start_i N250 _NC1853 _NC1854 DFFX1
X788 Clk_i Signb_i S_signb_i _NC1855 _NC1856 _NC1857 DFFX1
X789 Clk_i Signa_i S_signa_i _NC1858 _NC1859 _NC1860 DFFX1
X790 Clk_i Fractb_i[0] S_fractb_i[0] _NC1861 _NC1862 _NC1863 DFFX1
X791 Clk_i Fractb_i[1] S_fractb_i[1] _NC1864 _NC1865 _NC1866 DFFX1
X792 Clk_i Fractb_i[2] S_fractb_i[2] _NC1867 _NC1868 _NC1869 DFFX1
X793 Clk_i Fractb_i[3] S_fractb_i[3] _NC1870 _NC1871 _NC1872 DFFX1
X794 Clk_i Fractb_i[4] S_fractb_i[4] _NC1873 _NC1874 _NC1875 DFFX1
X795 Clk_i Fractb_i[5] S_fractb_i[5] _NC1876 _NC1877 _NC1878 DFFX1
X796 Clk_i Fractb_i[6] S_fractb_i[6] _NC1879 _NC1880 _NC1881 DFFX1
X797 Clk_i Fractb_i[7] S_fractb_i[7] _NC1882 _NC1883 _NC1884 DFFX1
X798 Clk_i Fractb_i[8] S_fractb_i[8] _NC1885 _NC1886 _NC1887 DFFX1
X799 Clk_i Fractb_i[9] S_fractb_i[9] _NC1888 _NC1889 _NC1890 DFFX1
X800 Clk_i Fractb_i[10] S_fractb_i[10] _NC1891 _NC1892 _NC1893 DFFX1
X801 Clk_i Fractb_i[11] S_fractb_i[11] _NC1894 _NC1895 _NC1896 DFFX1
X802 Clk_i Fractb_i[12] S_fractb_i[12] _NC1897 _NC1898 _NC1899 DFFX1
X803 Clk_i Fractb_i[13] S_fractb_i[13] _NC1900 _NC1901 _NC1902 DFFX1
X804 Clk_i Fractb_i[14] S_fractb_i[14] _NC1903 _NC1904 _NC1905 DFFX1
X805 Clk_i Fractb_i[15] S_fractb_i[15] _NC1906 _NC1907 _NC1908 DFFX1
X806 Clk_i Fractb_i[16] S_fractb_i[16] _NC1909 _NC1910 _NC1911 DFFX1
X807 Clk_i Fractb_i[17] S_fractb_i[17] _NC1912 _NC1913 _NC1914 DFFX1
X808 Clk_i Fractb_i[18] S_fractb_i[18] _NC1915 _NC1916 _NC1917 DFFX1
X809 Clk_i Fractb_i[19] S_fractb_i[19] _NC1918 _NC1919 _NC1920 DFFX1
X810 Clk_i Fractb_i[20] S_fractb_i[20] _NC1921 _NC1922 _NC1923 DFFX1
X811 Clk_i Fractb_i[21] S_fractb_i[21] _NC1924 _NC1925 _NC1926 DFFX1
X812 Clk_i Fractb_i[22] S_fractb_i[22] _NC1927 _NC1928 _NC1929 DFFX1
X813 Clk_i Fractb_i[23] S_fractb_i[23] _NC1930 _NC1931 _NC1932 DFFX1
X814 Clk_i Fracta_i[0] S_fracta_i[0] _NC1933 _NC1934 _NC1935 DFFX1
X815 Clk_i Fracta_i[1] S_fracta_i[1] _NC1936 _NC1937 _NC1938 DFFX1
X816 Clk_i Fracta_i[2] S_fracta_i[2] _NC1939 _NC1940 _NC1941 DFFX1
X817 Clk_i Fracta_i[3] S_fracta_i[3] _NC1942 _NC1943 _NC1944 DFFX1
X818 Clk_i Fracta_i[4] S_fracta_i[4] _NC1945 _NC1946 _NC1947 DFFX1
X819 Clk_i Fracta_i[5] S_fracta_i[5] _NC1948 _NC1949 _NC1950 DFFX1
X820 Clk_i Fracta_i[6] S_fracta_i[6] _NC1951 _NC1952 _NC1953 DFFX1
X821 Clk_i Fracta_i[7] S_fracta_i[7] _NC1954 _NC1955 _NC1956 DFFX1
X822 Clk_i Fracta_i[8] S_fracta_i[8] _NC1957 _NC1958 _NC1959 DFFX1
X823 Clk_i Fracta_i[9] S_fracta_i[9] _NC1960 _NC1961 _NC1962 DFFX1
X824 Clk_i Fracta_i[10] S_fracta_i[10] _NC1963 _NC1964 _NC1965 DFFX1
X825 Clk_i Fracta_i[11] S_fracta_i[11] _NC1966 _NC1967 _NC1968 DFFX1
X826 Clk_i Fracta_i[12] S_fracta_i[12] _NC1969 _NC1970 _NC1971 DFFX1
X827 Clk_i Fracta_i[13] S_fracta_i[13] _NC1972 _NC1973 _NC1974 DFFX1
X828 Clk_i Fracta_i[14] S_fracta_i[14] _NC1975 _NC1976 _NC1977 DFFX1
X829 Clk_i Fracta_i[15] S_fracta_i[15] _NC1978 _NC1979 _NC1980 DFFX1
X830 Clk_i Fracta_i[16] S_fracta_i[16] _NC1981 _NC1982 _NC1983 DFFX1
X831 Clk_i Fracta_i[17] S_fracta_i[17] _NC1984 _NC1985 _NC1986 DFFX1
X832 Clk_i Fracta_i[18] S_fracta_i[18] _NC1987 _NC1988 _NC1989 DFFX1
X833 Clk_i Fracta_i[19] S_fracta_i[19] _NC1990 _NC1991 _NC1992 DFFX1
X834 Clk_i Fracta_i[20] S_fracta_i[20] _NC1993 _NC1994 _NC1995 DFFX1
X835 Clk_i Fracta_i[21] S_fracta_i[21] _NC1996 _NC1997 _NC1998 DFFX1
X836 Clk_i Fracta_i[22] S_fracta_i[22] _NC1999 _NC2000 _NC2001 DFFX1
X837 Clk_i Fracta_i[23] S_fracta_i[23] _NC2002 _NC2003 _NC2004 DFFX1
.ENDS mul_24

.SUBCKT mul_24_DW01_add_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] SUM[28] SUM[29] SUM[30] SUM[31] SUM[32] SUM[33] SUM[34] SUM[35] SUM[36] SUM[37] SUM[38] SUM[39] SUM[40] SUM[41] SUM[42] SUM[43] SUM[44] SUM[45] SUM[46] SUM[47] CO
X0 A[12] B[12] SUM[12] _NC0 _NC1 XOR2X1
X1 A[37] Carry[23] SUM[37] _NC2 _NC3 XOR2X1
X2 A[38] N2 SUM[38] _NC4 _NC5 XOR2X1
X3 A[39] N4 SUM[39] _NC6 _NC7 XOR2X1
X4 A[40] N5 SUM[40] _NC8 _NC9 XOR2X1
X5 A[41] N6 SUM[41] _NC10 _NC11 XOR2X1
X6 A[42] N7 SUM[42] _NC12 _NC13 XOR2X1
X7 A[43] N8 SUM[43] _NC14 _NC15 XOR2X1
X8 A[44] N9 SUM[44] _NC16 _NC17 XOR2X1
X9 A[45] N10 SUM[45] _NC18 _NC19 XOR2X1
X10 A[46] N3 SUM[46] _NC20 _NC21 XOR2X1
X11 B[6] _NC22 _NC23 SUM[6] NBUFFX2
X12 B[5] _NC24 _NC25 SUM[5] NBUFFX2
X13 B[11] _NC26 _NC27 SUM[11] NBUFFX2
X14 B[10] _NC28 _NC29 SUM[10] NBUFFX2
X15 B[9] _NC30 _NC31 SUM[9] NBUFFX2
X16 B[8] _NC32 _NC33 SUM[8] NBUFFX2
X17 B[7] _NC34 _NC35 SUM[7] NBUFFX2
X18 B[4] _NC36 _NC37 SUM[4] NBUFFX2
X19 B[3] _NC38 _NC39 SUM[3] NBUFFX2
X20 B[2] _NC40 _NC41 SUM[2] NBUFFX2
X21 B[1] _NC42 _NC43 SUM[1] NBUFFX2
X22 B[0] _NC44 _NC45 SUM[0] NBUFFX2
X23 A[47] N23 SUM[47] _NC46 _NC47 XNOR2X1
X24 A[46] N3 N23 _NC48 _NC49 NAND2X1
X25 A[44] N9 N10 _NC50 _NC51 AND2X1
X26 A[43] N8 N9 _NC52 _NC53 AND2X1
X27 A[42] N7 N8 _NC54 _NC55 AND2X1
X28 A[41] N6 N7 _NC56 _NC57 AND2X1
X29 A[40] N5 N6 _NC58 _NC59 AND2X1
X30 A[39] N4 N5 _NC60 _NC61 AND2X1
X31 A[38] N2 N4 _NC62 _NC63 AND2X1
X32 A[45] N10 N3 _NC64 _NC65 AND2X1
X33 A[37] Carry[23] N2 _NC66 _NC67 AND2X1
X34 A[12] B[12] N1 _NC68 _NC69 AND2X1
X35 A[13] B[13] N1 Carry[0] SUM[13] _NC70 _NC71 FADDX1
X36 A[14] B[14] Carry[0] Carry[1] SUM[14] _NC72 _NC73 FADDX1
X37 A[15] B[15] Carry[1] Carry[2] SUM[15] _NC74 _NC75 FADDX1
X38 A[16] B[16] Carry[2] Carry[3] SUM[16] _NC76 _NC77 FADDX1
X39 A[17] B[17] Carry[3] Carry[4] SUM[17] _NC78 _NC79 FADDX1
X40 A[18] B[18] Carry[4] Carry[5] SUM[18] _NC80 _NC81 FADDX1
X41 A[19] B[19] Carry[5] Carry[6] SUM[19] _NC82 _NC83 FADDX1
X42 A[20] B[20] Carry[6] Carry[7] SUM[20] _NC84 _NC85 FADDX1
X43 A[21] B[21] Carry[7] Carry[8] SUM[21] _NC86 _NC87 FADDX1
X44 A[22] B[22] Carry[8] Carry[9] SUM[22] _NC88 _NC89 FADDX1
X45 A[23] B[23] Carry[9] Carry[10] SUM[23] _NC90 _NC91 FADDX1
X46 A[24] B[24] Carry[10] Carry[11] SUM[24] _NC92 _NC93 FADDX1
X47 A[25] B[25] Carry[11] Carry[12] SUM[25] _NC94 _NC95 FADDX1
X48 A[26] B[26] Carry[12] Carry[13] SUM[26] _NC96 _NC97 FADDX1
X49 A[27] B[27] Carry[13] Carry[14] SUM[27] _NC98 _NC99 FADDX1
X50 A[28] B[28] Carry[14] Carry[15] SUM[28] _NC100 _NC101 FADDX1
X51 A[29] B[29] Carry[15] Carry[16] SUM[29] _NC102 _NC103 FADDX1
X52 A[30] B[30] Carry[16] Carry[17] SUM[30] _NC104 _NC105 FADDX1
X53 A[31] B[31] Carry[17] Carry[18] SUM[31] _NC106 _NC107 FADDX1
X54 A[32] B[32] Carry[18] Carry[19] SUM[32] _NC108 _NC109 FADDX1
X55 A[33] B[33] Carry[19] Carry[20] SUM[33] _NC110 _NC111 FADDX1
X56 A[34] B[34] Carry[20] Carry[21] SUM[34] _NC112 _NC113 FADDX1
X57 A[35] B[35] Carry[21] Carry[22] SUM[35] _NC114 _NC115 FADDX1
X58 A[36] B[36] Carry[22] Carry[23] SUM[36] _NC116 _NC117 FADDX1
.ENDS mul_24_DW01_add_0

.SUBCKT mul_24_DW01_add_1 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] SUM[28] SUM[29] SUM[30] SUM[31] SUM[32] SUM[33] SUM[34] SUM[35] SUM[36] SUM[37] SUM[38] SUM[39] SUM[40] SUM[41] SUM[42] SUM[43] SUM[44] SUM[45] SUM[46] SUM[47] CO
X0 A[24] B[24] SUM[24] _NC0 _NC1 XOR2X1
X1 B[36] Carry[10] SUM[36] _NC2 _NC3 XOR2X1
X2 B[37] N3 SUM[37] _NC4 _NC5 XOR2X1
X3 B[38] N7 SUM[38] _NC6 _NC7 XOR2X1
X4 B[39] N8 SUM[39] _NC8 _NC9 XOR2X1
X5 B[40] N9 SUM[40] _NC10 _NC11 XOR2X1
X6 B[41] N4 SUM[41] _NC12 _NC13 XOR2X1
X7 B[42] N10 SUM[42] _NC14 _NC15 XOR2X1
X8 B[43] N11 SUM[43] _NC16 _NC17 XOR2X1
X9 B[44] N5 SUM[44] _NC18 _NC19 XOR2X1
X10 B[45] N6 SUM[45] _NC20 _NC21 XOR2X1
X11 B[46] N12 SUM[46] _NC22 _NC23 XOR2X1
X12 B[47] N1 SUM[47] _NC24 _NC25 XOR2X1
X13 B[45] N6 N12 _NC26 _NC27 AND2X1
X14 B[42] N10 N11 _NC28 _NC29 AND2X1
X15 B[41] N4 N10 _NC30 _NC31 AND2X1
X16 B[39] N8 N9 _NC32 _NC33 AND2X1
X17 B[38] N7 N8 _NC34 _NC35 AND2X1
X18 B[37] N3 N7 _NC36 _NC37 AND2X1
X19 B[44] N5 N6 _NC38 _NC39 AND2X1
X20 B[43] N11 N5 _NC40 _NC41 AND2X1
X21 B[40] N9 N4 _NC42 _NC43 AND2X1
X22 B[36] Carry[10] N3 _NC44 _NC45 AND2X1
X23 A[24] B[24] N2 _NC46 _NC47 AND2X1
X24 A[23] _NC48 _NC49 SUM[23] NBUFFX2
X25 A[22] _NC50 _NC51 SUM[22] NBUFFX2
X26 A[21] _NC52 _NC53 SUM[21] NBUFFX2
X27 A[20] _NC54 _NC55 SUM[20] NBUFFX2
X28 A[19] _NC56 _NC57 SUM[19] NBUFFX2
X29 A[17] _NC58 _NC59 SUM[17] NBUFFX2
X30 A[16] _NC60 _NC61 SUM[16] NBUFFX2
X31 A[15] _NC62 _NC63 SUM[15] NBUFFX2
X32 A[14] _NC64 _NC65 SUM[14] NBUFFX2
X33 A[13] _NC66 _NC67 SUM[13] NBUFFX2
X34 A[18] _NC68 _NC69 SUM[18] NBUFFX2
X35 A[12] _NC70 _NC71 SUM[12] NBUFFX2
X36 B[46] N12 N1 _NC72 _NC73 AND2X1
X37 A[25] B[25] N2 Carry[0] SUM[25] _NC74 _NC75 FADDX1
X38 A[26] B[26] Carry[0] Carry[1] SUM[26] _NC76 _NC77 FADDX1
X39 A[27] B[27] Carry[1] Carry[2] SUM[27] _NC78 _NC79 FADDX1
X40 A[28] B[28] Carry[2] Carry[3] SUM[28] _NC80 _NC81 FADDX1
X41 A[29] B[29] Carry[3] Carry[4] SUM[29] _NC82 _NC83 FADDX1
X42 A[30] B[30] Carry[4] Carry[5] SUM[30] _NC84 _NC85 FADDX1
X43 A[31] B[31] Carry[5] Carry[6] SUM[31] _NC86 _NC87 FADDX1
X44 A[32] B[32] Carry[6] Carry[7] SUM[32] _NC88 _NC89 FADDX1
X45 A[33] B[33] Carry[7] Carry[8] SUM[33] _NC90 _NC91 FADDX1
X46 A[34] B[34] Carry[8] Carry[9] SUM[34] _NC92 _NC93 FADDX1
X47 A[35] B[35] Carry[9] Carry[10] SUM[35] _NC94 _NC95 FADDX1
.ENDS mul_24_DW01_add_1

.SUBCKT mul_24_DW01_add_2 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[30] A[31] A[32] A[33] A[34] A[35] A[36] A[37] A[38] A[39] A[40] A[41] A[42] A[43] A[44] A[45] A[46] A[47] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[30] B[31] B[32] B[33] B[34] B[35] B[36] B[37] B[38] B[39] B[40] B[41] B[42] B[43] B[44] B[45] B[46] B[47] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] SUM[28] SUM[29] SUM[30] SUM[31] SUM[32] SUM[33] SUM[34] SUM[35] SUM[36] SUM[37] SUM[38] SUM[39] SUM[40] SUM[41] SUM[42] SUM[43] SUM[44] SUM[45] SUM[46] SUM[47] CO
X0 A[12] B[12] SUM[12] _NC0 _NC1 XOR2X1
X1 B[24] Carry[10] SUM[24] _NC2 _NC3 XOR2X1
X2 B[25] N3 SUM[25] _NC4 _NC5 XOR2X1
X3 B[26] N7 SUM[26] _NC6 _NC7 XOR2X1
X4 B[27] N8 SUM[27] _NC8 _NC9 XOR2X1
X5 B[28] N9 SUM[28] _NC10 _NC11 XOR2X1
X6 B[29] N4 SUM[29] _NC12 _NC13 XOR2X1
X7 B[30] N10 SUM[30] _NC14 _NC15 XOR2X1
X8 B[31] N11 SUM[31] _NC16 _NC17 XOR2X1
X9 B[32] N5 SUM[32] _NC18 _NC19 XOR2X1
X10 B[33] N6 SUM[33] _NC20 _NC21 XOR2X1
X11 B[34] N12 SUM[34] _NC22 _NC23 XOR2X1
X12 B[35] N13 SUM[35] _NC24 _NC25 XOR2X1
X13 A[6] _NC26 _NC27 SUM[6] NBUFFX2
X14 A[5] _NC28 _NC29 SUM[5] NBUFFX2
X15 A[11] _NC30 _NC31 SUM[11] NBUFFX2
X16 A[10] _NC32 _NC33 SUM[10] NBUFFX2
X17 A[9] _NC34 _NC35 SUM[9] NBUFFX2
X18 A[8] _NC36 _NC37 SUM[8] NBUFFX2
X19 A[7] _NC38 _NC39 SUM[7] NBUFFX2
X20 A[4] _NC40 _NC41 SUM[4] NBUFFX2
X21 A[3] _NC42 _NC43 SUM[3] NBUFFX2
X22 A[2] _NC44 _NC45 SUM[2] NBUFFX2
X23 A[1] _NC46 _NC47 SUM[1] NBUFFX2
X24 A[0] _NC48 _NC49 SUM[0] NBUFFX2
X25 B[34] N12 N13 _NC50 _NC51 AND2X1
X26 B[33] N6 N12 _NC52 _NC53 AND2X1
X27 B[30] N10 N11 _NC54 _NC55 AND2X1
X28 B[29] N4 N10 _NC56 _NC57 AND2X1
X29 B[27] N8 N9 _NC58 _NC59 AND2X1
X30 B[26] N7 N8 _NC60 _NC61 AND2X1
X31 B[25] N3 N7 _NC62 _NC63 AND2X1
X32 B[32] N5 N6 _NC64 _NC65 AND2X1
X33 B[31] N11 N5 _NC66 _NC67 AND2X1
X34 B[28] N9 N4 _NC68 _NC69 AND2X1
X35 B[24] Carry[10] N3 _NC70 _NC71 AND2X1
X36 A[12] B[12] N2 _NC72 _NC73 AND2X1
X37 B[35] N13 SUM[36] _NC74 _NC75 AND2X1
X38 A[13] B[13] N2 Carry[0] SUM[13] _NC76 _NC77 FADDX1
X39 A[14] B[14] Carry[0] Carry[1] SUM[14] _NC78 _NC79 FADDX1
X40 A[15] B[15] Carry[1] Carry[2] SUM[15] _NC80 _NC81 FADDX1
X41 A[16] B[16] Carry[2] Carry[3] SUM[16] _NC82 _NC83 FADDX1
X42 A[17] B[17] Carry[3] Carry[4] SUM[17] _NC84 _NC85 FADDX1
X43 A[18] B[18] Carry[4] Carry[5] SUM[18] _NC86 _NC87 FADDX1
X44 A[19] B[19] Carry[5] Carry[6] SUM[19] _NC88 _NC89 FADDX1
X45 A[20] B[20] Carry[6] Carry[7] SUM[20] _NC90 _NC91 FADDX1
X46 A[21] B[21] Carry[7] Carry[8] SUM[21] _NC92 _NC93 FADDX1
X47 A[22] B[22] Carry[8] Carry[9] SUM[22] _NC94 _NC95 FADDX1
X48 A[23] B[23] Carry[9] Carry[10] SUM[23] _NC96 _NC97 FADDX1
.ENDS mul_24_DW01_add_2

.SUBCKT mul_24_DW_mult_uns_0 A[0] A[1] A[2] A[3] A[4] A[5] B[0] B[1] B[2] B[3] B[4] B[5] Product[0] Product[1] Product[2] Product[3] Product[4] Product[5] Product[6] Product[7] Product[8] Product[9] Product[10] Product[11]
X0 N132 N126 N51 _NC0 _NC1 NOR2X0
X1 N133 N126 N52 _NC2 _NC3 NOR2X0
X2 N134 N126 N53 _NC4 _NC5 NOR2X0
X3 N135 N126 N54 _NC6 _NC7 NOR2X0
X4 N136 N126 N55 _NC8 _NC9 NOR2X0
X5 N137 N126 N56 _NC10 _NC11 NOR2X0
X6 N132 N127 N57 _NC12 _NC13 NOR2X0
X7 N133 N127 N58 _NC14 _NC15 NOR2X0
X8 N134 N127 N59 _NC16 _NC17 NOR2X0
X9 N135 N127 N60 _NC18 _NC19 NOR2X0
X10 N136 N127 N61 _NC20 _NC21 NOR2X0
X11 N137 N127 N62 _NC22 _NC23 NOR2X0
X12 N132 N128 N63 _NC24 _NC25 NOR2X0
X13 N133 N128 N64 _NC26 _NC27 NOR2X0
X14 N134 N128 N65 _NC28 _NC29 NOR2X0
X15 N135 N128 N66 _NC30 _NC31 NOR2X0
X16 N136 N128 N67 _NC32 _NC33 NOR2X0
X17 N137 N128 N68 _NC34 _NC35 NOR2X0
X18 N132 N129 N69 _NC36 _NC37 NOR2X0
X19 N133 N129 N70 _NC38 _NC39 NOR2X0
X20 N134 N129 N71 _NC40 _NC41 NOR2X0
X21 N135 N129 N72 _NC42 _NC43 NOR2X0
X22 N136 N129 N73 _NC44 _NC45 NOR2X0
X23 N137 N129 N74 _NC46 _NC47 NOR2X0
X24 N132 N130 N75 _NC48 _NC49 NOR2X0
X25 N133 N130 N76 _NC50 _NC51 NOR2X0
X26 N134 N130 N77 _NC52 _NC53 NOR2X0
X27 N135 N130 N78 _NC54 _NC55 NOR2X0
X28 N136 N130 N79 _NC56 _NC57 NOR2X0
X29 N137 N130 N80 _NC58 _NC59 NOR2X0
X30 N131 N132 N81 _NC60 _NC61 NOR2X0
X31 N131 N133 N82 _NC62 _NC63 NOR2X0
X32 N131 N134 N83 _NC64 _NC65 NOR2X0
X33 N131 N135 N84 _NC66 _NC67 NOR2X0
X34 N131 N136 N85 _NC68 _NC69 NOR2X0
X35 N131 N137 Product[0] _NC70 _NC71 NOR2X0
X36 A[4] _NC72 _NC73 N127 INVX0
X37 A[5] _NC74 _NC75 N126 INVX0
X38 A[3] _NC76 _NC77 N128 INVX0
X39 A[2] _NC78 _NC79 N129 INVX0
X40 A[1] _NC80 _NC81 N130 INVX0
X41 B[4] _NC82 _NC83 N133 INVX0
X42 B[3] _NC84 _NC85 N134 INVX0
X43 B[5] _NC86 _NC87 N132 INVX0
X44 B[2] _NC88 _NC89 N135 INVX0
X45 B[0] _NC90 _NC91 N137 INVX0
X46 B[1] _NC92 _NC93 N136 INVX0
X47 A[0] _NC94 _NC95 N131 INVX0
X48 N84 N79 N49 _NC96 _NC97 _NC98 HADDX1
X49 N73 N68 N47 _NC99 _NC100 _NC101 HADDX1
X50 N78 N83 N48 N45 N46 _NC102 _NC103 FADDX1
X51 N67 N62 N43 _NC104 _NC105 _NC106 HADDX1
X52 N72 N82 N77 N41 N42 _NC107 _NC108 FADDX1
X53 N47 N44 N42 N39 N40 _NC109 _NC110 FADDX1
X54 N61 N56 N37 _NC111 _NC112 _NC113 HADDX1
X55 N66 N71 N76 N35 N36 _NC114 _NC115 FADDX1
X56 N38 N81 N43 N33 N34 _NC116 _NC117 FADDX1
X57 N36 N41 N34 N31 N32 _NC118 _NC119 FADDX1
X58 N60 N55 N29 _NC120 _NC121 _NC122 HADDX1
X59 N70 N65 N75 N27 N28 _NC123 _NC124 FADDX1
X60 N37 N30 N35 N25 N26 _NC125 _NC126 FADDX1
X61 N33 N28 N26 N23 N24 _NC127 _NC128 FADDX1
X62 N54 N69 N59 N21 N22 _NC129 _NC130 FADDX1
X63 N29 N64 N27 N19 N20 _NC131 _NC132 FADDX1
X64 N25 N22 N20 N17 N18 _NC133 _NC134 FADDX1
X65 N53 N63 N58 N15 N16 _NC135 _NC136 FADDX1
X66 N16 N21 N19 N13 N14 _NC137 _NC138 FADDX1
X67 N52 N57 N15 N11 N12 _NC139 _NC140 FADDX1
X68 N80 N85 N10 _NC141 _NC142 _NC143 HADDX1
X69 N50 N74 N10 N9 Product[2] _NC144 _NC145 FADDX1
X70 N46 N49 N9 N8 Product[3] _NC146 _NC147 FADDX1
X71 N40 N45 N8 N7 Product[4] _NC148 _NC149 FADDX1
X72 N32 N39 N7 N6 Product[5] _NC150 _NC151 FADDX1
X73 N24 N31 N6 N5 Product[6] _NC152 _NC153 FADDX1
X74 N18 N23 N5 N4 Product[7] _NC154 _NC155 FADDX1
X75 N17 N14 N4 N3 Product[8] _NC156 _NC157 FADDX1
X76 N13 N12 N3 N2 Product[9] _NC158 _NC159 FADDX1
X77 N11 N51 N2 Product[11] Product[10] _NC160 _NC161 FADDX1
.ENDS mul_24_DW_mult_uns_0

.SUBCKT mul_24_DW_mult_uns_1 A[0] A[1] A[2] A[3] A[4] A[5] B[0] B[1] B[2] B[3] B[4] B[5] Product[0] Product[1] Product[2] Product[3] Product[4] Product[5] Product[6] Product[7] Product[8] Product[9] Product[10] Product[11]
X0 N132 N126 N51 _NC0 _NC1 NOR2X0
X1 N133 N126 N52 _NC2 _NC3 NOR2X0
X2 N134 N126 N53 _NC4 _NC5 NOR2X0
X3 N135 N126 N54 _NC6 _NC7 NOR2X0
X4 N136 N126 N55 _NC8 _NC9 NOR2X0
X5 N137 N126 N56 _NC10 _NC11 NOR2X0
X6 N132 N127 N57 _NC12 _NC13 NOR2X0
X7 N133 N127 N58 _NC14 _NC15 NOR2X0
X8 N134 N127 N59 _NC16 _NC17 NOR2X0
X9 N135 N127 N60 _NC18 _NC19 NOR2X0
X10 N136 N127 N61 _NC20 _NC21 NOR2X0
X11 N137 N127 N62 _NC22 _NC23 NOR2X0
X12 N132 N128 N63 _NC24 _NC25 NOR2X0
X13 N133 N128 N64 _NC26 _NC27 NOR2X0
X14 N134 N128 N65 _NC28 _NC29 NOR2X0
X15 N135 N128 N66 _NC30 _NC31 NOR2X0
X16 N136 N128 N67 _NC32 _NC33 NOR2X0
X17 N137 N128 N68 _NC34 _NC35 NOR2X0
X18 N132 N129 N69 _NC36 _NC37 NOR2X0
X19 N133 N129 N70 _NC38 _NC39 NOR2X0
X20 N134 N129 N71 _NC40 _NC41 NOR2X0
X21 N135 N129 N72 _NC42 _NC43 NOR2X0
X22 N136 N129 N73 _NC44 _NC45 NOR2X0
X23 N137 N129 N74 _NC46 _NC47 NOR2X0
X24 N132 N130 N75 _NC48 _NC49 NOR2X0
X25 N133 N130 N76 _NC50 _NC51 NOR2X0
X26 N134 N130 N77 _NC52 _NC53 NOR2X0
X27 N135 N130 N78 _NC54 _NC55 NOR2X0
X28 N136 N130 N79 _NC56 _NC57 NOR2X0
X29 N137 N130 N80 _NC58 _NC59 NOR2X0
X30 N131 N132 N81 _NC60 _NC61 NOR2X0
X31 N131 N133 N82 _NC62 _NC63 NOR2X0
X32 N131 N134 N83 _NC64 _NC65 NOR2X0
X33 N131 N135 N84 _NC66 _NC67 NOR2X0
X34 N131 N136 N85 _NC68 _NC69 NOR2X0
X35 N131 N137 Product[0] _NC70 _NC71 NOR2X0
X36 A[4] _NC72 _NC73 N127 INVX0
X37 A[5] _NC74 _NC75 N126 INVX0
X38 A[3] _NC76 _NC77 N128 INVX0
X39 A[2] _NC78 _NC79 N129 INVX0
X40 A[1] _NC80 _NC81 N130 INVX0
X41 B[4] _NC82 _NC83 N133 INVX0
X42 B[3] _NC84 _NC85 N134 INVX0
X43 B[5] _NC86 _NC87 N132 INVX0
X44 B[2] _NC88 _NC89 N135 INVX0
X45 B[0] _NC90 _NC91 N137 INVX0
X46 B[1] _NC92 _NC93 N136 INVX0
X47 A[0] _NC94 _NC95 N131 INVX0
X48 N84 N79 N49 _NC96 _NC97 _NC98 HADDX1
X49 N73 N68 N47 _NC99 _NC100 _NC101 HADDX1
X50 N78 N83 N48 N45 N46 _NC102 _NC103 FADDX1
X51 N67 N62 N43 _NC104 _NC105 _NC106 HADDX1
X52 N72 N82 N77 N41 N42 _NC107 _NC108 FADDX1
X53 N47 N44 N42 N39 N40 _NC109 _NC110 FADDX1
X54 N61 N56 N37 _NC111 _NC112 _NC113 HADDX1
X55 N66 N71 N76 N35 N36 _NC114 _NC115 FADDX1
X56 N38 N81 N43 N33 N34 _NC116 _NC117 FADDX1
X57 N36 N41 N34 N31 N32 _NC118 _NC119 FADDX1
X58 N60 N55 N29 _NC120 _NC121 _NC122 HADDX1
X59 N70 N65 N75 N27 N28 _NC123 _NC124 FADDX1
X60 N37 N30 N35 N25 N26 _NC125 _NC126 FADDX1
X61 N33 N28 N26 N23 N24 _NC127 _NC128 FADDX1
X62 N54 N69 N59 N21 N22 _NC129 _NC130 FADDX1
X63 N29 N64 N27 N19 N20 _NC131 _NC132 FADDX1
X64 N25 N22 N20 N17 N18 _NC133 _NC134 FADDX1
X65 N53 N63 N58 N15 N16 _NC135 _NC136 FADDX1
X66 N16 N21 N19 N13 N14 _NC137 _NC138 FADDX1
X67 N52 N57 N15 N11 N12 _NC139 _NC140 FADDX1
X68 N80 N85 N10 _NC141 _NC142 _NC143 HADDX1
X69 N50 N74 N10 N9 Product[2] _NC144 _NC145 FADDX1
X70 N46 N49 N9 N8 Product[3] _NC146 _NC147 FADDX1
X71 N40 N45 N8 N7 Product[4] _NC148 _NC149 FADDX1
X72 N32 N39 N7 N6 Product[5] _NC150 _NC151 FADDX1
X73 N24 N31 N6 N5 Product[6] _NC152 _NC153 FADDX1
X74 N18 N23 N5 N4 Product[7] _NC154 _NC155 FADDX1
X75 N17 N14 N4 N3 Product[8] _NC156 _NC157 FADDX1
X76 N13 N12 N3 N2 Product[9] _NC158 _NC159 FADDX1
X77 N11 N51 N2 Product[11] Product[10] _NC160 _NC161 FADDX1
.ENDS mul_24_DW_mult_uns_1

.SUBCKT mul_24_DW_mult_uns_2 A[0] A[1] A[2] A[3] A[4] A[5] B[0] B[1] B[2] B[3] B[4] B[5] Product[0] Product[1] Product[2] Product[3] Product[4] Product[5] Product[6] Product[7] Product[8] Product[9] Product[10] Product[11]
X0 N132 N126 N51 _NC0 _NC1 NOR2X0
X1 N133 N126 N52 _NC2 _NC3 NOR2X0
X2 N134 N126 N53 _NC4 _NC5 NOR2X0
X3 N135 N126 N54 _NC6 _NC7 NOR2X0
X4 N136 N126 N55 _NC8 _NC9 NOR2X0
X5 N137 N126 N56 _NC10 _NC11 NOR2X0
X6 N132 N127 N57 _NC12 _NC13 NOR2X0
X7 N133 N127 N58 _NC14 _NC15 NOR2X0
X8 N134 N127 N59 _NC16 _NC17 NOR2X0
X9 N135 N127 N60 _NC18 _NC19 NOR2X0
X10 N136 N127 N61 _NC20 _NC21 NOR2X0
X11 N137 N127 N62 _NC22 _NC23 NOR2X0
X12 N132 N128 N63 _NC24 _NC25 NOR2X0
X13 N133 N128 N64 _NC26 _NC27 NOR2X0
X14 N134 N128 N65 _NC28 _NC29 NOR2X0
X15 N135 N128 N66 _NC30 _NC31 NOR2X0
X16 N136 N128 N67 _NC32 _NC33 NOR2X0
X17 N137 N128 N68 _NC34 _NC35 NOR2X0
X18 N132 N129 N69 _NC36 _NC37 NOR2X0
X19 N133 N129 N70 _NC38 _NC39 NOR2X0
X20 N134 N129 N71 _NC40 _NC41 NOR2X0
X21 N135 N129 N72 _NC42 _NC43 NOR2X0
X22 N136 N129 N73 _NC44 _NC45 NOR2X0
X23 N137 N129 N74 _NC46 _NC47 NOR2X0
X24 N132 N130 N75 _NC48 _NC49 NOR2X0
X25 N133 N130 N76 _NC50 _NC51 NOR2X0
X26 N134 N130 N77 _NC52 _NC53 NOR2X0
X27 N135 N130 N78 _NC54 _NC55 NOR2X0
X28 N136 N130 N79 _NC56 _NC57 NOR2X0
X29 N137 N130 N80 _NC58 _NC59 NOR2X0
X30 N131 N132 N81 _NC60 _NC61 NOR2X0
X31 N131 N133 N82 _NC62 _NC63 NOR2X0
X32 N131 N134 N83 _NC64 _NC65 NOR2X0
X33 N131 N135 N84 _NC66 _NC67 NOR2X0
X34 N131 N136 N85 _NC68 _NC69 NOR2X0
X35 N131 N137 Product[0] _NC70 _NC71 NOR2X0
X36 A[4] _NC72 _NC73 N127 INVX0
X37 A[5] _NC74 _NC75 N126 INVX0
X38 A[3] _NC76 _NC77 N128 INVX0
X39 A[2] _NC78 _NC79 N129 INVX0
X40 A[1] _NC80 _NC81 N130 INVX0
X41 B[4] _NC82 _NC83 N133 INVX0
X42 B[3] _NC84 _NC85 N134 INVX0
X43 B[5] _NC86 _NC87 N132 INVX0
X44 B[2] _NC88 _NC89 N135 INVX0
X45 B[0] _NC90 _NC91 N137 INVX0
X46 B[1] _NC92 _NC93 N136 INVX0
X47 A[0] _NC94 _NC95 N131 INVX0
X48 N84 N79 N49 _NC96 _NC97 _NC98 HADDX1
X49 N73 N68 N47 _NC99 _NC100 _NC101 HADDX1
X50 N78 N83 N48 N45 N46 _NC102 _NC103 FADDX1
X51 N67 N62 N43 _NC104 _NC105 _NC106 HADDX1
X52 N72 N82 N77 N41 N42 _NC107 _NC108 FADDX1
X53 N47 N44 N42 N39 N40 _NC109 _NC110 FADDX1
X54 N61 N56 N37 _NC111 _NC112 _NC113 HADDX1
X55 N66 N71 N76 N35 N36 _NC114 _NC115 FADDX1
X56 N38 N81 N43 N33 N34 _NC116 _NC117 FADDX1
X57 N36 N41 N34 N31 N32 _NC118 _NC119 FADDX1
X58 N60 N55 N29 _NC120 _NC121 _NC122 HADDX1
X59 N70 N65 N75 N27 N28 _NC123 _NC124 FADDX1
X60 N37 N30 N35 N25 N26 _NC125 _NC126 FADDX1
X61 N33 N28 N26 N23 N24 _NC127 _NC128 FADDX1
X62 N54 N69 N59 N21 N22 _NC129 _NC130 FADDX1
X63 N29 N64 N27 N19 N20 _NC131 _NC132 FADDX1
X64 N25 N22 N20 N17 N18 _NC133 _NC134 FADDX1
X65 N53 N63 N58 N15 N16 _NC135 _NC136 FADDX1
X66 N16 N21 N19 N13 N14 _NC137 _NC138 FADDX1
X67 N52 N57 N15 N11 N12 _NC139 _NC140 FADDX1
X68 N80 N85 N10 _NC141 _NC142 _NC143 HADDX1
X69 N50 N74 N10 N9 Product[2] _NC144 _NC145 FADDX1
X70 N46 N49 N9 N8 Product[3] _NC146 _NC147 FADDX1
X71 N40 N45 N8 N7 Product[4] _NC148 _NC149 FADDX1
X72 N32 N39 N7 N6 Product[5] _NC150 _NC151 FADDX1
X73 N24 N31 N6 N5 Product[6] _NC152 _NC153 FADDX1
X74 N18 N23 N5 N4 Product[7] _NC154 _NC155 FADDX1
X75 N17 N14 N4 N3 Product[8] _NC156 _NC157 FADDX1
X76 N13 N12 N3 N2 Product[9] _NC158 _NC159 FADDX1
X77 N11 N51 N2 Product[11] Product[10] _NC160 _NC161 FADDX1
.ENDS mul_24_DW_mult_uns_2

.SUBCKT mul_24_DW_mult_uns_3 A[0] A[1] A[2] A[3] A[4] A[5] B[0] B[1] B[2] B[3] B[4] B[5] Product[0] Product[1] Product[2] Product[3] Product[4] Product[5] Product[6] Product[7] Product[8] Product[9] Product[10] Product[11]
X0 N132 N126 N51 _NC0 _NC1 NOR2X0
X1 N133 N126 N52 _NC2 _NC3 NOR2X0
X2 N134 N126 N53 _NC4 _NC5 NOR2X0
X3 N135 N126 N54 _NC6 _NC7 NOR2X0
X4 N136 N126 N55 _NC8 _NC9 NOR2X0
X5 N137 N126 N56 _NC10 _NC11 NOR2X0
X6 N132 N127 N57 _NC12 _NC13 NOR2X0
X7 N133 N127 N58 _NC14 _NC15 NOR2X0
X8 N134 N127 N59 _NC16 _NC17 NOR2X0
X9 N135 N127 N60 _NC18 _NC19 NOR2X0
X10 N136 N127 N61 _NC20 _NC21 NOR2X0
X11 N137 N127 N62 _NC22 _NC23 NOR2X0
X12 N132 N128 N63 _NC24 _NC25 NOR2X0
X13 N133 N128 N64 _NC26 _NC27 NOR2X0
X14 N134 N128 N65 _NC28 _NC29 NOR2X0
X15 N135 N128 N66 _NC30 _NC31 NOR2X0
X16 N136 N128 N67 _NC32 _NC33 NOR2X0
X17 N137 N128 N68 _NC34 _NC35 NOR2X0
X18 N132 N129 N69 _NC36 _NC37 NOR2X0
X19 N133 N129 N70 _NC38 _NC39 NOR2X0
X20 N134 N129 N71 _NC40 _NC41 NOR2X0
X21 N135 N129 N72 _NC42 _NC43 NOR2X0
X22 N136 N129 N73 _NC44 _NC45 NOR2X0
X23 N137 N129 N74 _NC46 _NC47 NOR2X0
X24 N132 N130 N75 _NC48 _NC49 NOR2X0
X25 N133 N130 N76 _NC50 _NC51 NOR2X0
X26 N134 N130 N77 _NC52 _NC53 NOR2X0
X27 N135 N130 N78 _NC54 _NC55 NOR2X0
X28 N136 N130 N79 _NC56 _NC57 NOR2X0
X29 N137 N130 N80 _NC58 _NC59 NOR2X0
X30 N131 N132 N81 _NC60 _NC61 NOR2X0
X31 N131 N133 N82 _NC62 _NC63 NOR2X0
X32 N131 N134 N83 _NC64 _NC65 NOR2X0
X33 N131 N135 N84 _NC66 _NC67 NOR2X0
X34 N131 N136 N85 _NC68 _NC69 NOR2X0
X35 N131 N137 Product[0] _NC70 _NC71 NOR2X0
X36 A[4] _NC72 _NC73 N127 INVX0
X37 A[5] _NC74 _NC75 N126 INVX0
X38 A[3] _NC76 _NC77 N128 INVX0
X39 A[2] _NC78 _NC79 N129 INVX0
X40 A[1] _NC80 _NC81 N130 INVX0
X41 B[4] _NC82 _NC83 N133 INVX0
X42 B[3] _NC84 _NC85 N134 INVX0
X43 B[5] _NC86 _NC87 N132 INVX0
X44 B[2] _NC88 _NC89 N135 INVX0
X45 B[0] _NC90 _NC91 N137 INVX0
X46 B[1] _NC92 _NC93 N136 INVX0
X47 A[0] _NC94 _NC95 N131 INVX0
X48 N84 N79 N49 _NC96 _NC97 _NC98 HADDX1
X49 N73 N68 N47 _NC99 _NC100 _NC101 HADDX1
X50 N78 N83 N48 N45 N46 _NC102 _NC103 FADDX1
X51 N67 N62 N43 _NC104 _NC105 _NC106 HADDX1
X52 N72 N82 N77 N41 N42 _NC107 _NC108 FADDX1
X53 N47 N44 N42 N39 N40 _NC109 _NC110 FADDX1
X54 N61 N56 N37 _NC111 _NC112 _NC113 HADDX1
X55 N66 N71 N76 N35 N36 _NC114 _NC115 FADDX1
X56 N38 N81 N43 N33 N34 _NC116 _NC117 FADDX1
X57 N36 N41 N34 N31 N32 _NC118 _NC119 FADDX1
X58 N60 N55 N29 _NC120 _NC121 _NC122 HADDX1
X59 N70 N65 N75 N27 N28 _NC123 _NC124 FADDX1
X60 N37 N30 N35 N25 N26 _NC125 _NC126 FADDX1
X61 N33 N28 N26 N23 N24 _NC127 _NC128 FADDX1
X62 N54 N69 N59 N21 N22 _NC129 _NC130 FADDX1
X63 N29 N64 N27 N19 N20 _NC131 _NC132 FADDX1
X64 N25 N22 N20 N17 N18 _NC133 _NC134 FADDX1
X65 N53 N63 N58 N15 N16 _NC135 _NC136 FADDX1
X66 N16 N21 N19 N13 N14 _NC137 _NC138 FADDX1
X67 N52 N57 N15 N11 N12 _NC139 _NC140 FADDX1
X68 N80 N85 N10 _NC141 _NC142 _NC143 HADDX1
X69 N50 N74 N10 N9 Product[2] _NC144 _NC145 FADDX1
X70 N46 N49 N9 N8 Product[3] _NC146 _NC147 FADDX1
X71 N40 N45 N8 N7 Product[4] _NC148 _NC149 FADDX1
X72 N32 N39 N7 N6 Product[5] _NC150 _NC151 FADDX1
X73 N24 N31 N6 N5 Product[6] _NC152 _NC153 FADDX1
X74 N18 N23 N5 N4 Product[7] _NC154 _NC155 FADDX1
X75 N17 N14 N4 N3 Product[8] _NC156 _NC157 FADDX1
X76 N13 N12 N3 N2 Product[9] _NC158 _NC159 FADDX1
X77 N11 N51 N2 Product[11] Product[10] _NC160 _NC161 FADDX1
.ENDS mul_24_DW_mult_uns_3

.SUBCKT mul_24_DW01_add_3 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] CO
X0 A[22] N4 SUM[22] _NC0 _NC1 XOR2X1
X1 A[21] N3 SUM[21] _NC2 _NC3 XOR2X1
X2 A[20] N2 SUM[20] _NC4 _NC5 XOR2X1
X3 A[19] Carry[11] SUM[19] _NC6 _NC7 XOR2X1
X4 A[6] B[6] SUM[6] _NC8 _NC9 XOR2X1
X5 B[5] _NC10 _NC11 SUM[5] NBUFFX2
X6 B[4] _NC12 _NC13 SUM[4] NBUFFX2
X7 B[3] _NC14 _NC15 SUM[3] NBUFFX2
X8 B[2] _NC16 _NC17 SUM[2] NBUFFX2
X9 B[1] _NC18 _NC19 SUM[1] NBUFFX2
X10 B[0] _NC20 _NC21 SUM[0] NBUFFX2
X11 A[23] N11 SUM[23] _NC22 _NC23 XNOR2X1
X12 A[22] N4 N11 _NC24 _NC25 NAND2X1
X13 A[21] N3 N4 _NC26 _NC27 AND2X1
X14 A[20] N2 N3 _NC28 _NC29 AND2X1
X15 A[19] Carry[11] N2 _NC30 _NC31 AND2X1
X16 A[6] B[6] N1 _NC32 _NC33 AND2X1
X17 A[7] B[7] N1 Carry[0] SUM[7] _NC34 _NC35 FADDX1
X18 A[8] B[8] Carry[0] Carry[1] SUM[8] _NC36 _NC37 FADDX1
X19 A[9] B[9] Carry[1] Carry[2] SUM[9] _NC38 _NC39 FADDX1
X20 A[10] B[10] Carry[2] Carry[3] SUM[10] _NC40 _NC41 FADDX1
X21 A[11] B[11] Carry[3] Carry[4] SUM[11] _NC42 _NC43 FADDX1
X22 A[12] B[12] Carry[4] Carry[5] SUM[12] _NC44 _NC45 FADDX1
X23 A[13] B[13] Carry[5] Carry[6] SUM[13] _NC46 _NC47 FADDX1
X24 A[14] B[14] Carry[6] Carry[7] SUM[14] _NC48 _NC49 FADDX1
X25 A[15] B[15] Carry[7] Carry[8] SUM[15] _NC50 _NC51 FADDX1
X26 A[16] B[16] Carry[8] Carry[9] SUM[16] _NC52 _NC53 FADDX1
X27 A[17] B[17] Carry[9] Carry[10] SUM[17] _NC54 _NC55 FADDX1
X28 A[18] B[18] Carry[10] Carry[11] SUM[18] _NC56 _NC57 FADDX1
.ENDS mul_24_DW01_add_3

.SUBCKT pre_norm_mul Clk_i Opa_i[0] Opa_i[1] Opa_i[2] Opa_i[3] Opa_i[4] Opa_i[5] Opa_i[6] Opa_i[7] Opa_i[8] Opa_i[9] Opa_i[10] Opa_i[11] Opa_i[12] Opa_i[13] Opa_i[14] Opa_i[15] Opa_i[16] Opa_i[17] Opa_i[18] Opa_i[19] Opa_i[20] Opa_i[21] Opa_i[22] Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Opa_i[31] Opb_i[0] Opb_i[1] Opb_i[2] Opb_i[3] Opb_i[4] Opb_i[5] Opb_i[6] Opb_i[7] Opb_i[8] Opb_i[9] Opb_i[10] Opb_i[11] Opb_i[12] Opb_i[13] Opb_i[14] Opb_i[15] Opb_i[16] Opb_i[17] Opb_i[18] Opb_i[19] Opb_i[20] Opb_i[21] Opb_i[22] Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Opb_i[31] Exp_10_o[0] Exp_10_o[1] Exp_10_o[2] Exp_10_o[3] Exp_10_o[4] Exp_10_o[5] Exp_10_o[6] Exp_10_o[7] Exp_10_o[8] Exp_10_o[9] Fracta_24_o[0] Fracta_24_o[1] Fracta_24_o[2] Fracta_24_o[3] Fracta_24_o[4] Fracta_24_o[5] Fracta_24_o[6] Fracta_24_o[7] Fracta_24_o[8] Fracta_24_o[9] Fracta_24_o[10] Fracta_24_o[11] Fracta_24_o[12] Fracta_24_o[13] Fracta_24_o[14] Fracta_24_o[15] Fracta_24_o[16] Fracta_24_o[17] Fracta_24_o[18] Fracta_24_o[19] Fracta_24_o[20] Fracta_24_o[21] Fracta_24_o[22] Fracta_24_o[23] Fractb_24_o[0] Fractb_24_o[1] Fractb_24_o[2] Fractb_24_o[3] Fractb_24_o[4] Fractb_24_o[5] Fractb_24_o[6] Fractb_24_o[7] Fractb_24_o[8] Fractb_24_o[9] Fractb_24_o[10] Fractb_24_o[11] Fractb_24_o[12] Fractb_24_o[13] Fractb_24_o[14] Fractb_24_o[15] Fractb_24_o[16] Fractb_24_o[17] Fractb_24_o[18] Fractb_24_o[19] Fractb_24_o[20] Fractb_24_o[21] Fractb_24_o[22] Fractb_24_o[23]
X0 Fractb_24_o[23] Add_0_root_add_1_root_sub_101_B[0] S_exp_10_o[0] _NC0 _NC1 XOR2X1
X1 Fractb_24_o[23] Add_0_root_add_1_root_sub_101_B[0] Add_0_root_add_1_root_sub_101_carry[0] _NC2 _NC3 AND2X1
X2 Add_0_root_add_1_root_sub_101_B[2] Add_0_root_add_1_root_sub_101_carry[1] S_exp_10_o[2] _NC4 _NC5 XOR2X1
X3 Add_0_root_add_1_root_sub_101_B[2] Add_0_root_add_1_root_sub_101_carry[1] Add_0_root_add_1_root_sub_101_carry[2] _NC6 _NC7 AND2X1
X4 Add_0_root_add_1_root_sub_101_B[3] Add_0_root_add_1_root_sub_101_carry[2] S_exp_10_o[3] _NC8 _NC9 XOR2X1
X5 Add_0_root_add_1_root_sub_101_B[3] Add_0_root_add_1_root_sub_101_carry[2] Add_0_root_add_1_root_sub_101_carry[3] _NC10 _NC11 AND2X1
X6 Add_0_root_add_1_root_sub_101_B[4] Add_0_root_add_1_root_sub_101_carry[3] S_exp_10_o[4] _NC12 _NC13 XOR2X1
X7 Add_0_root_add_1_root_sub_101_B[4] Add_0_root_add_1_root_sub_101_carry[3] Add_0_root_add_1_root_sub_101_carry[4] _NC14 _NC15 AND2X1
X8 Add_0_root_add_1_root_sub_101_B[5] Add_0_root_add_1_root_sub_101_carry[4] S_exp_10_o[5] _NC16 _NC17 XOR2X1
X9 Add_0_root_add_1_root_sub_101_B[5] Add_0_root_add_1_root_sub_101_carry[4] Add_0_root_add_1_root_sub_101_carry[5] _NC18 _NC19 AND2X1
X10 Add_0_root_add_1_root_sub_101_B[6] Add_0_root_add_1_root_sub_101_carry[5] S_exp_10_o[6] _NC20 _NC21 XOR2X1
X11 Add_0_root_add_1_root_sub_101_B[6] Add_0_root_add_1_root_sub_101_carry[5] Add_0_root_add_1_root_sub_101_carry[6] _NC22 _NC23 AND2X1
X12 Add_0_root_add_1_root_sub_101_carry[6] Add_0_root_add_1_root_sub_101_B[7] S_exp_10_o[7] _NC24 _NC25 XNOR2X1
X13 Add_0_root_add_1_root_sub_101_B[7] Add_0_root_add_1_root_sub_101_carry[6] Add_0_root_add_1_root_sub_101_carry[7] _NC26 _NC27 OR2X1
X14 Add_0_root_add_1_root_sub_101_carry[7] Add_0_root_add_1_root_sub_101_B[8] S_exp_10_o[8] _NC28 _NC29 XNOR2X1
X15 Opb_i[4] _NC30 _NC31 Fractb_24_o[4] NBUFFX2
X16 Opb_i[5] _NC32 _NC33 Fractb_24_o[5] NBUFFX2
X17 Opb_i[6] _NC34 _NC35 Fractb_24_o[6] NBUFFX2
X18 Opb_i[7] _NC36 _NC37 Fractb_24_o[7] NBUFFX2
X19 Opb_i[8] _NC38 _NC39 Fractb_24_o[8] NBUFFX2
X20 Opb_i[9] _NC40 _NC41 Fractb_24_o[9] NBUFFX2
X21 Opb_i[10] _NC42 _NC43 Fractb_24_o[10] NBUFFX2
X22 Opb_i[11] _NC44 _NC45 Fractb_24_o[11] NBUFFX2
X23 Opb_i[12] _NC46 _NC47 Fractb_24_o[12] NBUFFX2
X24 Opb_i[13] _NC48 _NC49 Fractb_24_o[13] NBUFFX2
X25 Opb_i[14] _NC50 _NC51 Fractb_24_o[14] NBUFFX2
X26 Opb_i[15] _NC52 _NC53 Fractb_24_o[15] NBUFFX2
X27 Opb_i[16] _NC54 _NC55 Fractb_24_o[16] NBUFFX2
X28 Opb_i[17] _NC56 _NC57 Fractb_24_o[17] NBUFFX2
X29 Opb_i[18] _NC58 _NC59 Fractb_24_o[18] NBUFFX2
X30 Opb_i[19] _NC60 _NC61 Fractb_24_o[19] NBUFFX2
X31 Opb_i[20] _NC62 _NC63 Fractb_24_o[20] NBUFFX2
X32 Opb_i[21] _NC64 _NC65 Fractb_24_o[21] NBUFFX2
X33 Opb_i[22] _NC66 _NC67 Fractb_24_o[22] NBUFFX2
X34 Opa_i[0] _NC68 _NC69 Fracta_24_o[0] NBUFFX2
X35 Opa_i[19] _NC70 _NC71 Fracta_24_o[19] NBUFFX2
X36 Opa_i[21] _NC72 _NC73 Fracta_24_o[21] NBUFFX2
X37 Opa_i[22] _NC74 _NC75 Fracta_24_o[22] NBUFFX2
X38 N1 N2 Fractb_24_o[23] _NC76 _NC77 NAND2X1
X39 Opb_i[0] _NC78 _NC79 Fractb_24_o[0] NBUFFX2
X40 N3 N4 Fracta_24_o[23] _NC80 _NC81 NAND2X1
X41 Opb_i[2] _NC82 _NC83 Fractb_24_o[2] NBUFFX2
X42 Fracta_24_o[23] _NC84 _NC85 S_opa_dn INVX0
X43 Opb_i[3] _NC86 _NC87 Fractb_24_o[3] NBUFFX2
X44 Opb_i[1] _NC88 _NC89 Fractb_24_o[1] NBUFFX2
X45 Fractb_24_o[23] _NC90 _NC91 Add_0_root_add_1_root_sub_101_A[1] INVX0
X46 Opa_i[1] _NC92 _NC93 Fracta_24_o[1] NBUFFX2
X47 Opa_i[11] _NC94 _NC95 Fracta_24_o[11] NBUFFX2
X48 Opa_i[20] _NC96 _NC97 Fracta_24_o[20] NBUFFX2
X49 Opa_i[5] _NC98 _NC99 Fracta_24_o[5] NBUFFX2
X50 Opa_i[12] _NC100 _NC101 Fracta_24_o[12] NBUFFX2
X51 Opa_i[18] _NC102 _NC103 Fracta_24_o[18] NBUFFX2
X52 Opa_i[17] _NC104 _NC105 Fracta_24_o[17] NBUFFX2
X53 Opa_i[10] _NC106 _NC107 Fracta_24_o[10] NBUFFX2
X54 Opa_i[7] _NC108 _NC109 Fracta_24_o[7] NBUFFX2
X55 Opa_i[9] _NC110 _NC111 Fracta_24_o[9] NBUFFX2
X56 Opa_i[3] _NC112 _NC113 Fracta_24_o[3] NBUFFX2
X57 Opa_i[8] _NC114 _NC115 Fracta_24_o[8] NBUFFX2
X58 Opa_i[2] _NC116 _NC117 Fracta_24_o[2] NBUFFX2
X59 Opa_i[13] _NC118 _NC119 Fracta_24_o[13] NBUFFX2
X60 Opa_i[15] _NC120 _NC121 Fracta_24_o[15] NBUFFX2
X61 Opa_i[4] _NC122 _NC123 Fracta_24_o[4] NBUFFX2
X62 Add_0_root_add_1_root_sub_101_B[8] Add_0_root_add_1_root_sub_101_carry[7] N5 _NC124 _NC125 NOR2X0
X63 Opa_i[16] _NC126 _NC127 Fracta_24_o[16] NBUFFX2
X64 Opa_i[6] _NC128 _NC129 Fracta_24_o[6] NBUFFX2
X65 Opa_i[14] _NC130 _NC131 Fracta_24_o[14] NBUFFX2
X66 Add_0_root_add_1_root_sub_101_A[1] Add_0_root_add_1_root_sub_101_B[1] Add_0_root_add_1_root_sub_101_carry[0] Add_0_root_add_1_root_sub_101_carry[1] S_exp_10_o[1] _NC132 _NC133 FADDX1
X67 Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Vss Vss Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Vss Vss S_opa_dn Add_0_root_add_1_root_sub_101_B[0] Add_0_root_add_1_root_sub_101_B[1] Add_0_root_add_1_root_sub_101_B[2] Add_0_root_add_1_root_sub_101_B[3] Add_0_root_add_1_root_sub_101_B[4] Add_0_root_add_1_root_sub_101_B[5] Add_0_root_add_1_root_sub_101_B[6] Add_0_root_add_1_root_sub_101_B[7] Add_0_root_add_1_root_sub_101_B[8] SYNOPSYS_UNCONNECTED__0 _NC134 pre_norm_mul_DW01_add_1
X68 Opa_i[26] Opa_i[25] Opa_i[24] Opa_i[23] N3 _NC135 _NC136 NOR4X0
X69 Opa_i[30] Opa_i[29] Opa_i[28] Opa_i[27] N4 _NC137 _NC138 NOR4X0
X70 Opb_i[26] Opb_i[25] Opb_i[24] Opb_i[23] N1 _NC139 _NC140 NOR4X0
X71 Opb_i[30] Opb_i[29] Opb_i[28] Opb_i[27] N2 _NC141 _NC142 NOR4X0
X72 Clk_i S_exp_10_o[0] Exp_10_o[0] _NC143 _NC144 _NC145 DFFX1
X73 Clk_i S_exp_10_o[1] Exp_10_o[1] _NC146 _NC147 _NC148 DFFX1
X74 Clk_i S_exp_10_o[2] Exp_10_o[2] _NC149 _NC150 _NC151 DFFX1
X75 Clk_i S_exp_10_o[3] Exp_10_o[3] _NC152 _NC153 _NC154 DFFX1
X76 Clk_i S_exp_10_o[4] Exp_10_o[4] _NC155 _NC156 _NC157 DFFX1
X77 Clk_i S_exp_10_o[5] Exp_10_o[5] _NC158 _NC159 _NC160 DFFX1
X78 Clk_i S_exp_10_o[6] Exp_10_o[6] _NC161 _NC162 _NC163 DFFX1
X79 Clk_i S_exp_10_o[7] Exp_10_o[7] _NC164 _NC165 _NC166 DFFX1
X80 Clk_i S_exp_10_o[8] Exp_10_o[8] _NC167 _NC168 _NC169 DFFX1
X81 Clk_i N5 Exp_10_o[9] _NC170 _NC171 _NC172 DFFX1
.ENDS pre_norm_mul

.SUBCKT pre_norm_mul_DW01_add_1 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] CO
X0 A[0] B[0] CI Carry[0] SUM[0] _NC0 _NC1 FADDX1
X1 A[1] B[1] Carry[0] Carry[1] SUM[1] _NC2 _NC3 FADDX1
X2 A[2] B[2] Carry[1] Carry[2] SUM[2] _NC4 _NC5 FADDX1
X3 A[3] B[3] Carry[2] Carry[3] SUM[3] _NC6 _NC7 FADDX1
X4 A[4] B[4] Carry[3] Carry[4] SUM[4] _NC8 _NC9 FADDX1
X5 A[5] B[5] Carry[4] Carry[5] SUM[5] _NC10 _NC11 FADDX1
X6 A[6] B[6] Carry[5] Carry[6] SUM[6] _NC12 _NC13 FADDX1
X7 A[7] B[7] Carry[6] SUM[8] SUM[7] _NC14 _NC15 FADDX1
.ENDS pre_norm_mul_DW01_add_1

.SUBCKT post_norm_addsub Clk_i Opa_i[0] Opa_i[1] Opa_i[2] Opa_i[3] Opa_i[4] Opa_i[5] Opa_i[6] Opa_i[7] Opa_i[8] Opa_i[9] Opa_i[10] Opa_i[11] Opa_i[12] Opa_i[13] Opa_i[14] Opa_i[15] Opa_i[16] Opa_i[17] Opa_i[18] Opa_i[19] Opa_i[20] Opa_i[21] Opa_i[22] Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Opa_i[31] Opb_i[0] Opb_i[1] Opb_i[2] Opb_i[3] Opb_i[4] Opb_i[5] Opb_i[6] Opb_i[7] Opb_i[8] Opb_i[9] Opb_i[10] Opb_i[11] Opb_i[12] Opb_i[13] Opb_i[14] Opb_i[15] Opb_i[16] Opb_i[17] Opb_i[18] Opb_i[19] Opb_i[20] Opb_i[21] Opb_i[22] Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Opb_i[31] Fract_28_i[0] Fract_28_i[1] Fract_28_i[2] Fract_28_i[3] Fract_28_i[4] Fract_28_i[5] Fract_28_i[6] Fract_28_i[7] Fract_28_i[8] Fract_28_i[9] Fract_28_i[10] Fract_28_i[11] Fract_28_i[12] Fract_28_i[13] Fract_28_i[14] Fract_28_i[15] Fract_28_i[16] Fract_28_i[17] Fract_28_i[18] Fract_28_i[19] Fract_28_i[20] Fract_28_i[21] Fract_28_i[22] Fract_28_i[23] Fract_28_i[24] Fract_28_i[25] Fract_28_i[26] Fract_28_i[27] Exp_i[0] Exp_i[1] Exp_i[2] Exp_i[3] Exp_i[4] Exp_i[5] Exp_i[6] Exp_i[7] Sign_i Fpu_op_i Rmode_i[0] Rmode_i[1] Output_o[0] Output_o[1] Output_o[2] Output_o[3] Output_o[4] Output_o[5] Output_o[6] Output_o[7] Output_o[8] Output_o[9] Output_o[10] Output_o[11] Output_o[12] Output_o[13] Output_o[14] Output_o[15] Output_o[16] Output_o[17] Output_o[18] Output_o[19] Output_o[20] Output_o[21] Output_o[22] Output_o[23] Output_o[24] Output_o[25] Output_o[26] Output_o[27] Output_o[28] Output_o[29] Output_o[30] Output_o[31] Ine_o
X0 N69 N27 N25 N1008 _NC0 _NC1 NOR3X0
X1 N25 N27 N4500 N1007 _NC2 _NC3 NOR3X0
X2 N4490 N27 N25 N1006 _NC4 _NC5 NOR3X0
X3 N4480 N27 N25 N1005 _NC6 _NC7 NOR3X0
X4 N4470 N27 N25 N1004 _NC8 _NC9 NOR3X0
X5 N25 N27 N4460 N1003 _NC10 _NC11 NOR3X0
X6 N25 N27 N4450 N1002 _NC12 _NC13 NOR3X0
X7 N25 N27 N4440 N1001 _NC14 _NC15 NOR3X0
X8 N58 N4420 N4430 N24 _NC16 _NC17 MUX21X1
X9 N4400 N4390 N4410 N6 _NC18 _NC19 MUX21X1
X10 N438 N437 N4390 N22 _NC20 _NC21 MUX21X1
X11 N436 N435 N438 N5 _NC22 _NC23 MUX21X1
X12 Fract_28_i[27] Fract_28_i[26] N436 N4 _NC24 _NC25 MUX21X1
X13 N70 N4330 N434 N24 _NC26 _NC27 MUX21X1
X14 N4310 N4300 N4320 N23 _NC28 _NC29 MUX21X1
X15 N4290 N4280 N4310 N22 _NC30 _NC31 MUX21X1
X16 N4270 N4260 N4290 N5 _NC32 _NC33 MUX21X1
X17 Fract_28_i[26] Fract_28_i[25] N4270 N4 _NC34 _NC35 MUX21X1
X18 N68 N69 N4250 N24 _NC36 _NC37 MUX21X1
X19 N4230 N4220 N4240 N23 _NC38 _NC39 MUX21X1
X20 N420 N419 N421 N23 _NC40 _NC41 MUX21X1
X21 N418 N417 N420 N22 _NC42 _NC43 MUX21X1
X22 N435 N4160 N418 N5 _NC44 _NC45 MUX21X1
X23 Fract_28_i[25] Fract_28_i[24] N435 N4 _NC46 _NC47 MUX21X1
X24 N67 N4500 N4150 N24 _NC48 _NC49 MUX21X1
X25 N4140 N71 N4500 N23 _NC50 _NC51 MUX21X1
X26 N4110 N4100 N4120 N23 _NC52 _NC53 MUX21X1
X27 N4090 N4080 N4110 N22 _NC54 _NC55 MUX21X1
X28 N4260 N4070 N4090 N5 _NC56 _NC57 MUX21X1
X29 Fract_28_i[24] Fract_28_i[23] N4260 N4 _NC58 _NC59 MUX21X1
X30 N66 N4490 N4060 N24 _NC60 _NC61 MUX21X1
X31 N403 N402 N404 N23 _NC62 _NC63 MUX21X1
X32 N437 N401 N403 N22 _NC64 _NC65 MUX21X1
X33 N4160 N400 N437 N5 _NC66 _NC67 MUX21X1
X34 Fract_28_i[23] Fract_28_i[22] N4160 N4 _NC68 _NC69 MUX21X1
X35 N65 N4480 N3990 N24 _NC70 _NC71 MUX21X1
X36 N3980 N2 N4480 _NC72 _NC73 OR2X1
X37 N3960 N3950 N3970 N23 _NC74 _NC75 MUX21X1
X38 N4280 N3940 N3960 N22 _NC76 _NC77 MUX21X1
X39 N4070 N3930 N4280 N5 _NC78 _NC79 MUX21X1
X40 Fract_28_i[22] Fract_28_i[21] N4070 N4 _NC80 _NC81 MUX21X1
X41 N64 N4470 N3920 N24 _NC82 _NC83 MUX21X1
X42 N3910 N2 N4470 _NC84 _NC85 OR2X1
X43 N3890 N3880 N3900 N23 _NC86 _NC87 MUX21X1
X44 N417 N387 N3890 N22 _NC88 _NC89 MUX21X1
X45 N400 N386 N417 N5 _NC90 _NC91 MUX21X1
X46 Fract_28_i[21] Fract_28_i[20] N400 N4 _NC92 _NC93 MUX21X1
X47 N63 N4460 N385 N24 _NC94 _NC95 MUX21X1
X48 N384 N2 N4460 _NC96 _NC97 OR2X1
X49 N3820 N3810 N383 N23 _NC98 _NC99 MUX21X1
X50 N4080 N3800 N3820 N22 _NC100 _NC101 MUX21X1
X51 N3930 N3790 N4080 N5 _NC102 _NC103 MUX21X1
X52 Fract_28_i[20] Fract_28_i[19] N3930 N4 _NC104 _NC105 MUX21X1
X53 N3780 N27 N25 N1000 _NC106 _NC107 NOR3X0
X54 N62 N4450 N3770 N24 _NC108 _NC109 MUX21X1
X55 N3760 N2 N4450 _NC110 _NC111 OR2X1
X56 N4400 N3740 N3750 N23 _NC112 _NC113 MUX21X1
X57 N401 N3730 N4400 N22 _NC114 _NC115 MUX21X1
X58 N386 N3720 N401 N5 _NC116 _NC117 MUX21X1
X59 Fract_28_i[19] Fract_28_i[18] N386 N4 _NC118 _NC119 MUX21X1
X60 N61 N4440 N3710 N24 _NC120 _NC121 MUX21X1
X61 N370 N2 N4440 _NC122 _NC123 OR2X1
X62 N4300 N368 N369 N2 _NC124 _NC125 MUX21X1
X63 N3940 N367 N4300 N22 _NC126 _NC127 MUX21X1
X64 N3790 N366 N3940 N5 _NC128 _NC129 MUX21X1
X65 Fract_28_i[18] N18 N3790 N4 _NC130 _NC131 MUX21X1
X66 N60 N3780 N3650 N24 _NC132 _NC133 MUX21X1
X67 N419 N4230 N3630 N2 _NC134 _NC135 MUX21X1
X68 N3620 N3610 N4230 N22 _NC136 _NC137 MUX21X1
X69 N387 N3600 N419 N22 _NC138 _NC139 MUX21X1
X70 N3720 N3590 N387 N5 _NC140 _NC141 MUX21X1
X71 N18 Fract_28_i[16] N3720 N4 _NC142 _NC143 MUX21X1
X72 N3570 N3560 N3580 N24 _NC144 _NC145 MUX21X1
X73 N77 N4140 N3570 N23 _NC146 _NC147 MUX21X1
X74 N79 N3550 N4140 N22 _NC148 _NC149 MUX21X1
X75 N3800 N353 N4100 N22 _NC150 _NC151 MUX21X1
X76 N366 N352 N3800 N5 _NC152 _NC153 MUX21X1
X77 Fract_28_i[16] Fract_28_i[15] N366 N4 _NC154 _NC155 MUX21X1
X78 N25 N27 N59 N1014 _NC156 _NC157 NOR3X0
X79 N402 N405 N351 N2 _NC158 _NC159 MUX21X1
X80 N350 N349 N405 N22 _NC160 _NC161 MUX21X1
X81 N3730 N3480 N402 N3 _NC162 _NC163 MUX21X1
X82 N3590 N3470 N3730 N21 _NC164 _NC165 MUX21X1
X83 Fract_28_i[15] Fract_28_i[14] N3590 N4 _NC166 _NC167 MUX21X1
X84 N25 N27 N3460 N1013 _NC168 _NC169 NOR3X0
X85 N76 N3980 N3460 N2 _NC170 _NC171 MUX21X1
X86 N78 N3450 N3980 N3 _NC172 _NC173 MUX21X1
X87 N367 N3430 N3950 N3 _NC174 _NC175 MUX21X1
X88 N352 N3420 N367 N21 _NC176 _NC177 MUX21X1
X89 Fract_28_i[14] Fract_28_i[13] N352 N4 _NC178 _NC179 MUX21X1
X90 N25 N27 N3410 N1012 _NC180 _NC181 NOR3X0
X91 N75 N3910 N3410 N2 _NC182 _NC183 MUX21X1
X92 N80 N3640 N3910 N3 _NC184 _NC185 MUX21X1
X93 N3390 N3380 N3610 N21 _NC186 _NC187 MUX21X1
X94 N3600 N3620 N3880 N3 _NC188 _NC189 MUX21X1
X95 N3370 N336 N3620 N21 _NC190 _NC191 MUX21X1
X96 N3470 N335 N3600 N21 _NC192 _NC193 MUX21X1
X97 Fract_28_i[13] Fract_28_i[12] N3470 N4 _NC194 _NC195 MUX21X1
X98 N334 N27 N25 N1011 _NC196 _NC197 NOR3X0
X99 N74 N384 N334 N2 _NC198 _NC199 MUX21X1
X100 N3550 N333 N384 N3 _NC200 _NC201 MUX21X1
X101 N81 N82 N3550 N21 _NC202 _NC203 MUX21X1
X102 N353 N3540 N3810 N3 _NC204 _NC205 MUX21X1
X103 N3310 N3300 N3540 N21 _NC206 _NC207 MUX21X1
X104 N3420 N3290 N353 N21 _NC208 _NC209 MUX21X1
X105 Fract_28_i[12] N16 N3420 N20 _NC210 _NC211 MUX21X1
X106 N4420 N27 N25 N1010 _NC212 _NC213 NOR3X0
X107 N73 N3760 N4420 N2 _NC214 _NC215 MUX21X1
X108 N3380 N3400 N349 N21 _NC216 _NC217 MUX21X1
X109 Fract_28_i[1] Fract_28_i[0] N3400 N20 _NC218 _NC219 MUX21X1
X110 Fract_28_i[3] Fract_28_i[2] N3380 N20 _NC220 _NC221 MUX21X1
X111 N3480 N350 N3740 N3 _NC222 _NC223 MUX21X1
X112 N336 N3390 N350 N21 _NC224 _NC225 MUX21X1
X113 N14 Fract_28_i[4] N3390 N20 _NC226 _NC227 MUX21X1
X114 Fract_28_i[7] Fract_28_i[6] N336 N20 _NC228 _NC229 MUX21X1
X115 N335 N3370 N3480 N21 _NC230 _NC231 MUX21X1
X116 Fract_28_i[9] Fract_28_i[8] N3370 N20 _NC232 _NC233 MUX21X1
X117 N16 Fract_28_i[10] N335 N20 _NC234 _NC235 MUX21X1
X118 N4330 N26 N25 N1009 _NC236 _NC237 NOR3X0
X119 N72 N370 N4330 N23 _NC238 _NC239 MUX21X1
X120 N3450 N3 N370 _NC240 _NC241 OR2X1
X121 N82 N3280 N3450 N21 _NC242 _NC243 MUX21X1
X122 Fract_28_i[2] Fract_28_i[1] N3270 N20 _NC244 _NC245 MUX21X1
X123 N3430 N3440 N368 N22 _NC246 _NC247 MUX21X1
X124 N3300 N332 N3440 N5 _NC248 _NC249 MUX21X1
X125 Fract_28_i[4] Fract_28_i[3] N332 N20 _NC250 _NC251 MUX21X1
X126 Fract_28_i[6] N14 N3300 N20 _NC252 _NC253 MUX21X1
X127 N3290 N3310 N3430 N5 _NC254 _NC255 MUX21X1
X128 Fract_28_i[8] Fract_28_i[7] N3310 N20 _NC256 _NC257 MUX21X1
X129 Fract_28_i[10] Fract_28_i[9] N3290 N20 _NC258 _NC259 MUX21X1
X130 N3560 N26 N25 N999 _NC260 _NC261 NOR3X0
X131 N3280 N5 N333 _NC262 _NC263 OR2X1
X132 Fract_28_i[9] Fract_28_i[10] N980 S_shr1[0] _NC264 _NC265 MUX21X1
X133 Fract_28_i[8] Fract_28_i[9] N979 S_shr1[0] _NC266 _NC267 MUX21X1
X134 Fract_28_i[7] Fract_28_i[8] N978 S_shr1[0] _NC268 _NC269 MUX21X1
X135 Fract_28_i[6] Fract_28_i[7] N977 S_shr1[0] _NC270 _NC271 MUX21X1
X136 N14 Fract_28_i[6] N976 S_shr1[0] _NC272 _NC273 MUX21X1
X137 Fract_28_i[4] N14 N975 S_shr1[0] _NC274 _NC275 MUX21X1
X138 Fract_28_i[3] Fract_28_i[4] N974 S_shr1[0] _NC276 _NC277 MUX21X1
X139 Fract_28_i[2] Fract_28_i[3] N973 S_shr1[0] _NC278 _NC279 MUX21X1
X140 Fract_28_i[26] Fract_28_i[27] N997 S_shr1[0] _NC280 _NC281 MUX21X1
X141 Fract_28_i[25] Fract_28_i[26] N996 S_shr1[0] _NC282 _NC283 MUX21X1
X142 Fract_28_i[24] Fract_28_i[25] N995 N28 _NC284 _NC285 MUX21X1
X143 Fract_28_i[23] Fract_28_i[24] N994 N28 _NC286 _NC287 MUX21X1
X144 Fract_28_i[22] Fract_28_i[23] N993 N28 _NC288 _NC289 MUX21X1
X145 Fract_28_i[21] Fract_28_i[22] N992 N28 _NC290 _NC291 MUX21X1
X146 Fract_28_i[20] Fract_28_i[21] N991 N28 _NC292 _NC293 MUX21X1
X147 Fract_28_i[1] Fract_28_i[2] N972 N28 _NC294 _NC295 MUX21X1
X148 Fract_28_i[19] Fract_28_i[20] N990 N28 _NC296 _NC297 MUX21X1
X149 Fract_28_i[18] Fract_28_i[19] N989 N28 _NC298 _NC299 MUX21X1
X150 N18 Fract_28_i[18] N988 N28 _NC300 _NC301 MUX21X1
X151 Fract_28_i[16] N18 N987 N28 _NC302 _NC303 MUX21X1
X152 Fract_28_i[15] Fract_28_i[16] N986 N28 _NC304 _NC305 MUX21X1
X153 Fract_28_i[14] Fract_28_i[15] N985 N28 _NC306 _NC307 MUX21X1
X154 Fract_28_i[13] Fract_28_i[14] N984 N28 _NC308 _NC309 MUX21X1
X155 Fract_28_i[12] Fract_28_i[13] N983 N28 _NC310 _NC311 MUX21X1
X156 N16 Fract_28_i[12] N982 N28 _NC312 _NC313 MUX21X1
X157 Fract_28_i[10] N16 N981 N28 _NC314 _NC315 MUX21X1
X158 Fract_28_i[0] Fract_28_i[1] N971 N28 _NC316 _NC317 MUX21X1
X159 N188 N102 N194 _NC318 _NC319 AND2X1
X160 Sub_172_aco_carry[7] _NC320 _NC321 S_expo9_2[8] INVX0
X161 Exp_i[5] N41 N925 _NC322 _NC323 XOR2X1
X162 Exp_i[4] N44 N41 _NC324 _NC325 NOR2X0
X163 Exp_i[4] N44 N924 _NC326 _NC327 XNOR2X1
X164 Exp_i[3] N43 N38 N923 _NC328 _NC329 AO21X1
X165 N43 Exp_i[3] N38 _NC330 _NC331 NOR2X0
X166 Exp_i[2] N42 N37 N922 _NC332 _NC333 AO21X1
X167 N42 Exp_i[2] N37 _NC334 _NC335 NOR2X0
X168 Exp_i[1] Exp_i[0] N36 N921 _NC336 _NC337 AO21X1
X169 Exp_i[1] Exp_i[0] N36 _NC338 _NC339 NOR2X0
X170 Exp_i[0] _NC340 _NC341 N920 INVX0
X171 Add_90_I27_L07002_C129_carry[3] N535 N546 _NC342 _NC343 XOR2X1
X172 N530 _NC344 _NC345 N541 INVX0
X173 Add_90_I26_L07002_C129_carry[3] N518 N529 _NC346 _NC347 XOR2X1
X174 N513 _NC348 _NC349 N524 INVX0
X175 Add_90_I25_L07002_C129_carry[3] N501 N512 _NC350 _NC351 XOR2X1
X176 N496 _NC352 _NC353 N507 INVX0
X177 Add_90_I24_L07002_C129_carry[3] N484 N495 _NC354 _NC355 XOR2X1
X178 N479 _NC356 _NC357 N490 INVX0
X179 Add_90_I23_L07002_C129_carry[3] N467 N478 _NC358 _NC359 XOR2X1
X180 N462 _NC360 _NC361 N473 INVX0
X181 Add_90_I22_L07002_C129_carry[3] N450 N461 _NC362 _NC363 XOR2X1
X182 N445 _NC364 _NC365 N456 INVX0
X183 Add_90_I21_L07002_C129_carry[3] N433 N444 _NC366 _NC367 XOR2X1
X184 N428 _NC368 _NC369 N439 INVX0
X185 Add_90_I20_L07002_C129_carry[3] N416 N427 _NC370 _NC371 XOR2X1
X186 N411 _NC372 _NC373 N422 INVX0
X187 Add_90_I19_L07002_C129_carry[3] N399 N410 _NC374 _NC375 XOR2X1
X188 Add_90_I18_L07002_C129_carry[3] N382 N393 _NC376 _NC377 XOR2X1
X189 N377 _NC378 _NC379 N388 INVX0
X190 Add_90_I17_L07002_C129_carry[3] N365 N376 _NC380 _NC381 XOR2X1
X191 N360 _NC382 _NC383 N371 INVX0
X192 Add_90_I16_L07002_C129_carry[3] N348 N359 _NC384 _NC385 XOR2X1
X193 N343 _NC386 _NC387 N354 INVX0
X194 Add_90_I15_L07002_C129_carry[3] N331 N342 _NC388 _NC389 XOR2X1
X195 N326 _NC390 _NC391 N337 INVX0
X196 Add_90_I14_L07002_C129_carry[3] N314 N325 _NC392 _NC393 XOR2X1
X197 N309 _NC394 _NC395 N320 INVX0
X198 Add_90_I13_L07002_C129_carry[3] N297 N308 _NC396 _NC397 XOR2X1
X199 N292 _NC398 _NC399 N303 INVX0
X200 Add_90_I12_L07002_C129_carry[3] N280 N291 _NC400 _NC401 XOR2X1
X201 N275 _NC402 _NC403 N286 INVX0
X202 Add_90_I11_L07002_C129_carry[3] N263 N274 _NC404 _NC405 XOR2X1
X203 N258 _NC406 _NC407 N269 INVX0
X204 Add_90_I10_L07002_C129_carry[3] N246 N257 _NC408 _NC409 XOR2X1
X205 N241 _NC410 _NC411 N252 INVX0
X206 Add_90_I9_L07002_C129_carry[3] N229 N240 _NC412 _NC413 XOR2X1
X207 N224 _NC414 _NC415 N235 INVX0
X208 N207 _NC416 _NC417 N218 INVX0
X209 N190 _NC418 _NC419 N201 INVX0
X210 N174 _NC420 _NC421 N184 INVX0
X211 N160 _NC422 _NC423 N169 INVX0
X212 Fract_28_i[27] Exp_i[0] Sub_0_root_add_0_root_sub_132_A[0] _NC424 _NC425 XOR2X1
X213 Fract_28_i[27] Exp_i[0] Add_1_root_add_0_root_sub_132_carry[0] _NC426 _NC427 AND2X1
X214 Exp_i[1] Add_1_root_add_0_root_sub_132_carry[0] Sub_0_root_add_0_root_sub_132_A[1] _NC428 _NC429 XOR2X1
X215 Exp_i[1] Add_1_root_add_0_root_sub_132_carry[0] Add_1_root_add_0_root_sub_132_carry[1] _NC430 _NC431 AND2X1
X216 Exp_i[2] Add_1_root_add_0_root_sub_132_carry[1] Sub_0_root_add_0_root_sub_132_A[2] _NC432 _NC433 XOR2X1
X217 Exp_i[2] Add_1_root_add_0_root_sub_132_carry[1] Add_1_root_add_0_root_sub_132_carry[2] _NC434 _NC435 AND2X1
X218 Exp_i[3] Add_1_root_add_0_root_sub_132_carry[2] Sub_0_root_add_0_root_sub_132_A[3] _NC436 _NC437 XOR2X1
X219 Exp_i[3] Add_1_root_add_0_root_sub_132_carry[2] Add_1_root_add_0_root_sub_132_carry[3] _NC438 _NC439 AND2X1
X220 Exp_i[4] Add_1_root_add_0_root_sub_132_carry[3] Sub_0_root_add_0_root_sub_132_A[4] _NC440 _NC441 XOR2X1
X221 Exp_i[4] Add_1_root_add_0_root_sub_132_carry[3] Add_1_root_add_0_root_sub_132_carry[4] _NC442 _NC443 AND2X1
X222 Exp_i[5] Add_1_root_add_0_root_sub_132_carry[4] Sub_0_root_add_0_root_sub_132_A[5] _NC444 _NC445 XOR2X1
X223 Exp_i[5] Add_1_root_add_0_root_sub_132_carry[4] Add_1_root_add_0_root_sub_132_carry[5] _NC446 _NC447 AND2X1
X224 Exp_i[6] Add_1_root_add_0_root_sub_132_carry[5] Sub_0_root_add_0_root_sub_132_A[6] _NC448 _NC449 XOR2X1
X225 Exp_i[6] Add_1_root_add_0_root_sub_132_carry[5] Add_1_root_add_0_root_sub_132_carry[6] _NC450 _NC451 AND2X1
X226 Exp_i[7] Add_1_root_add_0_root_sub_132_carry[6] Sub_0_root_add_0_root_sub_132_A[7] _NC452 _NC453 XOR2X1
X227 Add_1_root_add_0_root_sub_132_carry[6] Exp_i[7] Sub_0_root_add_0_root_sub_132_A[8] _NC454 _NC455 AND2X1
X228 N34 Sub_0_root_add_0_root_sub_132_A[0] S_exp10[0] _NC456 _NC457 XNOR2X1
X229 Sub_0_root_add_0_root_sub_132_A[0] N34 Sub_0_root_add_0_root_sub_132_carry[0] _NC458 _NC459 OR2X1
X230 Sub_0_root_add_0_root_sub_132_carry[5] Sub_0_root_add_0_root_sub_132_A[6] S_exp10[6] _NC460 _NC461 XNOR2X1
X231 Sub_0_root_add_0_root_sub_132_A[6] Sub_0_root_add_0_root_sub_132_carry[5] Sub_0_root_add_0_root_sub_132_carry[6] _NC462 _NC463 OR2X1
X232 Sub_0_root_add_0_root_sub_132_carry[6] Sub_0_root_add_0_root_sub_132_A[7] S_exp10[7] _NC464 _NC465 XNOR2X1
X233 Sub_0_root_add_0_root_sub_132_A[7] Sub_0_root_add_0_root_sub_132_carry[6] Sub_0_root_add_0_root_sub_132_carry[7] _NC466 _NC467 OR2X1
X234 Sub_0_root_add_0_root_sub_132_carry[7] Sub_0_root_add_0_root_sub_132_A[8] S_exp10[8] _NC468 _NC469 XNOR2X1
X235 N13 S_expo9_1[0] S_expo9_2[0] _NC470 _NC471 XNOR2X1
X236 S_expo9_1[0] N13 Sub_172_aco_carry[0] _NC472 _NC473 OR2X1
X237 Sub_172_aco_carry[0] S_expo9_1[1] S_expo9_2[1] _NC474 _NC475 XNOR2X1
X238 S_expo9_1[1] Sub_172_aco_carry[0] Sub_172_aco_carry[1] _NC476 _NC477 OR2X1
X239 Sub_172_aco_carry[1] S_expo9_1[2] S_expo9_2[2] _NC478 _NC479 XNOR2X1
X240 S_expo9_1[2] Sub_172_aco_carry[1] Sub_172_aco_carry[2] _NC480 _NC481 OR2X1
X241 Sub_172_aco_carry[2] S_expo9_1[3] S_expo9_2[3] _NC482 _NC483 XNOR2X1
X242 S_expo9_1[3] Sub_172_aco_carry[2] Sub_172_aco_carry[3] _NC484 _NC485 OR2X1
X243 Sub_172_aco_carry[3] S_expo9_1[4] S_expo9_2[4] _NC486 _NC487 XNOR2X1
X244 S_expo9_1[4] Sub_172_aco_carry[3] Sub_172_aco_carry[4] _NC488 _NC489 OR2X1
X245 Sub_172_aco_carry[4] S_expo9_1[5] S_expo9_2[5] _NC490 _NC491 XNOR2X1
X246 S_expo9_1[5] Sub_172_aco_carry[4] Sub_172_aco_carry[5] _NC492 _NC493 OR2X1
X247 Sub_172_aco_carry[5] S_expo9_1[6] S_expo9_2[6] _NC494 _NC495 XNOR2X1
X248 S_expo9_1[6] Sub_172_aco_carry[5] Sub_172_aco_carry[6] _NC496 _NC497 OR2X1
X249 Sub_172_aco_carry[6] S_expo9_1[7] S_expo9_2[7] _NC498 _NC499 XNOR2X1
X250 S_expo9_1[7] Sub_172_aco_carry[6] Sub_172_aco_carry[7] _NC500 _NC501 OR2X1
X251 N29 _NC502 _NC503 N28 INVX0
X252 N6 _NC504 _NC505 N23 INVX0
X253 S_shl1[1] _NC506 _NC507 N27 NBUFFX2
X254 S_shl1[0] _NC508 _NC509 N24 NBUFFX2
X255 S_shl1[0] _NC510 _NC511 N25 NBUFFX2
X256 S_shr1[0] _NC512 _NC513 N29 INVX0
X257 N3270 _NC514 _NC515 N82 INVX0
X258 S_fracto28_1[27] S_fracto28_1[26] N13 _NC516 _NC517 OR2X1
X259 Fract_28_i[0] N8 N3280 _NC518 _NC519 NAND2X1
X260 N2900 N2910 N121 _NC520 _NC521 NOR2X0
X261 N351 _NC522 _NC523 N59 INVX0
X262 N26 N4060 N1022 _NC524 _NC525 NOR2X0
X263 N26 N3650 N1016 _NC526 _NC527 NOR2X0
X264 N26 N3990 N1021 _NC528 _NC529 NOR2X0
X265 N26 N3580 N1015 _NC530 _NC531 NOR2X0
X266 N26 N434 N1025 _NC532 _NC533 NOR2X0
X267 N26 N4150 N1023 _NC534 _NC535 NOR2X0
X268 N26 N4250 N1024 _NC536 _NC537 NOR2X0
X269 N26 N3920 N1020 _NC538 _NC539 NOR2X0
X270 N26 N385 N1019 _NC540 _NC541 NOR2X0
X271 N26 N3770 N1018 _NC542 _NC543 NOR2X0
X272 N26 N3710 N1017 _NC544 _NC545 NOR2X0
X273 Fract_28_i[2] _NC546 _NC547 N319 INVX0
X274 Fract_28_i[1] _NC548 _NC549 N3200 INVX0
X275 N118 N119 N115 _NC550 _NC551 NAND2X1
X276 N115 _NC552 _NC553 N3220 INVX0
X277 Fract_28_i[23] Fract_28_i[24] N2220 _NC554 _NC555 NOR2X0
X278 Fract_28_i[4] _NC556 _NC557 N317 INVX0
X279 Fract_28_i[6] _NC558 _NC559 N3140 INVX0
X280 Fract_28_i[3] _NC560 _NC561 N318 INVX0
X281 N2590 Fract_28_i[20] N2570 _NC562 _NC563 NOR2X0
X282 N2580 Fract_28_i[18] N1600 _NC564 _NC565 NOR2X0
X283 N2920 N2930 N129 _NC566 _NC567 NOR2X0
X284 Fract_28_i[8] _NC568 _NC569 N3120 INVX0
X285 N2750 Fract_28_i[2] N2760 _NC570 _NC571 NOR2X0
X286 Fract_28_i[7] _NC572 _NC573 N3130 INVX0
X287 Fract_28_i[9] _NC574 _NC575 N3110 INVX0
X288 N264 Fract_28_i[14] N265 _NC576 _NC577 NOR2X0
X289 Fract_28_i[16] N17 N2630 _NC578 _NC579 NOR2X0
X290 Fract_28_i[4] N14 N2740 _NC580 _NC581 NOR2X0
X291 N2800 Fract_28_i[8] N281 _NC582 _NC583 NOR2X0
X292 N266 Fract_28_i[12] N1700 _NC584 _NC585 NOR2X0
X293 Fract_28_i[10] N15 N2790 _NC586 _NC587 NOR2X0
X294 N39 N107 N111 _NC588 _NC589 NAND2X1
X295 Rmode_i[0] _NC590 _NC591 N3250 INVX0
X296 Fract_28_i[0] _NC592 _NC593 N3210 INVX0
X297 Fract_28_i[10] _NC594 _NC595 N3100 INVX0
X298 Fract_28_i[12] _NC596 _NC597 N3070 INVX0
X299 Fract_28_i[27] _NC598 _NC599 N84 INVX0
X300 Fract_28_i[13] _NC600 _NC601 N3060 INVX0
X301 Fract_28_i[5] _NC602 _NC603 N14 NBUFFX2
X302 N3210 N84 N112 _NC604 _NC605 NOR2X0
X303 Rmode_i[1] N3250 N110 _NC606 _NC607 NAND2X1
X304 Rmode_i[1] _NC608 _NC609 N3240 INVX0
X305 N105 N106 S_roundup _NC610 _NC611 NAND2X1
X306 Fract_28_i[16] _NC612 _NC613 N3030 INVX0
X307 Fract_28_i[14] _NC614 _NC615 N3050 INVX0
X308 Fract_28_i[15] _NC616 _NC617 N3040 INVX0
X309 Fract_28_i[27] Fract_28_i[26] N2520 _NC618 _NC619 NOR2X0
X310 Fract_28_i[22] _NC620 _NC621 N101 INVX0
X311 Fract_28_i[18] _NC622 _NC623 N126 INVX0
X312 Fract_28_i[21] _NC624 _NC625 N102 INVX0
X313 Fract_28_i[20] _NC626 _NC627 N103 INVX0
X314 Fract_28_i[19] _NC628 _NC629 N104 INVX0
X315 Fract_28_i[11] _NC630 _NC631 N15 NBUFFX2
X316 Fract_28_i[11] _NC632 _NC633 N16 NBUFFX2
X317 Add_90_I8_L07002_C129_carry[3] N3260 N223 _NC634 _NC635 XNOR2X1
X318 Fract_28_i[24] _NC636 _NC637 N98 INVX0
X319 Fract_28_i[17] _NC638 _NC639 N17 NBUFFX2
X320 Fract_28_i[17] _NC640 _NC641 N18 NBUFFX2
X321 N150 _NC642 _NC643 S_zeros[5] INVX0
X322 Fract_28_i[25] Fract_28_i[26] N282 _NC644 _NC645 NOR2X0
X323 N1930 N191 N2350 _NC646 _NC647 NAND2X1
X324 N2880 Fract_28_i[23] N2860 _NC648 _NC649 NOR2X0
X325 S_zeros[4] _NC650 _NC651 N35 INVX0
X326 S_zeros[3] _NC652 _NC653 N32 INVX0
X327 N149 _NC654 _NC655 S_zeros[2] INVX0
X328 S_zeros[1] _NC656 _NC657 N33 INVX0
X329 N7 _NC658 _NC659 N21 INVX0
X330 N8 _NC660 _NC661 N20 INVX0
X331 N9 _NC662 _NC663 N22 INVX0
X332 N332 _NC664 _NC665 N81 INVX0
X333 N349 N9 N3760 _NC666 _NC667 NAND2X1
X334 N37 _NC668 _NC669 N43 INVX0
X335 N36 _NC670 _NC671 N42 INVX0
X336 N38 _NC672 _NC673 N44 INVX0
X337 N3400 N7 N3640 _NC674 _NC675 NAND2X1
X338 N4220 N6 N3780 _NC676 _NC677 NAND2X1
X339 N1095 N1094 N301 _NC678 _NC679 NAND2X1
X340 N1093 _NC680 _NC681 N56 INVX0
X341 N4130 N6 N3560 _NC682 _NC683 NAND2X1
X342 N405 N6 N4490 _NC684 _NC685 NAND2X1
X343 N4320 _NC686 _NC687 N70 INVX0
X344 N421 _NC688 _NC689 N68 INVX0
X345 N4120 _NC690 _NC691 N67 INVX0
X346 N4410 _NC692 _NC693 N58 INVX0
X347 N4430 N26 N1026 _NC694 _NC695 NOR2X0
X348 N28 N84 N998 _NC696 _NC697 NOR2X0
X349 N1930 N190 N2540 _NC698 _NC699 NAND2X1
X350 N157 N98 N2200 _NC700 _NC701 NAND2X1
X351 N2220 N101 N2210 _NC702 _NC703 NAND2X1
X352 N1600 _NC704 _NC705 N99 INVX0
X353 N129 N130 N117 _NC706 _NC707 NAND2X1
X354 N100 N102 N2590 _NC708 _NC709 NAND2X1
X355 N2570 N104 N2580 _NC710 _NC711 NAND2X1
X356 N2630 N17 N1880 _NC712 _NC713 NOR2X0
X357 N2590 N2570 N164 _NC714 _NC715 NOR2X0
X358 N2580 N1600 N159 _NC716 _NC717 NOR2X0
X359 N281 N3130 N2780 _NC718 _NC719 NAND2X1
X360 N281 N2780 N1870 _NC720 _NC721 NAND2X1
X361 N2790 N2800 N1750 _NC722 _NC723 NAND2X1
X362 N265 N3060 N266 _NC724 _NC725 NAND2X1
X363 N2630 N3040 N264 _NC726 _NC727 NAND2X1
X364 N2740 N318 N2750 _NC728 _NC729 NAND2X1
X365 N2790 N3110 N2800 _NC730 _NC731 NAND2X1
X366 N264 N265 N189 _NC732 _NC733 NOR2X0
X367 N2790 N15 N1850 _NC734 _NC735 NOR2X0
X368 N3090 N3140 N178 _NC736 _NC737 NAND2X1
X369 N2740 N14 N181 _NC738 _NC739 NOR2X0
X370 N266 N1700 N1690 _NC740 _NC741 NOR2X0
X371 N2750 N2760 N183 _NC742 _NC743 NOR2X0
X372 N394 _NC744 _NC745 N97 INVX0
X373 N14 _NC746 _NC747 N315 INVX0
X374 N395 _NC748 _NC749 N96 INVX0
X375 N433 _NC750 _NC751 N47 INVX0
X376 N432 _NC752 _NC753 N52 INVX0
X377 N416 _NC754 _NC755 N48 INVX0
X378 N413 _NC756 _NC757 N91 INVX0
X379 N415 _NC758 _NC759 N53 INVX0
X380 N414 _NC760 _NC761 N87 INVX0
X381 N412 _NC762 _NC763 N95 INVX0
X382 S_fracto28_rnd[27] _NC764 _NC765 N57 INVX0
X383 N2950 N2960 N152 _NC766 _NC767 NAND2X1
X384 N446 _NC768 _NC769 N93 INVX0
X385 N430 _NC770 _NC771 N90 INVX0
X386 N431 _NC772 _NC773 N86 INVX0
X387 N429 _NC774 _NC775 N94 INVX0
X388 S_zeros[0] _NC776 _NC777 N34 INVX0
X389 N127 N125 N124 N12 _NC778 _NC779 AND3X1
X390 N118 N12 S_output_o[22] _NC780 _NC781 OR2X1
X391 N15 _NC782 _NC783 N3080 INVX0
X392 N2720 N2730 N2710 _NC784 _NC785 NOR2X0
X393 N148 S_fracto28_rnd[27] N113 _NC786 _NC787 AND2X1
X394 N2030 N2040 N2020 _NC788 _NC789 NOR2X0
X395 N449 _NC790 _NC791 N51 INVX0
X396 N398 _NC792 _NC793 N54 INVX0
X397 N206 N103 N3260 _NC794 _NC795 NAND2X1
X398 N17 _NC796 _NC797 N302 INVX0
X399 N2370 _NC798 _NC799 Add_90_I5_L07002_C129_A[1] INVX0
X400 N247 N248 N2460 _NC800 _NC801 NOR2X0
X401 N179 N180 N1770 _NC802 _NC803 NOR2X0
X402 N450 _NC804 _NC805 N46 INVX0
X403 N399 _NC806 _NC807 N49 INVX0
X404 N231 N232 N230 _NC808 _NC809 NOR2X0
X405 N447 _NC810 _NC811 N89 INVX0
X406 N396 _NC812 _NC813 N92 INVX0
X407 N216 N217 N215 _NC814 _NC815 NOR2X0
X408 N448 _NC816 _NC817 N85 INVX0
X409 N397 _NC818 _NC819 N88 INVX0
X410 N157 N158 N150 _NC820 _NC821 NAND2X1
X411 Sub_0_root_add_0_root_sub_132_A[8] Sub_0_root_add_0_root_sub_132_carry[7] N11 _NC822 _NC823 NOR2X0
X412 N3640 N22 N4220 _NC824 _NC825 NOR2X0
X413 N333 N22 N4130 _NC826 _NC827 NOR2X0
X414 N368 _NC828 _NC829 N72 INVX0
X415 N3440 _NC830 _NC831 N78 INVX0
X416 N4240 _NC832 _NC833 N69 INVX0
X417 N3610 _NC834 _NC835 N80 INVX0
X418 N3540 _NC836 _NC837 N79 INVX0
X419 N4130 _NC838 _NC839 N71 INVX0
X420 N404 _NC840 _NC841 N66 INVX0
X421 N3970 _NC842 _NC843 N65 INVX0
X422 N3900 _NC844 _NC845 N64 INVX0
X423 N383 _NC846 _NC847 N63 INVX0
X424 N3750 _NC848 _NC849 N62 INVX0
X425 N3740 _NC850 _NC851 N73 INVX0
X426 N4100 _NC852 _NC853 N77 INVX0
X427 N369 _NC854 _NC855 N61 INVX0
X428 N3630 _NC856 _NC857 N60 INVX0
X429 N2200 _NC858 _NC859 N83 INVX0
X430 N117 _NC860 _NC861 N3230 INVX0
X431 N2210 _NC862 _NC863 N100 INVX0
X432 N3090 N178 N1760 _NC864 _NC865 NAND2X1
X433 N2780 _NC866 _NC867 N3090 INVX0
X434 N2770 _NC868 _NC869 N316 INVX0
X435 N124 _NC870 _NC871 N55 INVX0
X436 N148 N57 N114 _NC872 _NC873 AND2X1
X437 N148 N57 N19 _NC874 _NC875 AND2X1
X438 N3260 _NC876 _NC877 N50 INVX0
X439 N153 _NC878 _NC879 N45 INVX0
X440 N45 S_exp10[8] N155 _NC880 _NC881 NOR2X0
X441 N3950 _NC882 _NC883 N76 INVX0
X442 N3880 _NC884 _NC885 N75 INVX0
X443 N3810 _NC886 _NC887 N74 INVX0
X444 N283 N11 N153 _NC888 _NC889 NOR2X0
X445 S_shl1[1] _NC890 _NC891 N26 NBUFFX2
X446 Sub_0_root_add_0_root_sub_132_A[5] N150 Sub_0_root_add_0_root_sub_132_carry[4] Sub_0_root_add_0_root_sub_132_carry[5] S_exp10[5] _NC892 _NC893 FADDX1
X447 Sub_0_root_add_0_root_sub_132_A[4] N35 Sub_0_root_add_0_root_sub_132_carry[3] Sub_0_root_add_0_root_sub_132_carry[4] S_exp10[4] _NC894 _NC895 FADDX1
X448 Sub_0_root_add_0_root_sub_132_A[3] N32 Sub_0_root_add_0_root_sub_132_carry[2] Sub_0_root_add_0_root_sub_132_carry[3] S_exp10[3] _NC896 _NC897 FADDX1
X449 Sub_0_root_add_0_root_sub_132_A[2] N149 Sub_0_root_add_0_root_sub_132_carry[1] Sub_0_root_add_0_root_sub_132_carry[2] S_exp10[2] _NC898 _NC899 FADDX1
X450 Sub_0_root_add_0_root_sub_132_A[1] N33 Sub_0_root_add_0_root_sub_132_carry[0] Sub_0_root_add_0_root_sub_132_carry[1] S_exp10[1] _NC900 _NC901 FADDX1
X451 N162 Add_90_I5_L07002_C129_carry[2] N172 _NC902 _NC903 _NC904 HADDX1
X452 Add_90_I5_L07002_C129_A[1] N160 Add_90_I5_L07002_C129_carry[2] _NC905 _NC906 _NC907 HADDX1
X453 N177 Add_90_I6_L07002_C129_carry[3] N188 _NC908 _NC909 _NC910 HADDX1
X454 N176 Add_90_I6_L07002_C129_carry[2] Add_90_I6_L07002_C129_carry[3] _NC911 _NC912 _NC913 HADDX1
X455 N175 N174 Add_90_I6_L07002_C129_carry[2] _NC914 _NC915 _NC916 HADDX1
X456 N194 Add_90_I7_L07002_C129_carry[2] N206 _NC917 _NC918 _NC919 HADDX1
X457 N193 Add_90_I7_L07002_C129_carry[1] Add_90_I7_L07002_C129_carry[2] _NC920 _NC921 _NC922 HADDX1
X458 N192 Add_90_I7_L07002_C129_carry[0] Add_90_I7_L07002_C129_carry[1] _NC923 _NC924 _NC925 HADDX1
X459 N191 N190 Add_90_I7_L07002_C129_carry[0] _NC926 _NC927 _NC928 HADDX1
X460 N211 Add_90_I8_L07002_C129_carry[2] Add_90_I8_L07002_C129_carry[3] _NC929 _NC930 _NC931 HADDX1
X461 N210 Add_90_I8_L07002_C129_carry[1] Add_90_I8_L07002_C129_carry[2] _NC932 _NC933 _NC934 HADDX1
X462 N209 Add_90_I8_L07002_C129_carry[0] Add_90_I8_L07002_C129_carry[1] _NC935 _NC936 _NC937 HADDX1
X463 N208 N207 Add_90_I8_L07002_C129_carry[0] _NC938 _NC939 _NC940 HADDX1
X464 N228 Add_90_I9_L07002_C129_carry[2] Add_90_I9_L07002_C129_carry[3] _NC941 _NC942 _NC943 HADDX1
X465 N227 Add_90_I9_L07002_C129_carry[1] Add_90_I9_L07002_C129_carry[2] _NC944 _NC945 _NC946 HADDX1
X466 N226 Add_90_I9_L07002_C129_carry[0] Add_90_I9_L07002_C129_carry[1] _NC947 _NC948 _NC949 HADDX1
X467 N225 N224 Add_90_I9_L07002_C129_carry[0] _NC950 _NC951 _NC952 HADDX1
X468 N245 Add_90_I10_L07002_C129_carry[2] Add_90_I10_L07002_C129_carry[3] _NC953 _NC954 _NC955 HADDX1
X469 N244 Add_90_I10_L07002_C129_carry[1] Add_90_I10_L07002_C129_carry[2] _NC956 _NC957 _NC958 HADDX1
X470 N243 Add_90_I10_L07002_C129_carry[0] Add_90_I10_L07002_C129_carry[1] _NC959 _NC960 _NC961 HADDX1
X471 N242 N241 Add_90_I10_L07002_C129_carry[0] _NC962 _NC963 _NC964 HADDX1
X472 N262 Add_90_I11_L07002_C129_carry[2] Add_90_I11_L07002_C129_carry[3] _NC965 _NC966 _NC967 HADDX1
X473 N261 Add_90_I11_L07002_C129_carry[1] Add_90_I11_L07002_C129_carry[2] _NC968 _NC969 _NC970 HADDX1
X474 N260 Add_90_I11_L07002_C129_carry[0] Add_90_I11_L07002_C129_carry[1] _NC971 _NC972 _NC973 HADDX1
X475 N259 N258 Add_90_I11_L07002_C129_carry[0] _NC974 _NC975 _NC976 HADDX1
X476 N279 Add_90_I12_L07002_C129_carry[2] Add_90_I12_L07002_C129_carry[3] _NC977 _NC978 _NC979 HADDX1
X477 N278 Add_90_I12_L07002_C129_carry[1] Add_90_I12_L07002_C129_carry[2] _NC980 _NC981 _NC982 HADDX1
X478 N277 Add_90_I12_L07002_C129_carry[0] Add_90_I12_L07002_C129_carry[1] _NC983 _NC984 _NC985 HADDX1
X479 N276 N275 Add_90_I12_L07002_C129_carry[0] _NC986 _NC987 _NC988 HADDX1
X480 N296 Add_90_I13_L07002_C129_carry[2] Add_90_I13_L07002_C129_carry[3] _NC989 _NC990 _NC991 HADDX1
X481 N295 Add_90_I13_L07002_C129_carry[1] Add_90_I13_L07002_C129_carry[2] _NC992 _NC993 _NC994 HADDX1
X482 N294 Add_90_I13_L07002_C129_carry[0] Add_90_I13_L07002_C129_carry[1] _NC995 _NC996 _NC997 HADDX1
X483 N293 N292 Add_90_I13_L07002_C129_carry[0] _NC998 _NC999 _NC1000 HADDX1
X484 N313 Add_90_I14_L07002_C129_carry[2] Add_90_I14_L07002_C129_carry[3] _NC1001 _NC1002 _NC1003 HADDX1
X485 N312 Add_90_I14_L07002_C129_carry[1] Add_90_I14_L07002_C129_carry[2] _NC1004 _NC1005 _NC1006 HADDX1
X486 N311 Add_90_I14_L07002_C129_carry[0] Add_90_I14_L07002_C129_carry[1] _NC1007 _NC1008 _NC1009 HADDX1
X487 N310 N309 Add_90_I14_L07002_C129_carry[0] _NC1010 _NC1011 _NC1012 HADDX1
X488 N330 Add_90_I15_L07002_C129_carry[2] Add_90_I15_L07002_C129_carry[3] _NC1013 _NC1014 _NC1015 HADDX1
X489 N329 Add_90_I15_L07002_C129_carry[1] Add_90_I15_L07002_C129_carry[2] _NC1016 _NC1017 _NC1018 HADDX1
X490 N328 Add_90_I15_L07002_C129_carry[0] Add_90_I15_L07002_C129_carry[1] _NC1019 _NC1020 _NC1021 HADDX1
X491 N327 N326 Add_90_I15_L07002_C129_carry[0] _NC1022 _NC1023 _NC1024 HADDX1
X492 N347 Add_90_I16_L07002_C129_carry[2] Add_90_I16_L07002_C129_carry[3] _NC1025 _NC1026 _NC1027 HADDX1
X493 N346 Add_90_I16_L07002_C129_carry[1] Add_90_I16_L07002_C129_carry[2] _NC1028 _NC1029 _NC1030 HADDX1
X494 N345 Add_90_I16_L07002_C129_carry[0] Add_90_I16_L07002_C129_carry[1] _NC1031 _NC1032 _NC1033 HADDX1
X495 N344 N343 Add_90_I16_L07002_C129_carry[0] _NC1034 _NC1035 _NC1036 HADDX1
X496 N364 Add_90_I17_L07002_C129_carry[2] Add_90_I17_L07002_C129_carry[3] _NC1037 _NC1038 _NC1039 HADDX1
X497 N363 Add_90_I17_L07002_C129_carry[1] Add_90_I17_L07002_C129_carry[2] _NC1040 _NC1041 _NC1042 HADDX1
X498 N362 Add_90_I17_L07002_C129_carry[0] Add_90_I17_L07002_C129_carry[1] _NC1043 _NC1044 _NC1045 HADDX1
X499 N361 N360 Add_90_I17_L07002_C129_carry[0] _NC1046 _NC1047 _NC1048 HADDX1
X500 N381 Add_90_I18_L07002_C129_carry[2] Add_90_I18_L07002_C129_carry[3] _NC1049 _NC1050 _NC1051 HADDX1
X501 N380 Add_90_I18_L07002_C129_carry[1] Add_90_I18_L07002_C129_carry[2] _NC1052 _NC1053 _NC1054 HADDX1
X502 N379 Add_90_I18_L07002_C129_carry[0] Add_90_I18_L07002_C129_carry[1] _NC1055 _NC1056 _NC1057 HADDX1
X503 N378 N377 Add_90_I18_L07002_C129_carry[0] _NC1058 _NC1059 _NC1060 HADDX1
X504 N398 Add_90_I19_L07002_C129_carry[2] Add_90_I19_L07002_C129_carry[3] _NC1061 _NC1062 _NC1063 HADDX1
X505 N397 Add_90_I19_L07002_C129_carry[1] Add_90_I19_L07002_C129_carry[2] _NC1064 _NC1065 _NC1066 HADDX1
X506 N396 Add_90_I19_L07002_C129_carry[0] Add_90_I19_L07002_C129_carry[1] _NC1067 _NC1068 _NC1069 HADDX1
X507 N395 N394 Add_90_I19_L07002_C129_carry[0] _NC1070 _NC1071 _NC1072 HADDX1
X508 N415 Add_90_I20_L07002_C129_carry[2] Add_90_I20_L07002_C129_carry[3] _NC1073 _NC1074 _NC1075 HADDX1
X509 N414 Add_90_I20_L07002_C129_carry[1] Add_90_I20_L07002_C129_carry[2] _NC1076 _NC1077 _NC1078 HADDX1
X510 N413 Add_90_I20_L07002_C129_carry[0] Add_90_I20_L07002_C129_carry[1] _NC1079 _NC1080 _NC1081 HADDX1
X511 N412 N411 Add_90_I20_L07002_C129_carry[0] _NC1082 _NC1083 _NC1084 HADDX1
X512 N432 Add_90_I21_L07002_C129_carry[2] Add_90_I21_L07002_C129_carry[3] _NC1085 _NC1086 _NC1087 HADDX1
X513 N431 Add_90_I21_L07002_C129_carry[1] Add_90_I21_L07002_C129_carry[2] _NC1088 _NC1089 _NC1090 HADDX1
X514 N430 Add_90_I21_L07002_C129_carry[0] Add_90_I21_L07002_C129_carry[1] _NC1091 _NC1092 _NC1093 HADDX1
X515 N429 N428 Add_90_I21_L07002_C129_carry[0] _NC1094 _NC1095 _NC1096 HADDX1
X516 N449 Add_90_I22_L07002_C129_carry[2] Add_90_I22_L07002_C129_carry[3] _NC1097 _NC1098 _NC1099 HADDX1
X517 N448 Add_90_I22_L07002_C129_carry[1] Add_90_I22_L07002_C129_carry[2] _NC1100 _NC1101 _NC1102 HADDX1
X518 N447 Add_90_I22_L07002_C129_carry[0] Add_90_I22_L07002_C129_carry[1] _NC1103 _NC1104 _NC1105 HADDX1
X519 N446 N445 Add_90_I22_L07002_C129_carry[0] _NC1106 _NC1107 _NC1108 HADDX1
X520 N466 Add_90_I23_L07002_C129_carry[2] Add_90_I23_L07002_C129_carry[3] _NC1109 _NC1110 _NC1111 HADDX1
X521 N465 Add_90_I23_L07002_C129_carry[1] Add_90_I23_L07002_C129_carry[2] _NC1112 _NC1113 _NC1114 HADDX1
X522 N464 Add_90_I23_L07002_C129_carry[0] Add_90_I23_L07002_C129_carry[1] _NC1115 _NC1116 _NC1117 HADDX1
X523 N463 N462 Add_90_I23_L07002_C129_carry[0] _NC1118 _NC1119 _NC1120 HADDX1
X524 N483 Add_90_I24_L07002_C129_carry[2] Add_90_I24_L07002_C129_carry[3] _NC1121 _NC1122 _NC1123 HADDX1
X525 N482 Add_90_I24_L07002_C129_carry[1] Add_90_I24_L07002_C129_carry[2] _NC1124 _NC1125 _NC1126 HADDX1
X526 N481 Add_90_I24_L07002_C129_carry[0] Add_90_I24_L07002_C129_carry[1] _NC1127 _NC1128 _NC1129 HADDX1
X527 N480 N479 Add_90_I24_L07002_C129_carry[0] _NC1130 _NC1131 _NC1132 HADDX1
X528 N500 Add_90_I25_L07002_C129_carry[2] Add_90_I25_L07002_C129_carry[3] _NC1133 _NC1134 _NC1135 HADDX1
X529 N499 Add_90_I25_L07002_C129_carry[1] Add_90_I25_L07002_C129_carry[2] _NC1136 _NC1137 _NC1138 HADDX1
X530 N498 Add_90_I25_L07002_C129_carry[0] Add_90_I25_L07002_C129_carry[1] _NC1139 _NC1140 _NC1141 HADDX1
X531 N497 N496 Add_90_I25_L07002_C129_carry[0] _NC1142 _NC1143 _NC1144 HADDX1
X532 N517 Add_90_I26_L07002_C129_carry[2] Add_90_I26_L07002_C129_carry[3] _NC1145 _NC1146 _NC1147 HADDX1
X533 N516 Add_90_I26_L07002_C129_carry[1] Add_90_I26_L07002_C129_carry[2] _NC1148 _NC1149 _NC1150 HADDX1
X534 N515 Add_90_I26_L07002_C129_carry[0] Add_90_I26_L07002_C129_carry[1] _NC1151 _NC1152 _NC1153 HADDX1
X535 N514 N513 Add_90_I26_L07002_C129_carry[0] _NC1154 _NC1155 _NC1156 HADDX1
X536 N534 Add_90_I27_L07002_C129_carry[2] Add_90_I27_L07002_C129_carry[3] _NC1157 _NC1158 _NC1159 HADDX1
X537 N533 Add_90_I27_L07002_C129_carry[1] Add_90_I27_L07002_C129_carry[2] _NC1160 _NC1161 _NC1162 HADDX1
X538 N532 Add_90_I27_L07002_C129_carry[0] Add_90_I27_L07002_C129_carry[1] _NC1163 _NC1164 _NC1165 HADDX1
X539 N531 N530 Add_90_I27_L07002_C129_carry[0] _NC1166 _NC1167 _NC1168 HADDX1
X540 S_fracto28_1[0] S_fracto28_1[1] S_fracto28_1[2] S_fracto28_1[3] S_fracto28_1[4] S_fracto28_1[5] S_fracto28_1[6] S_fracto28_1[7] S_fracto28_1[8] S_fracto28_1[9] S_fracto28_1[10] S_fracto28_1[11] S_fracto28_1[12] S_fracto28_1[13] S_fracto28_1[14] S_fracto28_1[15] S_fracto28_1[16] S_fracto28_1[17] S_fracto28_1[18] S_fracto28_1[19] S_fracto28_1[20] S_fracto28_1[21] S_fracto28_1[22] S_fracto28_1[23] S_fracto28_1[24] S_fracto28_1[25] S_fracto28_1[26] S_fracto28_1[27] Vss Vss Vss S_roundup Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss Vss S_fracto28_rnd[0] S_fracto28_rnd[1] S_fracto28_rnd[2] S_fracto28_rnd[3] S_fracto28_rnd[4] S_fracto28_rnd[5] S_fracto28_rnd[6] S_fracto28_rnd[7] S_fracto28_rnd[8] S_fracto28_rnd[9] S_fracto28_rnd[10] S_fracto28_rnd[11] S_fracto28_rnd[12] S_fracto28_rnd[13] S_fracto28_rnd[14] S_fracto28_rnd[15] S_fracto28_rnd[16] S_fracto28_rnd[17] S_fracto28_rnd[18] S_fracto28_rnd[19] S_fracto28_rnd[20] S_fracto28_rnd[21] S_fracto28_rnd[22] S_fracto28_rnd[23] S_fracto28_rnd[24] S_fracto28_rnd[25] S_fracto28_rnd[26] S_fracto28_rnd[27] _NC1169 post_norm_addsub_DW01_add_0
X541 S_expo9_2[0] S_expo9_2[1] S_expo9_2[2] S_expo9_2[3] S_expo9_2[4] S_expo9_2[5] S_expo9_2[6] S_expo9_2[7] S_expo9_2[8] N1092 N1093 N1094 N1095 N1096 N1097 N1098 N1099 N1100 post_norm_addsub_DW01_inc_0
X542 N971 S_shr1[0] N999 N29 N1027 _NC1170 _NC1171 AO22X1
X543 N972 N28 N1000 N29 N1028 _NC1172 _NC1173 AO22X1
X544 N973 N28 N1001 N29 N1029 _NC1174 _NC1175 AO22X1
X545 N974 N28 N1002 N29 N1030 _NC1176 _NC1177 AO22X1
X546 N975 N28 N1003 N29 N1031 _NC1178 _NC1179 AO22X1
X547 N976 N28 N1004 N29 N1032 _NC1180 _NC1181 AO22X1
X548 N977 N28 N1005 N29 N1033 _NC1182 _NC1183 AO22X1
X549 N978 S_shr1[0] N1006 N29 N1034 _NC1184 _NC1185 AO22X1
X550 N979 S_shr1[0] N1007 N29 N1035 _NC1186 _NC1187 AO22X1
X551 N980 S_shr1[0] N1008 N29 N1036 _NC1188 _NC1189 AO22X1
X552 N981 S_shr1[0] N1009 N10 N1037 _NC1190 _NC1191 AO22X1
X553 N982 S_shr1[0] N1010 N10 N1038 _NC1192 _NC1193 AO22X1
X554 N983 S_shr1[0] N1011 N10 N1039 _NC1194 _NC1195 AO22X1
X555 N984 S_shr1[0] N1012 N10 N1040 _NC1196 _NC1197 AO22X1
X556 N985 S_shr1[0] N1013 N10 N1041 _NC1198 _NC1199 AO22X1
X557 N986 S_shr1[0] N1014 N10 N1042 _NC1200 _NC1201 AO22X1
X558 N987 S_shr1[0] N1015 N10 N1043 _NC1202 _NC1203 AO22X1
X559 N988 S_shr1[0] N1016 N10 N1044 _NC1204 _NC1205 AO22X1
X560 N989 S_shr1[0] N1017 N10 N1045 _NC1206 _NC1207 AO22X1
X561 N990 S_shr1[0] N1018 N10 N1046 _NC1208 _NC1209 AO22X1
X562 N991 S_shr1[0] N1019 N10 N1047 _NC1210 _NC1211 AO22X1
X563 N992 S_shr1[0] N1020 N10 N1048 _NC1212 _NC1213 AO22X1
X564 N993 S_shr1[0] N1021 N10 N1049 _NC1214 _NC1215 AO22X1
X565 N994 S_shr1[0] N1022 N10 N1050 _NC1216 _NC1217 AO22X1
X566 N995 S_shr1[0] N1023 N10 N1051 _NC1218 _NC1219 AO22X1
X567 N996 S_shr1[0] N1024 N10 N1052 _NC1220 _NC1221 AO22X1
X568 N997 S_shr1[0] N1025 N10 N1053 _NC1222 _NC1223 AO22X1
X569 N998 S_shr1[0] N1026 N10 N1054 _NC1224 _NC1225 AO22X1
X570 N1097 N1096 N1098 N299 _NC1226 _NC1227 AND3X1
X571 N301 N56 N1100 S_expo9_2[0] N300 _NC1228 _NC1229 NOR4X0
X572 S_fracto28_rnd[27] N1099 N299 N300 N2950 _NC1230 _NC1231 NAND4X0
X573 S_expo9_2[1] Sub_172_aco_carry[7] S_expo9_2[0] N2970 _NC1232 _NC1233 AND3X1
X574 S_expo9_2[4] S_expo9_2[5] S_expo9_2[6] S_expo9_2[7] N298 _NC1234 _NC1235 AND4X1
X575 S_expo9_2[3] S_expo9_2[2] N2970 N298 N2960 _NC1236 _NC1237 NAND4X0
X576 S_shr1[0] Fract_28_i[0] S_fracto28_rnd[3] S_fracto28_rnd[27] N152 N2940 _NC1238 _NC1239 AO221X1
X577 N2940 S_fracto28_rnd[0] S_fracto28_rnd[2] S_fracto28_rnd[1] N2890 _NC1240 _NC1241 NOR4X0
X578 Opa_i[26] Opa_i[25] Opa_i[24] Opa_i[23] N2920 _NC1242 _NC1243 NAND4X0
X579 Opa_i[30] Opa_i[29] Opa_i[28] Opa_i[27] N2930 _NC1244 _NC1245 NAND4X0
X580 Opb_i[26] Opb_i[25] Opb_i[24] Opb_i[23] N2900 _NC1246 _NC1247 NAND4X0
X581 Opb_i[30] Opb_i[29] Opb_i[28] Opb_i[27] N2910 _NC1248 _NC1249 NAND4X0
X582 N2890 N129 N121 N1176 _NC1250 _NC1251 NOR3X0
X583 Fract_28_i[25] Fract_28_i[26] N2530 _NC1252 _NC1253 XOR2X1
X584 N98 N2530 N2880 _NC1254 _NC1255 XNOR2X1
X585 N2880 Fract_28_i[23] N160 _NC1256 _NC1257 XOR2X1
X586 N2530 N98 N282 N2870 _NC1258 _NC1259 AO21X1
X587 N2860 N2870 N2370 _NC1260 _NC1261 XNOR2X1
X588 N2860 N2870 N162 _NC1262 _NC1263 AND2X1
X589 N169 N101 Fract_28_i[22] N160 N174 _NC1264 _NC1265 AO22X1
X590 N170 N101 Fract_28_i[22] Add_90_I5_L07002_C129_A[1] N175 _NC1266 _NC1267 AO22X1
X591 N171 N101 Fract_28_i[22] N162 N176 _NC1268 _NC1269 AO22X1
X592 N172 N101 N177 _NC1270 _NC1271 AND2X1
X593 N184 N102 Fract_28_i[21] N174 N190 _NC1272 _NC1273 AO22X1
X594 N185 N102 Fract_28_i[21] N175 N191 _NC1274 _NC1275 AO22X1
X595 N186 N102 Fract_28_i[21] N176 N192 _NC1276 _NC1277 AO22X1
X596 N187 N102 N177 Fract_28_i[21] N193 _NC1278 _NC1279 AO22X1
X597 N201 N103 Fract_28_i[20] N190 N207 _NC1280 _NC1281 AO22X1
X598 N202 N103 Fract_28_i[20] N191 N208 _NC1282 _NC1283 AO22X1
X599 N203 N103 Fract_28_i[20] N192 N209 _NC1284 _NC1285 AO22X1
X600 N204 N103 Fract_28_i[20] N193 N210 _NC1286 _NC1287 AO22X1
X601 N205 N103 Fract_28_i[20] N194 N211 _NC1288 _NC1289 AO22X1
X602 N218 N104 Fract_28_i[19] N207 N224 _NC1290 _NC1291 AO22X1
X603 N219 N104 Fract_28_i[19] N208 N225 _NC1292 _NC1293 AO22X1
X604 N220 N104 Fract_28_i[19] N209 N226 _NC1294 _NC1295 AO22X1
X605 N221 N104 Fract_28_i[19] N210 N227 _NC1296 _NC1297 AO22X1
X606 N222 N104 Fract_28_i[19] N211 N228 _NC1298 _NC1299 AO22X1
X607 N223 N104 Fract_28_i[19] N50 N229 _NC1300 _NC1301 AO22X1
X608 N235 N126 Fract_28_i[18] N224 N241 _NC1302 _NC1303 AO22X1
X609 N236 N126 Fract_28_i[18] N225 N242 _NC1304 _NC1305 AO22X1
X610 N237 N126 Fract_28_i[18] N226 N243 _NC1306 _NC1307 AO22X1
X611 N238 N126 Fract_28_i[18] N227 N244 _NC1308 _NC1309 AO22X1
X612 N239 N126 Fract_28_i[18] N228 N245 _NC1310 _NC1311 AO22X1
X613 N240 N126 Fract_28_i[18] N229 N246 _NC1312 _NC1313 AO22X1
X614 N252 N302 N18 N241 N258 _NC1314 _NC1315 AO22X1
X615 N253 N302 N18 N242 N259 _NC1316 _NC1317 AO22X1
X616 N254 N302 N18 N243 N260 _NC1318 _NC1319 AO22X1
X617 N255 N302 N18 N244 N261 _NC1320 _NC1321 AO22X1
X618 N256 N302 N18 N245 N262 _NC1322 _NC1323 AO22X1
X619 N257 N302 N18 N246 N263 _NC1324 _NC1325 AO22X1
X620 N269 N3030 Fract_28_i[16] N258 N275 _NC1326 _NC1327 AO22X1
X621 N270 N3030 Fract_28_i[16] N259 N276 _NC1328 _NC1329 AO22X1
X622 N271 N3030 Fract_28_i[16] N260 N277 _NC1330 _NC1331 AO22X1
X623 N272 N3030 Fract_28_i[16] N261 N278 _NC1332 _NC1333 AO22X1
X624 N273 N3030 Fract_28_i[16] N262 N279 _NC1334 _NC1335 AO22X1
X625 N274 N3030 Fract_28_i[16] N263 N280 _NC1336 _NC1337 AO22X1
X626 N286 N3040 Fract_28_i[15] N275 N292 _NC1338 _NC1339 AO22X1
X627 N287 N3040 Fract_28_i[15] N276 N293 _NC1340 _NC1341 AO22X1
X628 N288 N3040 Fract_28_i[15] N277 N294 _NC1342 _NC1343 AO22X1
X629 N289 N3040 Fract_28_i[15] N278 N295 _NC1344 _NC1345 AO22X1
X630 N290 N3040 Fract_28_i[15] N279 N296 _NC1346 _NC1347 AO22X1
X631 N291 N3040 Fract_28_i[15] N280 N297 _NC1348 _NC1349 AO22X1
X632 N303 N3050 Fract_28_i[14] N292 N309 _NC1350 _NC1351 AO22X1
X633 N304 N3050 Fract_28_i[14] N293 N310 _NC1352 _NC1353 AO22X1
X634 N305 N3050 Fract_28_i[14] N294 N311 _NC1354 _NC1355 AO22X1
X635 N306 N3050 Fract_28_i[14] N295 N312 _NC1356 _NC1357 AO22X1
X636 N307 N3050 Fract_28_i[14] N296 N313 _NC1358 _NC1359 AO22X1
X637 N308 N3050 Fract_28_i[14] N297 N314 _NC1360 _NC1361 AO22X1
X638 N320 N3060 Fract_28_i[13] N309 N326 _NC1362 _NC1363 AO22X1
X639 N321 N3060 Fract_28_i[13] N310 N327 _NC1364 _NC1365 AO22X1
X640 N322 N3060 Fract_28_i[13] N311 N328 _NC1366 _NC1367 AO22X1
X641 N323 N3060 Fract_28_i[13] N312 N329 _NC1368 _NC1369 AO22X1
X642 N324 N3060 Fract_28_i[13] N313 N330 _NC1370 _NC1371 AO22X1
X643 N325 N3060 Fract_28_i[13] N314 N331 _NC1372 _NC1373 AO22X1
X644 N337 N3070 Fract_28_i[12] N326 N343 _NC1374 _NC1375 AO22X1
X645 N338 N3070 Fract_28_i[12] N327 N344 _NC1376 _NC1377 AO22X1
X646 N339 N3070 Fract_28_i[12] N328 N345 _NC1378 _NC1379 AO22X1
X647 N340 N3070 Fract_28_i[12] N329 N346 _NC1380 _NC1381 AO22X1
X648 N341 N3070 Fract_28_i[12] N330 N347 _NC1382 _NC1383 AO22X1
X649 N342 N3070 Fract_28_i[12] N331 N348 _NC1384 _NC1385 AO22X1
X650 N354 N3080 N16 N343 N360 _NC1386 _NC1387 AO22X1
X651 N355 N3080 N16 N344 N361 _NC1388 _NC1389 AO22X1
X652 N356 N3080 N16 N345 N362 _NC1390 _NC1391 AO22X1
X653 N357 N3080 N16 N346 N363 _NC1392 _NC1393 AO22X1
X654 N358 N3080 N16 N347 N364 _NC1394 _NC1395 AO22X1
X655 N359 N3080 N16 N348 N365 _NC1396 _NC1397 AO22X1
X656 N371 N3100 Fract_28_i[10] N360 N377 _NC1398 _NC1399 AO22X1
X657 N372 N3100 Fract_28_i[10] N361 N378 _NC1400 _NC1401 AO22X1
X658 N373 N3100 Fract_28_i[10] N362 N379 _NC1402 _NC1403 AO22X1
X659 N374 N3100 Fract_28_i[10] N363 N380 _NC1404 _NC1405 AO22X1
X660 N375 N3100 Fract_28_i[10] N364 N381 _NC1406 _NC1407 AO22X1
X661 N376 N3100 Fract_28_i[10] N365 N382 _NC1408 _NC1409 AO22X1
X662 N388 N3110 Fract_28_i[9] N377 N394 _NC1410 _NC1411 AO22X1
X663 N389 N3110 Fract_28_i[9] N378 N395 _NC1412 _NC1413 AO22X1
X664 N390 N3110 Fract_28_i[9] N379 N396 _NC1414 _NC1415 AO22X1
X665 N391 N3110 Fract_28_i[9] N380 N397 _NC1416 _NC1417 AO22X1
X666 N392 N3110 Fract_28_i[9] N381 N398 _NC1418 _NC1419 AO22X1
X667 N393 N3110 Fract_28_i[9] N382 N399 _NC1420 _NC1421 AO22X1
X668 N97 N3120 Fract_28_i[8] N394 N411 _NC1422 _NC1423 AO22X1
X669 N406 N3120 Fract_28_i[8] N395 N412 _NC1424 _NC1425 AO22X1
X670 N407 N3120 Fract_28_i[8] N396 N413 _NC1426 _NC1427 AO22X1
X671 N408 N3120 Fract_28_i[8] N397 N414 _NC1428 _NC1429 AO22X1
X672 N409 N3120 Fract_28_i[8] N398 N415 _NC1430 _NC1431 AO22X1
X673 N410 N3120 Fract_28_i[8] N399 N416 _NC1432 _NC1433 AO22X1
X674 N422 N3130 Fract_28_i[7] N411 N428 _NC1434 _NC1435 AO22X1
X675 N423 N3130 Fract_28_i[7] N412 N429 _NC1436 _NC1437 AO22X1
X676 N424 N3130 Fract_28_i[7] N413 N430 _NC1438 _NC1439 AO22X1
X677 N425 N3130 Fract_28_i[7] N414 N431 _NC1440 _NC1441 AO22X1
X678 N426 N3130 Fract_28_i[7] N415 N432 _NC1442 _NC1443 AO22X1
X679 N427 N3130 Fract_28_i[7] N416 N433 _NC1444 _NC1445 AO22X1
X680 N439 N3140 Fract_28_i[6] N428 N445 _NC1446 _NC1447 AO22X1
X681 N440 N3140 Fract_28_i[6] N429 N446 _NC1448 _NC1449 AO22X1
X682 N441 N3140 Fract_28_i[6] N430 N447 _NC1450 _NC1451 AO22X1
X683 N442 N3140 Fract_28_i[6] N431 N448 _NC1452 _NC1453 AO22X1
X684 N443 N3140 Fract_28_i[6] N432 N449 _NC1454 _NC1455 AO22X1
X685 N444 N3140 Fract_28_i[6] N433 N450 _NC1456 _NC1457 AO22X1
X686 N456 N315 N14 N445 N462 _NC1458 _NC1459 AO22X1
X687 N457 N315 N14 N446 N463 _NC1460 _NC1461 AO22X1
X688 N458 N315 N14 N447 N464 _NC1462 _NC1463 AO22X1
X689 N459 N315 N14 N448 N465 _NC1464 _NC1465 AO22X1
X690 N460 N315 N14 N449 N466 _NC1466 _NC1467 AO22X1
X691 N461 N315 N14 N450 N467 _NC1468 _NC1469 AO22X1
X692 N473 N317 Fract_28_i[4] N462 N479 _NC1470 _NC1471 AO22X1
X693 N474 N317 Fract_28_i[4] N463 N480 _NC1472 _NC1473 AO22X1
X694 N475 N317 Fract_28_i[4] N464 N481 _NC1474 _NC1475 AO22X1
X695 N476 N317 Fract_28_i[4] N465 N482 _NC1476 _NC1477 AO22X1
X696 N477 N317 Fract_28_i[4] N466 N483 _NC1478 _NC1479 AO22X1
X697 N478 N317 Fract_28_i[4] N467 N484 _NC1480 _NC1481 AO22X1
X698 N490 N318 Fract_28_i[3] N479 N496 _NC1482 _NC1483 AO22X1
X699 N491 N318 Fract_28_i[3] N480 N497 _NC1484 _NC1485 AO22X1
X700 N492 N318 Fract_28_i[3] N481 N498 _NC1486 _NC1487 AO22X1
X701 N493 N318 Fract_28_i[3] N482 N499 _NC1488 _NC1489 AO22X1
X702 N494 N318 Fract_28_i[3] N483 N500 _NC1490 _NC1491 AO22X1
X703 N495 N318 Fract_28_i[3] N484 N501 _NC1492 _NC1493 AO22X1
X704 N507 N319 Fract_28_i[2] N496 N513 _NC1494 _NC1495 AO22X1
X705 N508 N319 Fract_28_i[2] N497 N514 _NC1496 _NC1497 AO22X1
X706 N509 N319 Fract_28_i[2] N498 N515 _NC1498 _NC1499 AO22X1
X707 N510 N319 Fract_28_i[2] N499 N516 _NC1500 _NC1501 AO22X1
X708 N511 N319 Fract_28_i[2] N500 N517 _NC1502 _NC1503 AO22X1
X709 N512 N319 Fract_28_i[2] N501 N518 _NC1504 _NC1505 AO22X1
X710 N524 N3200 Fract_28_i[1] N513 N530 _NC1506 _NC1507 AO22X1
X711 N525 N3200 Fract_28_i[1] N514 N531 _NC1508 _NC1509 AO22X1
X712 N526 N3200 Fract_28_i[1] N515 N532 _NC1510 _NC1511 AO22X1
X713 N527 N3200 Fract_28_i[1] N516 N533 _NC1512 _NC1513 AO22X1
X714 N528 N3200 Fract_28_i[1] N517 N534 _NC1514 _NC1515 AO22X1
X715 N529 N3200 Fract_28_i[1] N518 N535 _NC1516 _NC1517 AO22X1
X716 S_exp10[0] S_exp10[1] S_exp10[2] S_exp10[3] N284 _NC1518 _NC1519 OR4X1
X717 S_exp10[7] S_exp10[8] S_exp10[6] N285 _NC1520 _NC1521 OR3X1
X718 N284 N285 S_exp10[5] S_exp10[4] N283 _NC1522 _NC1523 NOR4X0
X719 N282 N84 N157 _NC1524 _NC1525 AND2X1
X720 N100 N2590 N1930 _NC1526 _NC1527 AND2X1
X721 N2630 N264 N168 _NC1528 _NC1529 AND2X1
X722 N2800 N281 N1860 _NC1530 _NC1531 OR2X1
X723 N422 N1860 N439 N1870 N268 _NC1532 _NC1533 OA22X1
X724 N360 N16 N377 N1850 N2690 _NC1534 _NC1535 AOI22X1
X725 N3210 N3200 N2760 N2770 _NC1536 _NC1537 NAND3X0
X726 N2760 N2770 N1840 _NC1538 _NC1539 AND2X1
X727 N541 N316 N183 N513 N1840 N530 N2720 _NC1540 _NC1541 AO222X1
X728 N2740 N2750 N182 _NC1542 _NC1543 AND2X1
X729 N181 N479 N14 N462 N182 N496 N2730 _NC1544 _NC1545 AO222X1
X730 N97 N1750 N456 N1760 N2710 N178 N2700 _NC1546 _NC1547 OA222X1
X731 N268 N2690 N2700 N267 _NC1548 _NC1549 NAND3X0
X732 N168 N292 N1690 N343 N1700 N267 N2600 _NC1550 _NC1551 AOI222X1
X733 N265 N266 N1900 _NC1552 _NC1553 AND2X1
X734 N258 N18 N275 N1880 N2620 _NC1554 _NC1555 AO22X1
X735 N326 N1900 N309 N189 N2620 N2610 _NC1556 _NC1557 AOI221X1
X736 N2600 N2610 N99 N2550 _NC1558 _NC1559 AO21X1
X737 N2570 N2580 N163 _NC1560 _NC1561 AND2X1
X738 N241 N159 N207 N164 N224 N163 N2560 _NC1562 _NC1563 AOI222X1
X739 N2540 N2550 N169 N2560 N251 _NC1564 _NC1565 NAND4X0
X740 N83 N251 N2520 N2530 S_zeros[0] _NC1566 _NC1567 AO22X1
X741 Exp_i[3] Exp_i[2] Exp_i[1] Exp_i[0] N249 _NC1568 _NC1569 NOR4X0
X742 Exp_i[7] Exp_i[6] Exp_i[5] Exp_i[4] N250 _NC1570 _NC1571 NOR4X0
X743 N249 N250 N153 N156 _NC1572 _NC1573 AOI21X1
X744 N155 S_zeros[0] N920 N156 N950 _NC1574 _NC1575 AO22X1
X745 N95 N1860 N94 N1870 N2430 _NC1576 _NC1577 OA22X1
X746 N361 N16 N378 N1850 N2440 _NC1578 _NC1579 AOI22X1
X747 N542 N316 N183 N514 N1840 N531 N247 _NC1580 _NC1581 AO222X1
X748 N181 N480 N14 N463 N182 N497 N248 _NC1582 _NC1583 AO222X1
X749 N96 N1750 N93 N1760 N2460 N178 N2450 _NC1584 _NC1585 OA222X1
X750 N2430 N2440 N2450 N2420 _NC1586 _NC1587 NAND3X0
X751 N168 N293 N1690 N344 N1700 N2420 N2390 _NC1588 _NC1589 AOI222X1
X752 N259 N18 N276 N1880 N2410 _NC1590 _NC1591 AO22X1
X753 N327 N1900 N310 N189 N2410 N2400 _NC1592 _NC1593 AOI221X1
X754 N2390 N2400 N99 N2360 _NC1594 _NC1595 AO21X1
X755 N242 N159 N208 N164 N225 N163 N2380 _NC1596 _NC1597 AOI222X1
X756 N2350 N2360 N2370 N2380 N234 _NC1598 _NC1599 NAND4X0
X757 N83 N234 Fract_28_i[24] N157 S_zeros[1] _NC1600 _NC1601 AO22X1
X758 N155 S_zeros[1] N921 N156 N951 _NC1602 _NC1603 AO22X1
X759 N1880 N277 N18 N260 N233 _NC1604 _NC1605 AO22X1
X760 N189 N311 N1900 N328 N233 N2240 _NC1606 _NC1607 AO221X1
X761 N91 N1860 N90 N1870 N2270 _NC1608 _NC1609 OA22X1
X762 N362 N16 N379 N1850 N2280 _NC1610 _NC1611 AOI22X1
X763 N543 N316 N183 N515 N1840 N532 N231 _NC1612 _NC1613 AO222X1
X764 N181 N481 N14 N464 N182 N498 N232 _NC1614 _NC1615 AO222X1
X765 N92 N1750 N89 N1760 N230 N178 N2290 _NC1616 _NC1617 OA222X1
X766 N2270 N2280 N2290 N2260 _NC1618 _NC1619 NAND3X0
X767 N1700 N2260 N1690 N345 N168 N294 N2250 _NC1620 _NC1621 AO222X1
X768 N2240 N2250 N2230 _NC1622 _NC1623 OR2X1
X769 N192 N1930 N243 N159 N2230 N1600 N2180 _NC1624 _NC1625 AOI222X1
X770 N226 N163 N2210 N2220 N209 N164 N2190 _NC1626 _NC1627 AOI222X1
X771 N2180 N2190 N2200 N149 _NC1628 _NC1629 AO21X1
X772 S_zeros[2] N155 N922 N156 N952 _NC1630 _NC1631 AO22X1
X773 N312 N189 N329 N1900 N2080 _NC1632 _NC1633 AOI22X1
X774 N261 N18 N278 N1880 N2090 _NC1634 _NC1635 AOI22X1
X775 N87 N1860 N86 N1870 N212 _NC1636 _NC1637 OA22X1
X776 N363 N16 N380 N1850 N213 _NC1638 _NC1639 AOI22X1
X777 N544 N316 N183 N516 N1840 N533 N216 _NC1640 _NC1641 AO222X1
X778 N181 N482 N14 N465 N182 N499 N217 _NC1642 _NC1643 AO222X1
X779 N88 N1750 N85 N1760 N215 N178 N214 _NC1644 _NC1645 OA222X1
X780 N212 N213 N214 N2110 _NC1646 _NC1647 NAND3X0
X781 N168 N295 N1690 N346 N1700 N2110 N2100 _NC1648 _NC1649 AOI222X1
X782 N2080 N2090 N2100 N2060 _NC1650 _NC1651 NAND3X0
X783 N163 N227 N164 N210 N159 N244 N2070 _NC1652 _NC1653 AO222X1
X784 N1600 N2060 N1930 N193 N2070 N2050 _NC1654 _NC1655 AO221X1
X785 N157 N2050 S_zeros[3] _NC1656 _NC1657 AND2X1
X786 N155 S_zeros[3] N923 N156 N953 _NC1658 _NC1659 AO22X1
X787 N313 N189 N330 N1900 N195 _NC1660 _NC1661 AOI22X1
X788 N262 N18 N279 N1880 N196 _NC1662 _NC1663 AOI22X1
X789 N53 N1860 N52 N1870 N199 _NC1664 _NC1665 OA22X1
X790 N364 N16 N381 N1850 N200 _NC1666 _NC1667 AOI22X1
X791 N545 N316 N183 N517 N1840 N534 N2030 _NC1668 _NC1669 AO222X1
X792 N181 N483 N14 N466 N182 N500 N2040 _NC1670 _NC1671 AO222X1
X793 N54 N1750 N51 N1760 N2020 N178 N2010 _NC1672 _NC1673 OA222X1
X794 N199 N200 N2010 N198 _NC1674 _NC1675 NAND3X0
X795 N168 N296 N1690 N347 N1700 N198 N197 _NC1676 _NC1677 AOI222X1
X796 N195 N196 N197 N1920 _NC1678 _NC1679 NAND3X0
X797 N163 N228 N164 N211 N159 N245 N1940 _NC1680 _NC1681 AO222X1
X798 N1600 N1920 N1930 N194 N1940 N1910 _NC1682 _NC1683 AO221X1
X799 N157 N1910 S_zeros[4] _NC1684 _NC1685 AND2X1
X800 N155 S_zeros[4] N924 N156 N954 _NC1686 _NC1687 AO22X1
X801 N314 N189 N331 N1900 N165 _NC1688 _NC1689 AOI22X1
X802 N263 N18 N280 N1880 N166 _NC1690 _NC1691 AOI22X1
X803 N48 N1860 N47 N1870 N1720 _NC1692 _NC1693 OA22X1
X804 N365 N16 N382 N1850 N173 _NC1694 _NC1695 AOI22X1
X805 N546 N316 N183 N518 N1840 N535 N179 _NC1696 _NC1697 AO222X1
X806 N181 N484 N14 N467 N182 N501 N180 _NC1698 _NC1699 AO222X1
X807 N49 N1750 N46 N1760 N1770 N178 N1740 _NC1700 _NC1701 OA222X1
X808 N1720 N173 N1740 N1710 _NC1702 _NC1703 NAND3X0
X809 N168 N297 N1690 N348 N1700 N1710 N167 _NC1704 _NC1705 AOI222X1
X810 N165 N166 N167 N161 _NC1706 _NC1707 NAND3X0
X811 N163 N229 N164 N50 N1620 _NC1708 _NC1709 AO22X1
X812 N159 N246 N1600 N161 N1620 N158 _NC1710 _NC1711 AO221X1
X813 S_zeros[5] N155 N925 N156 N955 _NC1712 _NC1713 AO22X1
X814 S_exp10[8] N153 N154 _NC1714 _NC1715 AND2X1
X815 S_exp10[1] N153 N154 N957 _NC1716 _NC1717 AO21X1
X816 S_exp10[2] N153 N154 N958 _NC1718 _NC1719 AO21X1
X817 S_exp10[3] N153 N154 N959 _NC1720 _NC1721 AO21X1
X818 S_exp10[4] N153 N154 N960 _NC1722 _NC1723 AO21X1
X819 S_exp10[5] N153 N154 N961 _NC1724 _NC1725 AO21X1
X820 S_exp10[6] N153 N154 N962 _NC1726 _NC1727 AO21X1
X821 S_exp10[7] N153 N154 N963 _NC1728 _NC1729 AO21X1
X822 N121 N129 N152 N124 _NC1730 _NC1731 NOR3X0
X823 S_zeros[3] S_zeros[0] S_zeros[4] N151 _NC1732 _NC1733 AND3X1
X824 N149 N150 S_zeros[1] N151 N125 _NC1734 _NC1735 NAND4X0
X825 N124 N125 N148 _NC1736 _NC1737 AND2X1
X826 S_fracto28_rnd[4] N113 S_fracto28_rnd[3] N19 S_output_o[0] _NC1738 _NC1739 AO22X1
X827 S_fracto28_rnd[14] N113 S_fracto28_rnd[13] N114 S_output_o[10] _NC1740 _NC1741 AO22X1
X828 S_fracto28_rnd[15] N113 S_fracto28_rnd[14] N19 S_output_o[11] _NC1742 _NC1743 AO22X1
X829 S_fracto28_rnd[16] N113 S_fracto28_rnd[15] N114 S_output_o[12] _NC1744 _NC1745 AO22X1
X830 S_fracto28_rnd[17] N113 S_fracto28_rnd[16] N19 S_output_o[13] _NC1746 _NC1747 AO22X1
X831 S_fracto28_rnd[18] N113 S_fracto28_rnd[17] N114 S_output_o[14] _NC1748 _NC1749 AO22X1
X832 S_fracto28_rnd[19] N113 S_fracto28_rnd[18] N19 S_output_o[15] _NC1750 _NC1751 AO22X1
X833 S_fracto28_rnd[20] N113 S_fracto28_rnd[19] N114 S_output_o[16] _NC1752 _NC1753 AO22X1
X834 S_fracto28_rnd[21] N113 S_fracto28_rnd[20] N19 S_output_o[17] _NC1754 _NC1755 AO22X1
X835 S_fracto28_rnd[22] N113 S_fracto28_rnd[21] N114 S_output_o[18] _NC1756 _NC1757 AO22X1
X836 S_fracto28_rnd[23] N113 S_fracto28_rnd[22] N19 S_output_o[19] _NC1758 _NC1759 AO22X1
X837 S_fracto28_rnd[5] N113 S_fracto28_rnd[4] N114 S_output_o[1] _NC1760 _NC1761 AO22X1
X838 S_fracto28_rnd[24] N113 S_fracto28_rnd[23] N19 S_output_o[20] _NC1762 _NC1763 AO22X1
X839 S_fracto28_rnd[25] N113 S_fracto28_rnd[24] N114 S_output_o[21] _NC1764 _NC1765 AO22X1
X840 Opb_i[31] Opa_i[31] Fpu_op_i N139 _NC1766 _NC1767 XOR3X1
X841 Opb_i[10] Opb_i[0] N147 _NC1768 _NC1769 OR2X1
X842 N147 Opb_i[11] Opb_i[13] Opb_i[12] N140 _NC1770 _NC1771 NOR4X0
X843 Opb_i[19] Opb_i[18] Opb_i[17] N146 _NC1772 _NC1773 OR3X1
X844 N146 Opb_i[14] Opb_i[16] Opb_i[15] N141 _NC1774 _NC1775 NOR4X0
X845 Opb_i[3] Opb_i[2] Opb_i[22] N145 _NC1776 _NC1777 OR3X1
X846 N145 Opb_i[1] Opb_i[21] Opb_i[20] N142 _NC1778 _NC1779 NOR4X0
X847 Opb_i[9] Opb_i[8] Opb_i[7] N144 _NC1780 _NC1781 OR3X1
X848 N144 Opb_i[4] Opb_i[6] Opb_i[5] N143 _NC1782 _NC1783 NOR4X0
X849 N140 N141 N142 N143 N120 _NC1784 _NC1785 NAND4X0
X850 N129 N139 N120 N128 _NC1786 _NC1787 AO21X1
X851 Opa_i[10] Opa_i[0] N138 _NC1788 _NC1789 OR2X1
X852 N138 Opa_i[11] Opa_i[13] Opa_i[12] N131 _NC1790 _NC1791 NOR4X0
X853 Opa_i[19] Opa_i[18] Opa_i[17] N137 _NC1792 _NC1793 OR3X1
X854 N137 Opa_i[14] Opa_i[16] Opa_i[15] N132 _NC1794 _NC1795 NOR4X0
X855 Opa_i[3] Opa_i[2] Opa_i[22] N136 _NC1796 _NC1797 OR3X1
X856 N136 Opa_i[1] Opa_i[21] Opa_i[20] N133 _NC1798 _NC1799 NOR4X0
X857 Opa_i[9] Opa_i[8] Opa_i[7] N135 _NC1800 _NC1801 OR3X1
X858 N135 Opa_i[4] Opa_i[6] Opa_i[5] N134 _NC1802 _NC1803 NOR4X0
X859 N131 N132 N133 N134 N130 _NC1804 _NC1805 NAND4X0
X860 N121 N128 N3230 N118 _NC1806 _NC1807 AO21X1
X861 S_fracto28_rnd[26] S_fracto28_rnd[27] S_fracto28_rnd[25] N57 N127 _NC1808 _NC1809 AO22X1
X862 N125 N57 N122 _NC1810 _NC1811 AND2X1
X863 S_fracto28_rnd[27] N125 N123 _NC1812 _NC1813 AND2X1
X864 N122 S_expo9_2[0] N123 N1092 N55 S_output_o[23] _NC1814 _NC1815 AO221X1
X865 N122 S_expo9_2[1] N123 N1093 N55 S_output_o[24] _NC1816 _NC1817 AO221X1
X866 N122 S_expo9_2[2] N123 N1094 N55 S_output_o[25] _NC1818 _NC1819 AO221X1
X867 N122 S_expo9_2[3] N123 N1095 N55 S_output_o[26] _NC1820 _NC1821 AO221X1
X868 N122 S_expo9_2[4] N123 N1096 N55 S_output_o[27] _NC1822 _NC1823 AO221X1
X869 N122 S_expo9_2[5] N123 N1097 N55 S_output_o[28] _NC1824 _NC1825 AO221X1
X870 N122 S_expo9_2[6] N123 N1098 N55 S_output_o[29] _NC1826 _NC1827 AO221X1
X871 S_fracto28_rnd[6] N113 S_fracto28_rnd[5] N19 S_output_o[2] _NC1828 _NC1829 AO22X1
X872 N122 S_expo9_2[7] N123 N1099 N55 S_output_o[30] _NC1830 _NC1831 AO221X1
X873 N3230 N120 N121 N119 _NC1832 _NC1833 NAND3X0
X874 Opa_i[31] N3230 Opb_i[31] N117 N116 _NC1834 _NC1835 AO22X1
X875 Sign_i N115 N3220 N116 S_output_o[31] _NC1836 _NC1837 AO22X1
X876 S_fracto28_rnd[7] N113 S_fracto28_rnd[6] N114 S_output_o[3] _NC1838 _NC1839 AO22X1
X877 S_fracto28_rnd[8] N113 S_fracto28_rnd[7] N19 S_output_o[4] _NC1840 _NC1841 AO22X1
X878 S_fracto28_rnd[9] N113 S_fracto28_rnd[8] N114 S_output_o[5] _NC1842 _NC1843 AO22X1
X879 S_fracto28_rnd[10] N113 S_fracto28_rnd[9] N19 S_output_o[6] _NC1844 _NC1845 AO22X1
X880 S_fracto28_rnd[11] N113 S_fracto28_rnd[10] N114 S_output_o[7] _NC1846 _NC1847 AO22X1
X881 N113 S_fracto28_rnd[12] S_fracto28_rnd[11] N19 S_output_o[8] _NC1848 _NC1849 AO22X1
X882 S_fracto28_rnd[13] N113 S_fracto28_rnd[12] N114 S_output_o[9] _NC1850 _NC1851 AO22X1
X883 S_fracto28_1[1] S_fracto28_1[0] N112 N107 _NC1852 _NC1853 NOR3X0
X884 S_fracto28_1[2] N111 N3250 N3240 N105 _NC1854 _NC1855 NAND4X0
X885 N110 Sign_i N108 _NC1856 _NC1857 OR2X1
X886 Rmode_i[1] N110 Sign_i N109 _NC1858 _NC1859 NAND3X0
X887 N107 N40 N108 N109 N106 _NC1860 _NC1861 AO22X1
X888 Clk_i S_output_o[23] Output_o[23] _NC1862 _NC1863 _NC1864 DFFX1
X889 Clk_i S_output_o[24] Output_o[24] _NC1865 _NC1866 _NC1867 DFFX1
X890 Clk_i S_output_o[25] Output_o[25] _NC1868 _NC1869 _NC1870 DFFX1
X891 Clk_i S_output_o[26] Output_o[26] _NC1871 _NC1872 _NC1873 DFFX1
X892 Clk_i S_output_o[27] Output_o[27] _NC1874 _NC1875 _NC1876 DFFX1
X893 Clk_i S_output_o[28] Output_o[28] _NC1877 _NC1878 _NC1879 DFFX1
X894 Clk_i S_output_o[29] Output_o[29] _NC1880 _NC1881 _NC1882 DFFX1
X895 Clk_i S_output_o[30] Output_o[30] _NC1883 _NC1884 _NC1885 DFFX1
X896 Clk_i S_output_o[22] Output_o[22] _NC1886 _NC1887 _NC1888 DFFX1
X897 Clk_i S_output_o[0] Output_o[0] _NC1889 _NC1890 _NC1891 DFFX1
X898 Clk_i S_output_o[10] Output_o[10] _NC1892 _NC1893 _NC1894 DFFX1
X899 Clk_i S_output_o[11] Output_o[11] _NC1895 _NC1896 _NC1897 DFFX1
X900 Clk_i S_output_o[12] Output_o[12] _NC1898 _NC1899 _NC1900 DFFX1
X901 Clk_i S_output_o[13] Output_o[13] _NC1901 _NC1902 _NC1903 DFFX1
X902 Clk_i S_output_o[14] Output_o[14] _NC1904 _NC1905 _NC1906 DFFX1
X903 Clk_i S_output_o[15] Output_o[15] _NC1907 _NC1908 _NC1909 DFFX1
X904 Clk_i S_output_o[16] Output_o[16] _NC1910 _NC1911 _NC1912 DFFX1
X905 Clk_i S_output_o[17] Output_o[17] _NC1913 _NC1914 _NC1915 DFFX1
X906 Clk_i S_output_o[18] Output_o[18] _NC1916 _NC1917 _NC1918 DFFX1
X907 Clk_i S_output_o[19] Output_o[19] _NC1919 _NC1920 _NC1921 DFFX1
X908 Clk_i S_output_o[1] Output_o[1] _NC1922 _NC1923 _NC1924 DFFX1
X909 Clk_i S_output_o[20] Output_o[20] _NC1925 _NC1926 _NC1927 DFFX1
X910 Clk_i S_output_o[21] Output_o[21] _NC1928 _NC1929 _NC1930 DFFX1
X911 Clk_i S_output_o[2] Output_o[2] _NC1931 _NC1932 _NC1933 DFFX1
X912 Clk_i S_output_o[3] Output_o[3] _NC1934 _NC1935 _NC1936 DFFX1
X913 Clk_i S_output_o[4] Output_o[4] _NC1937 _NC1938 _NC1939 DFFX1
X914 Clk_i S_output_o[5] Output_o[5] _NC1940 _NC1941 _NC1942 DFFX1
X915 Clk_i S_output_o[6] Output_o[6] _NC1943 _NC1944 _NC1945 DFFX1
X916 Clk_i S_output_o[7] Output_o[7] _NC1946 _NC1947 _NC1948 DFFX1
X917 Clk_i S_output_o[8] Output_o[8] _NC1949 _NC1950 _NC1951 DFFX1
X918 Clk_i S_output_o[9] Output_o[9] _NC1952 _NC1953 _NC1954 DFFX1
X919 Clk_i N1176 Ine_o _NC1955 _NC1956 _NC1957 DFFX1
X920 Clk_i N1027 S_fracto28_1[0] _NC1958 _NC1959 _NC1960 DFFX1
X921 Clk_i N1028 S_fracto28_1[1] _NC1961 _NC1962 _NC1963 DFFX1
X922 Clk_i N1029 S_fracto28_1[2] N40 _NC1964 _NC1965 DFFX1
X923 Clk_i N1030 S_fracto28_1[3] N39 _NC1966 _NC1967 DFFX1
X924 Clk_i N1031 S_fracto28_1[4] _NC1968 _NC1969 _NC1970 DFFX1
X925 Clk_i N1032 S_fracto28_1[5] _NC1971 _NC1972 _NC1973 DFFX1
X926 Clk_i N1033 S_fracto28_1[6] _NC1974 _NC1975 _NC1976 DFFX1
X927 Clk_i N1034 S_fracto28_1[7] _NC1977 _NC1978 _NC1979 DFFX1
X928 Clk_i N1035 S_fracto28_1[8] _NC1980 _NC1981 _NC1982 DFFX1
X929 Clk_i N1036 S_fracto28_1[9] _NC1983 _NC1984 _NC1985 DFFX1
X930 Clk_i N1037 S_fracto28_1[10] _NC1986 _NC1987 _NC1988 DFFX1
X931 Clk_i N1038 S_fracto28_1[11] _NC1989 _NC1990 _NC1991 DFFX1
X932 Clk_i N1039 S_fracto28_1[12] _NC1992 _NC1993 _NC1994 DFFX1
X933 Clk_i N1040 S_fracto28_1[13] _NC1995 _NC1996 _NC1997 DFFX1
X934 Clk_i N1041 S_fracto28_1[14] _NC1998 _NC1999 _NC2000 DFFX1
X935 Clk_i N1042 S_fracto28_1[15] _NC2001 _NC2002 _NC2003 DFFX1
X936 Clk_i N1043 S_fracto28_1[16] _NC2004 _NC2005 _NC2006 DFFX1
X937 Clk_i N1044 S_fracto28_1[17] _NC2007 _NC2008 _NC2009 DFFX1
X938 Clk_i N1045 S_fracto28_1[18] _NC2010 _NC2011 _NC2012 DFFX1
X939 Clk_i N1046 S_fracto28_1[19] _NC2013 _NC2014 _NC2015 DFFX1
X940 Clk_i N1047 S_fracto28_1[20] _NC2016 _NC2017 _NC2018 DFFX1
X941 Clk_i N1048 S_fracto28_1[21] _NC2019 _NC2020 _NC2021 DFFX1
X942 Clk_i N1049 S_fracto28_1[22] _NC2022 _NC2023 _NC2024 DFFX1
X943 Clk_i N1050 S_fracto28_1[23] _NC2025 _NC2026 _NC2027 DFFX1
X944 Clk_i N1051 S_fracto28_1[24] _NC2028 _NC2029 _NC2030 DFFX1
X945 Clk_i N1052 S_fracto28_1[25] _NC2031 _NC2032 _NC2033 DFFX1
X946 Clk_i N1053 S_fracto28_1[26] _NC2034 _NC2035 _NC2036 DFFX1
X947 Clk_i N1054 S_fracto28_1[27] _NC2037 _NC2038 _NC2039 DFFX1
X948 Clk_i N950 N4 N8 _NC2040 _NC2041 DFFX1
X949 Clk_i N951 N5 N7 _NC2042 _NC2043 DFFX1
X950 Clk_i N952 N3 N9 _NC2044 _NC2045 DFFX1
X951 Clk_i N953 N2 N6 _NC2046 _NC2047 DFFX1
X952 Clk_i N954 S_shl1[0] _NC2048 _NC2049 _NC2050 DFFX1
X953 Clk_i N955 S_shl1[1] _NC2051 _NC2052 _NC2053 DFFX1
X954 Clk_i Fract_28_i[27] S_shr1[0] N10 N155 Vdd _NC2054 _NC2055 DFFSSRX1
X955 Clk_i S_exp10[0] S_expo9_1[0] _NC2056 Vdd N155 _NC2057 _NC2058 DFFSSRX1
X956 Clk_i N957 S_expo9_1[1] _NC2059 _NC2060 _NC2061 DFFX1
X957 Clk_i N958 S_expo9_1[2] _NC2062 _NC2063 _NC2064 DFFX1
X958 Clk_i N959 S_expo9_1[3] _NC2065 _NC2066 _NC2067 DFFX1
X959 Clk_i N960 S_expo9_1[4] _NC2068 _NC2069 _NC2070 DFFX1
X960 Clk_i N961 S_expo9_1[5] _NC2071 _NC2072 _NC2073 DFFX1
X961 Clk_i N962 S_expo9_1[6] _NC2074 _NC2075 _NC2076 DFFX1
X962 Clk_i N963 S_expo9_1[7] _NC2077 _NC2078 _NC2079 DFFX1
X963 Clk_i S_output_o[31] Output_o[31] _NC2080 _NC2081 _NC2082 DFFX1
.ENDS post_norm_addsub

.SUBCKT post_norm_addsub_DW01_add_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] CO
X0 A[3] B[3] SUM[3] _NC0 _NC1 XOR2X1
X1 A[4] N17 SUM[4] _NC2 _NC3 XOR2X1
X2 A[5] N18 SUM[5] _NC4 _NC5 XOR2X1
X3 A[6] N19 SUM[6] _NC6 _NC7 XOR2X1
X4 A[7] N1 SUM[7] _NC8 _NC9 XOR2X1
X5 A[8] N2 SUM[8] _NC10 _NC11 XOR2X1
X6 A[9] N3 SUM[9] _NC12 _NC13 XOR2X1
X7 A[10] N4 SUM[10] _NC14 _NC15 XOR2X1
X8 A[11] N5 SUM[11] _NC16 _NC17 XOR2X1
X9 A[12] N6 SUM[12] _NC18 _NC19 XOR2X1
X10 A[13] N7 SUM[13] _NC20 _NC21 XOR2X1
X11 A[14] N8 SUM[14] _NC22 _NC23 XOR2X1
X12 A[15] N20 SUM[15] _NC24 _NC25 XOR2X1
X13 A[16] N21 SUM[16] _NC26 _NC27 XOR2X1
X14 A[17] N9 SUM[17] _NC28 _NC29 XOR2X1
X15 A[18] N10 SUM[18] _NC30 _NC31 XOR2X1
X16 A[19] N11 SUM[19] _NC32 _NC33 XOR2X1
X17 A[20] N12 SUM[20] _NC34 _NC35 XOR2X1
X18 A[21] N13 SUM[21] _NC36 _NC37 XOR2X1
X19 A[22] N14 SUM[22] _NC38 _NC39 XOR2X1
X20 A[23] N15 SUM[23] _NC40 _NC41 XOR2X1
X21 A[24] N22 SUM[24] _NC42 _NC43 XOR2X1
X22 A[25] N16 SUM[25] _NC44 _NC45 XOR2X1
X23 A[26] N23 SUM[26] _NC46 _NC47 XOR2X1
X24 A[1] _NC48 _NC49 SUM[1] NBUFFX2
X25 A[25] N16 N23 _NC50 _NC51 AND2X1
X26 A[23] N15 N22 _NC52 _NC53 AND2X1
X27 A[15] N20 N21 _NC54 _NC55 AND2X1
X28 A[14] N8 N20 _NC56 _NC57 AND2X1
X29 A[5] N18 N19 _NC58 _NC59 AND2X1
X30 A[4] N17 N18 _NC60 _NC61 AND2X1
X31 A[3] B[3] N17 _NC62 _NC63 AND2X1
X32 A[24] N22 N16 _NC64 _NC65 AND2X1
X33 A[22] N14 N15 _NC66 _NC67 AND2X1
X34 A[21] N13 N14 _NC68 _NC69 AND2X1
X35 A[20] N12 N13 _NC70 _NC71 AND2X1
X36 A[19] N11 N12 _NC72 _NC73 AND2X1
X37 A[18] N10 N11 _NC74 _NC75 AND2X1
X38 A[17] N9 N10 _NC76 _NC77 AND2X1
X39 A[16] N21 N9 _NC78 _NC79 AND2X1
X40 A[13] N7 N8 _NC80 _NC81 AND2X1
X41 A[12] N6 N7 _NC82 _NC83 AND2X1
X42 A[11] N5 N6 _NC84 _NC85 AND2X1
X43 A[10] N4 N5 _NC86 _NC87 AND2X1
X44 A[9] N3 N4 _NC88 _NC89 AND2X1
X45 A[8] N2 N3 _NC90 _NC91 AND2X1
X46 A[7] N1 N2 _NC92 _NC93 AND2X1
X47 A[6] N19 N1 _NC94 _NC95 AND2X1
X48 A[26] N23 N27 _NC96 _NC97 NAND2X1
X49 A[27] N27 SUM[27] _NC98 _NC99 XNOR2X1
X50 A[2] _NC100 _NC101 SUM[2] NBUFFX2
X51 A[0] _NC102 _NC103 SUM[0] NBUFFX2
.ENDS post_norm_addsub_DW01_add_0

.SUBCKT post_norm_addsub_DW01_inc_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8]
X0 A[0] _NC0 _NC1 SUM[0] INVX0
X1 Carry[6] A[8] SUM[8] _NC2 _NC3 XOR2X1
X2 A[1] A[0] Carry[0] _NC4 _NC5 _NC6 HADDX1
X3 A[2] Carry[0] Carry[1] _NC7 _NC8 _NC9 HADDX1
X4 A[3] Carry[1] Carry[2] _NC10 _NC11 _NC12 HADDX1
X5 A[4] Carry[2] Carry[3] _NC13 _NC14 _NC15 HADDX1
X6 A[5] Carry[3] Carry[4] _NC16 _NC17 _NC18 HADDX1
X7 A[6] Carry[4] Carry[5] _NC19 _NC20 _NC21 HADDX1
X8 A[7] Carry[5] Carry[6] _NC22 _NC23 _NC24 HADDX1
.ENDS post_norm_addsub_DW01_inc_0

.SUBCKT addsub_28 Clk_i Fpu_op_i Fracta_i[0] Fracta_i[1] Fracta_i[2] Fracta_i[3] Fracta_i[4] Fracta_i[5] Fracta_i[6] Fracta_i[7] Fracta_i[8] Fracta_i[9] Fracta_i[10] Fracta_i[11] Fracta_i[12] Fracta_i[13] Fracta_i[14] Fracta_i[15] Fracta_i[16] Fracta_i[17] Fracta_i[18] Fracta_i[19] Fracta_i[20] Fracta_i[21] Fracta_i[22] Fracta_i[23] Fracta_i[24] Fracta_i[25] Fracta_i[26] Fracta_i[27] Fractb_i[0] Fractb_i[1] Fractb_i[2] Fractb_i[3] Fractb_i[4] Fractb_i[5] Fractb_i[6] Fractb_i[7] Fractb_i[8] Fractb_i[9] Fractb_i[10] Fractb_i[11] Fractb_i[12] Fractb_i[13] Fractb_i[14] Fractb_i[15] Fractb_i[16] Fractb_i[17] Fractb_i[18] Fractb_i[19] Fractb_i[20] Fractb_i[21] Fractb_i[22] Fractb_i[23] Fractb_i[24] Fractb_i[25] Fractb_i[26] Fractb_i[27] Signa_i Signb_i Fract_o[0] Fract_o[1] Fract_o[2] Fract_o[3] Fract_o[4] Fract_o[5] Fract_o[6] Fract_o[7] Fract_o[8] Fract_o[9] Fract_o[10] Fract_o[11] Fract_o[12] Fract_o[13] Fract_o[14] Fract_o[15] Fract_o[16] Fract_o[17] Fract_o[18] Fract_o[19] Fract_o[20] Fract_o[21] Fract_o[22] Fract_o[23] Fract_o[24] Fract_o[25] Fract_o[26] Fract_o[27] Sign_o
X0 Signa_i _NC0 _NC1 N29 INVX0
X1 Signb_i _NC2 _NC3 N30 INVX0
X2 N14 N15 S_sign_o _NC4 _NC5 NOR2X0
X3 N67 N6 N28 _NC6 _NC7 NOR2X0
X4 N13 N67 N27 _NC8 _NC9 NOR2X0
X5 N29 N30 N26 _NC10 _NC11 NOR2X0
X6 N22 N23 N17 _NC12 _NC13 NAND2X1
X7 N6 _NC14 _NC15 N13 INVX0
X8 N27 _NC16 _NC17 N12 NBUFFX2
X9 N28 _NC18 _NC19 N9 NBUFFX2
X10 N27 _NC20 _NC21 N10 NBUFFX2
X11 N27 _NC22 _NC23 N11 NBUFFX2
X12 N28 _NC24 _NC25 N7 NBUFFX2
X13 N28 _NC26 _NC27 N8 NBUFFX2
X14 N30 N29 Fpu_op_i N67 _NC28 _NC29 XNOR3X1
X15 Fractb_i[0] Fractb_i[1] Fractb_i[2] Fractb_i[3] Fractb_i[4] Fractb_i[5] Fractb_i[6] Fractb_i[7] Fractb_i[8] Fractb_i[9] Fractb_i[10] Fractb_i[11] Fractb_i[12] Fractb_i[13] Fractb_i[14] Fractb_i[15] Fractb_i[16] Fractb_i[17] Fractb_i[18] Fractb_i[19] Fractb_i[20] Fractb_i[21] Fractb_i[22] Fractb_i[23] Fractb_i[24] Fractb_i[25] Fractb_i[26] Fractb_i[27] Fracta_i[0] Fracta_i[1] Fracta_i[2] Fracta_i[3] Fracta_i[4] Fracta_i[5] Fracta_i[6] Fracta_i[7] Fracta_i[8] Fracta_i[9] Fracta_i[10] Fracta_i[11] Fracta_i[12] Fracta_i[13] Fracta_i[14] Fracta_i[15] Fracta_i[16] Fracta_i[17] Fracta_i[18] Fracta_i[19] Fracta_i[20] Fracta_i[21] Fracta_i[22] Fracta_i[23] Fracta_i[24] Fracta_i[25] Fracta_i[26] Fracta_i[27] Vss Vdd Vss N6 _NC30 addsub_28_DW_cmp_0
X16 Fracta_i[0] Fracta_i[1] Fracta_i[2] Fracta_i[3] Fracta_i[4] Fracta_i[5] Fracta_i[6] Fracta_i[7] Fracta_i[8] Fracta_i[9] Fracta_i[10] Fracta_i[11] Fracta_i[12] Fracta_i[13] Fracta_i[14] Fracta_i[15] Fracta_i[16] Fracta_i[17] Fracta_i[18] Fracta_i[19] Fracta_i[20] Fracta_i[21] Fracta_i[22] Fracta_i[23] Fracta_i[24] Fracta_i[25] Fracta_i[26] Fracta_i[27] Fractb_i[0] Fractb_i[1] Fractb_i[2] Fractb_i[3] Fractb_i[4] Fractb_i[5] Fractb_i[6] Fractb_i[7] Fractb_i[8] Fractb_i[9] Fractb_i[10] Fractb_i[11] Fractb_i[12] Fractb_i[13] Fractb_i[14] Fractb_i[15] Fractb_i[16] Fractb_i[17] Fractb_i[18] Fractb_i[19] Fractb_i[20] Fractb_i[21] Fractb_i[22] Fractb_i[23] Fractb_i[24] Fractb_i[25] Fractb_i[26] Fractb_i[27] Vss N39 N40 N41 N42 N43 N44 N45 N46 N47 N48 N49 N50 N51 N52 N53 N54 N55 N56 N57 N58 N59 N60 N61 N62 N63 N64 N65 N66 _NC31 addsub_28_DW01_add_0
X17 Fracta_i[0] Fracta_i[1] Fracta_i[2] Fracta_i[3] Fracta_i[4] Fracta_i[5] Fracta_i[6] Fracta_i[7] Fracta_i[8] Fracta_i[9] Fracta_i[10] Fracta_i[11] Fracta_i[12] Fracta_i[13] Fracta_i[14] Fracta_i[15] Fracta_i[16] Fracta_i[17] Fracta_i[18] Fracta_i[19] Fracta_i[20] Fracta_i[21] Fracta_i[22] Fracta_i[23] Fracta_i[24] Fracta_i[25] Fracta_i[26] Fracta_i[27] Fractb_i[0] Fractb_i[1] Fractb_i[2] Fractb_i[3] Fractb_i[4] Fractb_i[5] Fractb_i[6] Fractb_i[7] Fractb_i[8] Fractb_i[9] Fractb_i[10] Fractb_i[11] Fractb_i[12] Fractb_i[13] Fractb_i[14] Fractb_i[15] Fractb_i[16] Fractb_i[17] Fractb_i[18] Fractb_i[19] Fractb_i[20] Fractb_i[21] Fractb_i[22] Fractb_i[23] Fractb_i[24] Fractb_i[25] Fractb_i[26] Fractb_i[27] Vss N68 N69 N70 N71 N72 N73 N74 N75 N76 N77 N78 N79 N80 N81 N82 N83 N84 N85 N86 N87 N88 N89 N90 N91 N92 N93 N94 N95 _NC32 addsub_28_DW01_sub_1
X18 Fractb_i[0] Fractb_i[1] Fractb_i[2] Fractb_i[3] Fractb_i[4] Fractb_i[5] Fractb_i[6] Fractb_i[7] Fractb_i[8] Fractb_i[9] Fractb_i[10] Fractb_i[11] Fractb_i[12] Fractb_i[13] Fractb_i[14] Fractb_i[15] Fractb_i[16] Fractb_i[17] Fractb_i[18] Fractb_i[19] Fractb_i[20] Fractb_i[21] Fractb_i[22] Fractb_i[23] Fractb_i[24] Fractb_i[25] Fractb_i[26] Fractb_i[27] Fracta_i[0] Fracta_i[1] Fracta_i[2] Fracta_i[3] Fracta_i[4] Fracta_i[5] Fracta_i[6] Fracta_i[7] Fracta_i[8] Fracta_i[9] Fracta_i[10] Fracta_i[11] Fracta_i[12] Fracta_i[13] Fracta_i[14] Fracta_i[15] Fracta_i[16] Fracta_i[17] Fracta_i[18] Fracta_i[19] Fracta_i[20] Fracta_i[21] Fracta_i[22] Fracta_i[23] Fracta_i[24] Fracta_i[25] Fracta_i[26] Fracta_i[27] Vss N96 N97 N98 N99 N100 N101 N102 N103 N104 N105 N106 N107 N108 N109 N110 N111 N112 N113 N114 N115 N116 N117 N118 N119 N120 N121 N122 N123 _NC33 addsub_28_DW01_sub_0
X19 N68 N12 N96 N9 N39 N67 S_fract_o[0] _NC34 _NC35 AO222X1
X20 N78 N12 N106 N9 N49 N67 S_fract_o[10] _NC36 _NC37 AO222X1
X21 N79 N12 N107 N9 N50 N67 S_fract_o[11] _NC38 _NC39 AO222X1
X22 N80 N12 N108 N9 N51 N67 S_fract_o[12] _NC40 _NC41 AO222X1
X23 N81 N11 N109 N8 N52 N67 S_fract_o[13] _NC42 _NC43 AO222X1
X24 N82 N11 N110 N8 N53 N67 S_fract_o[14] _NC44 _NC45 AO222X1
X25 N83 N11 N111 N8 N54 N67 S_fract_o[15] _NC46 _NC47 AO222X1
X26 N84 N11 N112 N8 N55 N67 S_fract_o[16] _NC48 _NC49 AO222X1
X27 N85 N11 N113 N8 N56 N67 S_fract_o[17] _NC50 _NC51 AO222X1
X28 N86 N11 N114 N8 N57 N67 S_fract_o[18] _NC52 _NC53 AO222X1
X29 N87 N11 N115 N8 N58 N67 S_fract_o[19] _NC54 _NC55 AO222X1
X30 N69 N11 N97 N8 N40 N67 S_fract_o[1] _NC56 _NC57 AO222X1
X31 N88 N11 N116 N8 N59 N67 S_fract_o[20] _NC58 _NC59 AO222X1
X32 N89 N11 N117 N8 N60 N67 S_fract_o[21] _NC60 _NC61 AO222X1
X33 N90 N11 N118 N8 N61 N67 S_fract_o[22] _NC62 _NC63 AO222X1
X34 N91 N11 N119 N8 N62 N67 S_fract_o[23] _NC64 _NC65 AO222X1
X35 N92 N10 N120 N7 N63 N67 S_fract_o[24] _NC66 _NC67 AO222X1
X36 N93 N10 N121 N7 N64 N67 S_fract_o[25] _NC68 _NC69 AO222X1
X37 N94 N10 N122 N7 N65 N67 S_fract_o[26] _NC70 _NC71 AO222X1
X38 N95 N10 N123 N7 N66 N67 S_fract_o[27] _NC72 _NC73 AO222X1
X39 N70 N10 N98 N7 N41 N67 S_fract_o[2] _NC74 _NC75 AO222X1
X40 N71 N10 N99 N7 N42 N67 S_fract_o[3] _NC76 _NC77 AO222X1
X41 N72 N10 N100 N7 N43 N67 S_fract_o[4] _NC78 _NC79 AO222X1
X42 N73 N10 N101 N7 N44 N67 S_fract_o[5] _NC80 _NC81 AO222X1
X43 N74 N10 N102 N7 N45 N67 S_fract_o[6] _NC82 _NC83 AO222X1
X44 N75 N10 N103 N7 N46 N67 S_fract_o[7] _NC84 _NC85 AO222X1
X45 N76 N10 N104 N7 N47 N67 S_fract_o[8] _NC86 _NC87 AO222X1
X46 N77 N10 N105 N7 N48 N67 S_fract_o[9] _NC88 _NC89 AO222X1
X47 S_fract_o[11] S_fract_o[12] S_fract_o[13] S_fract_o[14] N25 _NC90 _NC91 OR4X1
X48 N25 N26 S_fract_o[10] S_fract_o[0] N22 _NC92 _NC93 NOR4X0
X49 S_fract_o[18] S_fract_o[19] S_fract_o[1] S_fract_o[20] N24 _NC94 _NC95 OR4X1
X50 N24 S_fract_o[15] S_fract_o[17] S_fract_o[16] N23 _NC96 _NC97 NOR4X0
X51 S_fract_o[27] S_fract_o[26] S_fract_o[25] S_fract_o[24] N21 _NC98 _NC99 OR4X1
X52 S_fract_o[22] S_fract_o[23] S_fract_o[21] N21 N18 _NC100 _NC101 OR4X1
X53 S_fract_o[6] S_fract_o[7] S_fract_o[8] S_fract_o[9] N19 _NC102 _NC103 OR4X1
X54 S_fract_o[2] S_fract_o[3] S_fract_o[4] S_fract_o[5] N20 _NC104 _NC105 OR4X1
X55 N17 N18 N19 N20 N14 _NC106 _NC107 NOR4X0
X56 Fpu_op_i N30 N16 _NC108 _NC109 XOR2X1
X57 N6 N16 N29 N13 N15 _NC110 _NC111 OA22X1
X58 Clk_i S_sign_o Sign_o _NC112 _NC113 _NC114 DFFX1
X59 Clk_i S_fract_o[0] Fract_o[0] _NC115 _NC116 _NC117 DFFX1
X60 Clk_i S_fract_o[1] Fract_o[1] _NC118 _NC119 _NC120 DFFX1
X61 Clk_i S_fract_o[2] Fract_o[2] _NC121 _NC122 _NC123 DFFX1
X62 Clk_i S_fract_o[3] Fract_o[3] _NC124 _NC125 _NC126 DFFX1
X63 Clk_i S_fract_o[4] Fract_o[4] _NC127 _NC128 _NC129 DFFX1
X64 Clk_i S_fract_o[5] Fract_o[5] _NC130 _NC131 _NC132 DFFX1
X65 Clk_i S_fract_o[6] Fract_o[6] _NC133 _NC134 _NC135 DFFX1
X66 Clk_i S_fract_o[7] Fract_o[7] _NC136 _NC137 _NC138 DFFX1
X67 Clk_i S_fract_o[8] Fract_o[8] _NC139 _NC140 _NC141 DFFX1
X68 Clk_i S_fract_o[9] Fract_o[9] _NC142 _NC143 _NC144 DFFX1
X69 Clk_i S_fract_o[10] Fract_o[10] _NC145 _NC146 _NC147 DFFX1
X70 Clk_i S_fract_o[11] Fract_o[11] _NC148 _NC149 _NC150 DFFX1
X71 Clk_i S_fract_o[12] Fract_o[12] _NC151 _NC152 _NC153 DFFX1
X72 Clk_i S_fract_o[13] Fract_o[13] _NC154 _NC155 _NC156 DFFX1
X73 Clk_i S_fract_o[14] Fract_o[14] _NC157 _NC158 _NC159 DFFX1
X74 Clk_i S_fract_o[15] Fract_o[15] _NC160 _NC161 _NC162 DFFX1
X75 Clk_i S_fract_o[16] Fract_o[16] _NC163 _NC164 _NC165 DFFX1
X76 Clk_i S_fract_o[17] Fract_o[17] _NC166 _NC167 _NC168 DFFX1
X77 Clk_i S_fract_o[18] Fract_o[18] _NC169 _NC170 _NC171 DFFX1
X78 Clk_i S_fract_o[19] Fract_o[19] _NC172 _NC173 _NC174 DFFX1
X79 Clk_i S_fract_o[20] Fract_o[20] _NC175 _NC176 _NC177 DFFX1
X80 Clk_i S_fract_o[21] Fract_o[21] _NC178 _NC179 _NC180 DFFX1
X81 Clk_i S_fract_o[22] Fract_o[22] _NC181 _NC182 _NC183 DFFX1
X82 Clk_i S_fract_o[23] Fract_o[23] _NC184 _NC185 _NC186 DFFX1
X83 Clk_i S_fract_o[24] Fract_o[24] _NC187 _NC188 _NC189 DFFX1
X84 Clk_i S_fract_o[25] Fract_o[25] _NC190 _NC191 _NC192 DFFX1
X85 Clk_i S_fract_o[26] Fract_o[26] _NC193 _NC194 _NC195 DFFX1
X86 Clk_i S_fract_o[27] Fract_o[27] _NC196 _NC197 _NC198 DFFX1
.ENDS addsub_28

.SUBCKT addsub_28_DW_cmp_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
X0 N1139 B[21] N1209 _NC0 _NC1 NOR2X0
X1 A[20] N1209 N1217 _NC2 _NC3 NOR2X0
X2 N1141 B[23] N1216 _NC4 _NC5 NOR2X0
X3 A[22] N1216 N1218 _NC6 _NC7 NOR2X0
X4 B[23] N1141 N1218 B[22] N1215 _NC8 _NC9 AO22X1
X5 B[21] N1139 N1217 B[20] N1215 N1201 _NC10 _NC11 AO221X1
X6 A[22] N1140 N1216 N1208 _NC12 _NC13 AOI21X1
X7 N1215 N1208 N1202 _NC14 _NC15 OR2X1
X8 N1135 B[19] N1214 _NC16 _NC17 NOR2X0
X9 A[18] N1134 N1214 N1151 _NC18 _NC19 AO21X1
X10 A[18] N1214 N1213 _NC20 _NC21 NOR2X0
X11 B[19] N1135 N1213 B[18] N1210 _NC22 _NC23 AO22X1
X12 N1132 B[17] N1157 _NC24 _NC25 NOR2X0
X13 A[16] N1157 N1212 _NC26 _NC27 NOR2X0
X14 B[17] N1132 N1212 B[16] N1210 N1211 _NC28 _NC29 AO221X1
X15 N1133 N1210 N1211 N1203 _NC30 _NC31 OA21X1
X16 A[20] N1137 N1207 _NC32 _NC33 NAND2X0
X17 N1138 N1207 N1208 N1152 _NC34 _NC35 NAND3X0
X18 N1145 B[26] N1197 _NC36 _NC37 NOR2X0
X19 N1146 B[27] N1196 _NC38 _NC39 NOR2X0
X20 N1197 N1196 N1204 _NC40 _NC41 NOR2X0
X21 N1144 B[25] N1198 _NC42 _NC43 NOR2X0
X22 A[24] N1198 N1206 _NC44 _NC45 NOR2X0
X23 N1206 B[24] B[25] N1144 B[26] N1145 N1205 _NC46 _NC47 AO222X1
X24 B[27] N1146 N1204 N1205 N1200 _NC48 _NC49 AO22X1
X25 N1201 N1202 N1203 N1136 N1200 N1147 _NC50 _NC51 AO221X1
X26 N1143 B[24] N1199 _NC52 _NC53 NOR2X0
X27 N1196 N1197 N1198 N1199 N1153 _NC54 _NC55 OR4X1
X28 N1142 N1153 N1148 _NC56 _NC57 NAND2X0
X29 N1118 B[7] N1185 _NC58 _NC59 NOR2X0
X30 A[6] N1117 N1185 N1183 _NC60 _NC61 AO21X1
X31 B[1] N1111 N1195 _NC62 _NC63 NOR2X0
X32 A[0] N1195 N1193 _NC64 _NC65 NOR2X0
X33 N1113 B[3] N1192 _NC66 _NC67 NOR2X0
X34 A[2] N1192 N1194 _NC68 _NC69 NOR2X0
X35 B[3] N1113 N1194 B[2] N1191 _NC70 _NC71 AO22X1
X36 B[1] N1111 N1193 B[0] N1191 N1188 _NC72 _NC73 AO221X1
X37 N1112 A[2] N1192 N1190 _NC74 _NC75 AOI21X1
X38 A[5] N1115 N1187 _NC76 _NC77 NAND2X0
X39 N1190 N1191 B[4] N1114 N1187 N1189 _NC78 _NC79 OA221X1
X40 N1116 N1188 N1189 N1164 _NC80 _NC81 NAND3X0
X41 N1187 N1114 B[4] N1186 _NC82 _NC83 NAND3X0
X42 A[5] N1115 N1186 N1181 _NC84 _NC85 OA21X1
X43 A[6] N1185 N1184 _NC86 _NC87 NOR2X0
X44 B[7] N1118 N1184 B[6] N1182 _NC88 _NC89 AOI22X1
X45 N1181 N1182 N1182 N1183 N1165 _NC90 _NC91 AO22X1
X46 A[13] N1126 N1170 _NC92 _NC93 NAND2X0
X47 N1170 N1125 B[12] N1180 _NC94 _NC95 NAND3X0
X48 A[13] N1126 N1180 N1176 _NC96 _NC97 OA21X1
X49 N1129 B[15] N1178 _NC98 _NC99 NOR2X0
X50 A[14] N1178 N1179 _NC100 _NC101 NOR2X0
X51 B[15] N1129 N1179 B[14] N1177 _NC102 _NC103 AOI22X1
X52 A[14] N1128 N1178 N1172 _NC104 _NC105 AO21X1
X53 N1176 N1177 N1177 N1172 N1166 _NC106 _NC107 AO22X1
X54 N1123 B[11] N1174 _NC108 _NC109 NOR2X0
X55 A[10] N1174 N1175 _NC110 _NC111 NOR2X0
X56 B[11] N1123 N1175 B[10] N1168 _NC112 _NC113 AOI22X1
X57 A[10] N1122 N1174 N1163 _NC114 _NC115 AO21X1
X58 A[9] N1120 N1160 _NC116 _NC117 NAND2X0
X59 N1160 N1119 B[8] N1173 _NC118 _NC119 NAND3X0
X60 A[9] N1120 N1173 N1169 _NC120 _NC121 OA21X1
X61 N1125 B[12] N1171 _NC122 _NC123 OR2X1
X62 N1170 N1171 N1127 N1162 _NC124 _NC125 NAND3X0
X63 N1168 N1163 N1169 N1168 N1162 N1167 _NC126 _NC127 AO221X1
X64 N1166 N1167 N1158 _NC128 _NC129 AND2X1
X65 N1164 N1165 N1158 N1154 _NC130 _NC131 NAND3X0
X66 N1119 B[8] N1161 _NC132 _NC133 OR2X1
X67 N1121 N1124 N1160 N1161 N1159 _NC134 _NC135 NAND4X0
X68 N1158 N1159 N1155 _NC136 _NC137 NAND2X0
X69 A[16] N1130 N1156 _NC138 _NC139 NAND2X0
X70 N1154 N1155 N1131 N1156 N1150 _NC140 _NC141 NAND4X0
X71 N1150 N1151 N1152 N1153 N1149 _NC142 _NC143 NOR4X0
X72 N1147 N1148 N1149 GE_LT_GT_LE _NC144 _NC145 AO21X1
X73 A[27] _NC146 _NC147 N1146 INVX0
X74 B[16] _NC148 _NC149 N1130 INVX0
X75 B[22] _NC150 _NC151 N1140 INVX0
X76 N1151 _NC152 _NC153 N1133 INVX0
X77 B[5] _NC154 _NC155 N1115 INVX0
X78 B[13] _NC156 _NC157 N1126 INVX0
X79 B[9] _NC158 _NC159 N1120 INVX0
X80 B[2] _NC160 _NC161 N1112 INVX0
X81 A[15] _NC162 _NC163 N1129 INVX0
X82 A[7] _NC164 _NC165 N1118 INVX0
X83 A[11] _NC166 _NC167 N1123 INVX0
X84 A[19] _NC168 _NC169 N1135 INVX0
X85 A[23] _NC170 _NC171 N1141 INVX0
X86 A[3] _NC172 _NC173 N1113 INVX0
X87 A[17] _NC174 _NC175 N1132 INVX0
X88 A[21] _NC176 _NC177 N1139 INVX0
X89 A[4] _NC178 _NC179 N1114 INVX0
X90 A[26] _NC180 _NC181 N1145 INVX0
X91 A[25] _NC182 _NC183 N1144 INVX0
X92 A[24] _NC184 _NC185 N1143 INVX0
X93 A[8] _NC186 _NC187 N1119 INVX0
X94 A[12] _NC188 _NC189 N1125 INVX0
X95 A[1] _NC190 _NC191 N1111 INVX0
X96 B[10] _NC192 _NC193 N1122 INVX0
X97 B[6] _NC194 _NC195 N1117 INVX0
X98 B[14] _NC196 _NC197 N1128 INVX0
X99 B[18] _NC198 _NC199 N1134 INVX0
X100 N1162 _NC200 _NC201 N1124 INVX0
X101 N1163 _NC202 _NC203 N1121 INVX0
X102 N1172 _NC204 _NC205 N1127 INVX0
X103 B[20] _NC206 _NC207 N1137 INVX0
X104 N1209 _NC208 _NC209 N1138 INVX0
X105 N1157 _NC210 _NC211 N1131 INVX0
X106 N1200 _NC212 _NC213 N1142 INVX0
X107 N1183 _NC214 _NC215 N1116 INVX0
X108 N1152 _NC216 _NC217 N1136 INVX0
.ENDS addsub_28_DW_cmp_0

.SUBCKT addsub_28_DW01_add_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] CI SUM[0] SUM[1] SUM[2] SUM[3] SUM[4] SUM[5] SUM[6] SUM[7] SUM[8] SUM[9] SUM[10] SUM[11] SUM[12] SUM[13] SUM[14] SUM[15] SUM[16] SUM[17] SUM[18] SUM[19] SUM[20] SUM[21] SUM[22] SUM[23] SUM[24] SUM[25] SUM[26] SUM[27] CO
X0 A[0] B[0] SUM[0] _NC0 _NC1 XOR2X1
X1 A[0] B[0] N1 _NC2 _NC3 AND2X1
X2 A[27] B[27] Carry[25] SUM[27] _NC4 _NC5 XOR3X1
X3 A[1] B[1] N1 Carry[0] SUM[1] _NC6 _NC7 FADDX1
X4 A[2] B[2] Carry[0] Carry[1] SUM[2] _NC8 _NC9 FADDX1
X5 A[3] B[3] Carry[1] Carry[2] SUM[3] _NC10 _NC11 FADDX1
X6 A[4] B[4] Carry[2] Carry[3] SUM[4] _NC12 _NC13 FADDX1
X7 A[5] B[5] Carry[3] Carry[4] SUM[5] _NC14 _NC15 FADDX1
X8 A[6] B[6] Carry[4] Carry[5] SUM[6] _NC16 _NC17 FADDX1
X9 A[7] B[7] Carry[5] Carry[6] SUM[7] _NC18 _NC19 FADDX1
X10 A[8] B[8] Carry[6] Carry[7] SUM[8] _NC20 _NC21 FADDX1
X11 A[9] B[9] Carry[7] Carry[8] SUM[9] _NC22 _NC23 FADDX1
X12 A[10] B[10] Carry[8] Carry[9] SUM[10] _NC24 _NC25 FADDX1
X13 A[11] B[11] Carry[9] Carry[10] SUM[11] _NC26 _NC27 FADDX1
X14 A[12] B[12] Carry[10] Carry[11] SUM[12] _NC28 _NC29 FADDX1
X15 A[13] B[13] Carry[11] Carry[12] SUM[13] _NC30 _NC31 FADDX1
X16 A[14] B[14] Carry[12] Carry[13] SUM[14] _NC32 _NC33 FADDX1
X17 A[15] B[15] Carry[13] Carry[14] SUM[15] _NC34 _NC35 FADDX1
X18 A[16] B[16] Carry[14] Carry[15] SUM[16] _NC36 _NC37 FADDX1
X19 A[17] B[17] Carry[15] Carry[16] SUM[17] _NC38 _NC39 FADDX1
X20 A[18] B[18] Carry[16] Carry[17] SUM[18] _NC40 _NC41 FADDX1
X21 A[19] B[19] Carry[17] Carry[18] SUM[19] _NC42 _NC43 FADDX1
X22 A[20] B[20] Carry[18] Carry[19] SUM[20] _NC44 _NC45 FADDX1
X23 A[21] B[21] Carry[19] Carry[20] SUM[21] _NC46 _NC47 FADDX1
X24 A[22] B[22] Carry[20] Carry[21] SUM[22] _NC48 _NC49 FADDX1
X25 A[23] B[23] Carry[21] Carry[22] SUM[23] _NC50 _NC51 FADDX1
X26 A[24] B[24] Carry[22] Carry[23] SUM[24] _NC52 _NC53 FADDX1
X27 A[25] B[25] Carry[23] Carry[24] SUM[25] _NC54 _NC55 FADDX1
X28 A[26] B[26] Carry[24] Carry[25] SUM[26] _NC56 _NC57 FADDX1
.ENDS addsub_28_DW01_add_0

.SUBCKT addsub_28_DW01_sub_1 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] DIFF[9] DIFF[10] DIFF[11] DIFF[12] DIFF[13] DIFF[14] DIFF[15] DIFF[16] DIFF[17] DIFF[18] DIFF[19] DIFF[20] DIFF[21] DIFF[22] DIFF[23] DIFF[24] DIFF[25] DIFF[26] DIFF[27] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 B[27] _NC2 _NC3 N28 INVX0
X2 B[13] _NC4 _NC5 N14 INVX0
X3 B[9] _NC6 _NC7 N10 INVX0
X4 B[5] _NC8 _NC9 N6 INVX0
X5 A[0] _NC10 _NC11 N1 INVX0
X6 N1 B[0] Carry[0] _NC12 _NC13 NAND2X1
X7 B[1] _NC14 _NC15 N2 INVX0
X8 B[15] _NC16 _NC17 N16 INVX0
X9 B[11] _NC18 _NC19 N12 INVX0
X10 B[7] _NC20 _NC21 N8 INVX0
X11 B[23] _NC22 _NC23 N24 INVX0
X12 B[19] _NC24 _NC25 N20 INVX0
X13 B[3] _NC26 _NC27 N4 INVX0
X14 B[24] _NC28 _NC29 N25 INVX0
X15 B[21] _NC30 _NC31 N22 INVX0
X16 B[17] _NC32 _NC33 N18 INVX0
X17 B[4] _NC34 _NC35 N5 INVX0
X18 B[25] _NC36 _NC37 N26 INVX0
X19 B[26] _NC38 _NC39 N27 INVX0
X20 B[2] _NC40 _NC41 N3 INVX0
X21 B[14] _NC42 _NC43 N15 INVX0
X22 B[10] _NC44 _NC45 N11 INVX0
X23 B[6] _NC46 _NC47 N7 INVX0
X24 B[12] _NC48 _NC49 N13 INVX0
X25 B[8] _NC50 _NC51 N9 INVX0
X26 B[22] _NC52 _NC53 N23 INVX0
X27 B[18] _NC54 _NC55 N19 INVX0
X28 B[20] _NC56 _NC57 N21 INVX0
X29 B[16] _NC58 _NC59 N17 INVX0
X30 A[27] N28 Carry[26] DIFF[27] _NC60 _NC61 XOR3X1
X31 A[1] N2 Carry[0] Carry[1] DIFF[1] _NC62 _NC63 FADDX1
X32 A[2] N3 Carry[1] Carry[2] DIFF[2] _NC64 _NC65 FADDX1
X33 A[3] N4 Carry[2] Carry[3] DIFF[3] _NC66 _NC67 FADDX1
X34 A[4] N5 Carry[3] Carry[4] DIFF[4] _NC68 _NC69 FADDX1
X35 A[5] N6 Carry[4] Carry[5] DIFF[5] _NC70 _NC71 FADDX1
X36 A[6] N7 Carry[5] Carry[6] DIFF[6] _NC72 _NC73 FADDX1
X37 A[7] N8 Carry[6] Carry[7] DIFF[7] _NC74 _NC75 FADDX1
X38 A[8] N9 Carry[7] Carry[8] DIFF[8] _NC76 _NC77 FADDX1
X39 A[9] N10 Carry[8] Carry[9] DIFF[9] _NC78 _NC79 FADDX1
X40 A[10] N11 Carry[9] Carry[10] DIFF[10] _NC80 _NC81 FADDX1
X41 A[11] N12 Carry[10] Carry[11] DIFF[11] _NC82 _NC83 FADDX1
X42 A[12] N13 Carry[11] Carry[12] DIFF[12] _NC84 _NC85 FADDX1
X43 A[13] N14 Carry[12] Carry[13] DIFF[13] _NC86 _NC87 FADDX1
X44 A[14] N15 Carry[13] Carry[14] DIFF[14] _NC88 _NC89 FADDX1
X45 A[15] N16 Carry[14] Carry[15] DIFF[15] _NC90 _NC91 FADDX1
X46 A[16] N17 Carry[15] Carry[16] DIFF[16] _NC92 _NC93 FADDX1
X47 A[17] N18 Carry[16] Carry[17] DIFF[17] _NC94 _NC95 FADDX1
X48 A[18] N19 Carry[17] Carry[18] DIFF[18] _NC96 _NC97 FADDX1
X49 A[19] N20 Carry[18] Carry[19] DIFF[19] _NC98 _NC99 FADDX1
X50 A[20] N21 Carry[19] Carry[20] DIFF[20] _NC100 _NC101 FADDX1
X51 A[21] N22 Carry[20] Carry[21] DIFF[21] _NC102 _NC103 FADDX1
X52 A[22] N23 Carry[21] Carry[22] DIFF[22] _NC104 _NC105 FADDX1
X53 A[23] N24 Carry[22] Carry[23] DIFF[23] _NC106 _NC107 FADDX1
X54 A[24] N25 Carry[23] Carry[24] DIFF[24] _NC108 _NC109 FADDX1
X55 A[25] N26 Carry[24] Carry[25] DIFF[25] _NC110 _NC111 FADDX1
X56 A[26] N27 Carry[25] Carry[26] DIFF[26] _NC112 _NC113 FADDX1
.ENDS addsub_28_DW01_sub_1

.SUBCKT addsub_28_DW01_sub_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17] B[18] B[19] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] DIFF[8] DIFF[9] DIFF[10] DIFF[11] DIFF[12] DIFF[13] DIFF[14] DIFF[15] DIFF[16] DIFF[17] DIFF[18] DIFF[19] DIFF[20] DIFF[21] DIFF[22] DIFF[23] DIFF[24] DIFF[25] DIFF[26] DIFF[27] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 B[27] _NC2 _NC3 N28 INVX0
X2 A[0] _NC4 _NC5 N1 INVX0
X3 N1 B[0] Carry[0] _NC6 _NC7 NAND2X1
X4 B[1] _NC8 _NC9 N2 INVX0
X5 B[2] _NC10 _NC11 N3 INVX0
X6 B[13] _NC12 _NC13 N14 INVX0
X7 B[9] _NC14 _NC15 N10 INVX0
X8 B[5] _NC16 _NC17 N6 INVX0
X9 B[26] _NC18 _NC19 N27 INVX0
X10 B[25] _NC20 _NC21 N26 INVX0
X11 B[23] _NC22 _NC23 N24 INVX0
X12 B[21] _NC24 _NC25 N22 INVX0
X13 B[19] _NC26 _NC27 N20 INVX0
X14 B[17] _NC28 _NC29 N18 INVX0
X15 B[15] _NC30 _NC31 N16 INVX0
X16 B[12] _NC32 _NC33 N13 INVX0
X17 B[11] _NC34 _NC35 N12 INVX0
X18 B[8] _NC36 _NC37 N9 INVX0
X19 B[7] _NC38 _NC39 N8 INVX0
X20 B[4] _NC40 _NC41 N5 INVX0
X21 B[3] _NC42 _NC43 N4 INVX0
X22 B[22] _NC44 _NC45 N23 INVX0
X23 B[20] _NC46 _NC47 N21 INVX0
X24 B[16] _NC48 _NC49 N17 INVX0
X25 B[18] _NC50 _NC51 N19 INVX0
X26 B[14] _NC52 _NC53 N15 INVX0
X27 B[10] _NC54 _NC55 N11 INVX0
X28 B[6] _NC56 _NC57 N7 INVX0
X29 B[24] _NC58 _NC59 N25 INVX0
X30 A[27] N28 Carry[26] DIFF[27] _NC60 _NC61 XOR3X1
X31 A[1] N2 Carry[0] Carry[1] DIFF[1] _NC62 _NC63 FADDX1
X32 A[2] N3 Carry[1] Carry[2] DIFF[2] _NC64 _NC65 FADDX1
X33 A[3] N4 Carry[2] Carry[3] DIFF[3] _NC66 _NC67 FADDX1
X34 A[4] N5 Carry[3] Carry[4] DIFF[4] _NC68 _NC69 FADDX1
X35 A[5] N6 Carry[4] Carry[5] DIFF[5] _NC70 _NC71 FADDX1
X36 A[6] N7 Carry[5] Carry[6] DIFF[6] _NC72 _NC73 FADDX1
X37 A[7] N8 Carry[6] Carry[7] DIFF[7] _NC74 _NC75 FADDX1
X38 A[8] N9 Carry[7] Carry[8] DIFF[8] _NC76 _NC77 FADDX1
X39 A[9] N10 Carry[8] Carry[9] DIFF[9] _NC78 _NC79 FADDX1
X40 A[10] N11 Carry[9] Carry[10] DIFF[10] _NC80 _NC81 FADDX1
X41 A[11] N12 Carry[10] Carry[11] DIFF[11] _NC82 _NC83 FADDX1
X42 A[12] N13 Carry[11] Carry[12] DIFF[12] _NC84 _NC85 FADDX1
X43 A[13] N14 Carry[12] Carry[13] DIFF[13] _NC86 _NC87 FADDX1
X44 A[14] N15 Carry[13] Carry[14] DIFF[14] _NC88 _NC89 FADDX1
X45 A[15] N16 Carry[14] Carry[15] DIFF[15] _NC90 _NC91 FADDX1
X46 A[16] N17 Carry[15] Carry[16] DIFF[16] _NC92 _NC93 FADDX1
X47 A[17] N18 Carry[16] Carry[17] DIFF[17] _NC94 _NC95 FADDX1
X48 A[18] N19 Carry[17] Carry[18] DIFF[18] _NC96 _NC97 FADDX1
X49 A[19] N20 Carry[18] Carry[19] DIFF[19] _NC98 _NC99 FADDX1
X50 A[20] N21 Carry[19] Carry[20] DIFF[20] _NC100 _NC101 FADDX1
X51 A[21] N22 Carry[20] Carry[21] DIFF[21] _NC102 _NC103 FADDX1
X52 A[22] N23 Carry[21] Carry[22] DIFF[22] _NC104 _NC105 FADDX1
X53 A[23] N24 Carry[22] Carry[23] DIFF[23] _NC106 _NC107 FADDX1
X54 A[24] N25 Carry[23] Carry[24] DIFF[24] _NC108 _NC109 FADDX1
X55 A[25] N26 Carry[24] Carry[25] DIFF[25] _NC110 _NC111 FADDX1
X56 A[26] N27 Carry[25] Carry[26] DIFF[26] _NC112 _NC113 FADDX1
.ENDS addsub_28_DW01_sub_0

.SUBCKT pre_norm_addsub Clk_i Opa_i[0] Opa_i[1] Opa_i[2] Opa_i[3] Opa_i[4] Opa_i[5] Opa_i[6] Opa_i[7] Opa_i[8] Opa_i[9] Opa_i[10] Opa_i[11] Opa_i[12] Opa_i[13] Opa_i[14] Opa_i[15] Opa_i[16] Opa_i[17] Opa_i[18] Opa_i[19] Opa_i[20] Opa_i[21] Opa_i[22] Opa_i[23] Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] Opa_i[29] Opa_i[30] Opa_i[31] Opb_i[0] Opb_i[1] Opb_i[2] Opb_i[3] Opb_i[4] Opb_i[5] Opb_i[6] Opb_i[7] Opb_i[8] Opb_i[9] Opb_i[10] Opb_i[11] Opb_i[12] Opb_i[13] Opb_i[14] Opb_i[15] Opb_i[16] Opb_i[17] Opb_i[18] Opb_i[19] Opb_i[20] Opb_i[21] Opb_i[22] Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Opb_i[31] Fracta_28_o[0] Fracta_28_o[1] Fracta_28_o[2] Fracta_28_o[3] Fracta_28_o[4] Fracta_28_o[5] Fracta_28_o[6] Fracta_28_o[7] Fracta_28_o[8] Fracta_28_o[9] Fracta_28_o[10] Fracta_28_o[11] Fracta_28_o[12] Fracta_28_o[13] Fracta_28_o[14] Fracta_28_o[15] Fracta_28_o[16] Fracta_28_o[17] Fracta_28_o[18] Fracta_28_o[19] Fracta_28_o[20] Fracta_28_o[21] Fracta_28_o[22] Fracta_28_o[23] Fracta_28_o[24] Fracta_28_o[25] Fracta_28_o[26] Fracta_28_o[27] Fractb_28_o[0] Fractb_28_o[1] Fractb_28_o[2] Fractb_28_o[3] Fractb_28_o[4] Fractb_28_o[5] Fractb_28_o[6] Fractb_28_o[7] Fractb_28_o[8] Fractb_28_o[9] Fractb_28_o[10] Fractb_28_o[11] Fractb_28_o[12] Fractb_28_o[13] Fractb_28_o[14] Fractb_28_o[15] Fractb_28_o[16] Fractb_28_o[17] Fractb_28_o[18] Fractb_28_o[19] Fractb_28_o[20] Fractb_28_o[21] Fractb_28_o[22] Fractb_28_o[23] Fractb_28_o[24] Fractb_28_o[25] Fractb_28_o[26] Fractb_28_o[27] Exp_o[0] Exp_o[1] Exp_o[2] Exp_o[3] Exp_o[4] Exp_o[5] Exp_o[6] Exp_o[7]
X0 N431 N430 N432 N31 _NC0 _NC1 MUX21X1
X1 N429 N428 N431 N11 _NC2 _NC3 MUX21X1
X2 N4260 N4250 N4270 N31 _NC4 _NC5 MUX21X1
X3 N4240 N4230 N4260 N11 _NC6 _NC7 MUX21X1
X4 N4210 N4200 N4220 N31 _NC8 _NC9 MUX21X1
X5 N4190 N4180 N4210 N11 _NC10 _NC11 MUX21X1
X6 N4170 N4160 N4180 N23 _NC12 _NC13 MUX21X1
X7 N414 N413 N415 N31 _NC14 _NC15 MUX21X1
X8 N412 N411 N414 N11 _NC16 _NC17 MUX21X1
X9 N4100 N4090 N411 N23 _NC18 _NC19 MUX21X1
X10 N4070 N4060 N4080 N31 _NC20 _NC21 MUX21X1
X11 N4050 N4040 N4070 N11 _NC22 _NC23 MUX21X1
X12 N4030 N258 N4040 N23 _NC24 _NC25 MUX21X1
X13 N4010 N4000 N4020 N31 _NC26 _NC27 MUX21X1
X14 N3990 N398 N4010 N11 _NC28 _NC29 MUX21X1
X15 N397 N396 N398 N23 _NC30 _NC31 MUX21X1
X16 N394 N3930 N395 N31 _NC32 _NC33 MUX21X1
X17 N3920 N3910 N394 N11 _NC34 _NC35 MUX21X1
X18 N4160 N259 N3910 N23 _NC36 _NC37 MUX21X1
X19 N3890 N3880 N3900 N25 _NC38 _NC39 MUX21X1
X20 N3870 N268 N4160 N25 _NC40 _NC41 MUX21X1
X21 N3840 N3830 N3850 N31 _NC42 _NC43 MUX21X1
X22 N3820 N381 N3840 N11 _NC44 _NC45 MUX21X1
X23 N4090 N380 N381 N23 _NC46 _NC47 MUX21X1
X24 N261 N379 N380 N25 _NC48 _NC49 MUX21X1
X25 N378 N260 N4090 N25 _NC50 _NC51 MUX21X1
X26 N377 N31 N29 S_fract_shr_28[25] _NC52 _NC53 NOR3X0
X27 N430 N32 N29 S_fract_shr_28[24] _NC54 _NC55 NOR3X0
X28 N30 N32 N4250 S_fract_shr_28[23] _NC56 _NC57 NOR3X0
X29 N3750 S_exp_diff[3] N4250 _NC58 _NC59 OR2X1
X30 N30 N32 N4200 S_fract_shr_28[22] _NC60 _NC61 NOR3X0
X31 N3740 S_exp_diff[3] N4200 _NC62 _NC63 OR2X1
X32 N30 N32 N413 S_fract_shr_28[21] _NC64 _NC65 NOR3X0
X33 N3730 S_exp_diff[3] N413 _NC66 _NC67 OR2X1
X34 N4060 N32 N30 S_fract_shr_28[20] _NC68 _NC69 NOR3X0
X35 N3720 S_exp_diff[3] N4060 _NC70 _NC71 OR2X1
X36 N4000 N32 N30 S_fract_shr_28[19] _NC72 _NC73 NOR3X0
X37 N3710 S_exp_diff[3] N4000 _NC74 _NC75 OR2X1
X38 N3690 N3680 N3700 N31 _NC76 _NC77 MUX21X1
X39 N428 N3670 N3690 N11 _NC78 _NC79 MUX21X1
X40 N258 N3660 N3670 N23 _NC80 _NC81 MUX21X1
X41 S_fract_sm_28[1] S_fract_sm_28[0] N3880 N27 _NC82 _NC83 MUX21X1
X42 N3860 N3890 N3650 N25 _NC84 _NC85 MUX21X1
X43 S_fract_sm_28[3] S_fract_sm_28[2] N3890 N27 _NC86 _NC87 MUX21X1
X44 S_fract_sm_28[5] S_fract_sm_28[4] N3860 N27 _NC88 _NC89 MUX21X1
X45 N364 N4030 N428 N23 _NC90 _NC91 MUX21X1
X46 N363 N3870 N4030 N25 _NC92 _NC93 MUX21X1
X47 N293 N292 N3870 N27 _NC94 _NC95 MUX21X1
X48 N3930 N32 N30 S_fract_shr_28[18] _NC96 _NC97 NOR3X0
X49 N3830 N32 N30 S_fract_shr_28[17] _NC98 _NC99 NOR3X0
X50 N112 N361 N3830 N11 _NC100 _NC101 MUX21X1
X51 N3680 N32 N30 S_fract_shr_28[16] _NC102 _NC103 NOR3X0
X52 N113 N429 N3680 N11 _NC104 _NC105 MUX21X1
X53 N115 N152 N429 N23 _NC106 _NC107 MUX21X1
X54 N30 N32 N3580 S_fract_shr_28[15] _NC108 _NC109 NOR3X0
X55 N3570 N32 N30 S_fract_shr_28[14] _NC110 _NC111 NOR3X0
X56 N3740 N4190 N3570 N11 _NC112 _NC113 MUX21X1
X57 N114 N3560 N4190 N23 _NC114 _NC115 MUX21X1
X58 N3530 N32 N30 S_fract_shr_28[13] _NC116 _NC117 NOR3X0
X59 N3730 N412 N3530 N11 _NC118 _NC119 MUX21X1
X60 N3520 N3510 N412 N23 _NC120 _NC121 MUX21X1
X61 N3500 N3490 N3730 N24 _NC122 _NC123 MUX21X1
X62 N30 N32 N3480 S_fract_shr_28[12] _NC124 _NC125 NOR3X0
X63 N3720 N4050 N3480 N11 _NC126 _NC127 MUX21X1
X64 N152 N364 N4050 N24 _NC128 _NC129 MUX21X1
X65 N347 N346 N364 N25 _NC130 _NC131 MUX21X1
X66 N344 N343 N345 N25 _NC132 _NC133 MUX21X1
X67 N3590 N115 N3720 N24 _NC134 _NC135 MUX21X1
X68 N3410 N3400 N3420 N25 _NC136 _NC137 MUX21X1
X69 N30 N32 N3380 S_fract_shr_28[11] _NC138 _NC139 NOR3X0
X70 N3710 N3990 N3380 N11 _NC140 _NC141 MUX21X1
X71 N3370 N3360 N3990 N24 _NC142 _NC143 MUX21X1
X72 N3350 N3340 N3710 N24 _NC144 _NC145 MUX21X1
X73 N30 N31 N3330 S_fract_shr_28[10] _NC146 _NC147 NOR3X0
X74 N111 N3920 N3330 N11 _NC148 _NC149 MUX21X1
X75 N3560 N4170 N3920 N24 _NC150 _NC151 MUX21X1
X76 N346 N363 N4170 N25 _NC152 _NC153 MUX21X1
X77 N295 N294 N363 N27 _NC154 _NC155 MUX21X1
X78 N2970 N296 N346 N27 _NC156 _NC157 MUX21X1
X79 N2670 N347 N3560 N25 _NC158 _NC159 MUX21X1
X80 N2990 N2980 N347 N27 _NC160 _NC161 MUX21X1
X81 S_fract_sm_28[15] S_fract_sm_28[14] N343 N27 _NC162 _NC163 MUX21X1
X82 N3540 N3550 N362 N24 _NC164 _NC165 MUX21X1
X83 N3400 N344 N3550 N25 _NC166 _NC167 MUX21X1
X84 S_fract_sm_28[17] S_fract_sm_28[16] N344 N27 _NC168 _NC169 MUX21X1
X85 S_fract_sm_28[19] S_fract_sm_28[18] N3400 N27 _NC170 _NC171 MUX21X1
X86 N3390 N3410 N3540 N25 _NC172 _NC173 MUX21X1
X87 S_fract_sm_28[21] S_fract_sm_28[20] N3410 N27 _NC174 _NC175 MUX21X1
X88 S_fract_sm_28[23] S_fract_sm_28[22] N3390 N28 _NC176 _NC177 MUX21X1
X89 N3310 N377 N3320 N31 _NC178 _NC179 MUX21X1
X90 N330 S_exp_diff[1] N3500 _NC180 _NC181 OR2X1
X91 N361 N3820 N3310 N11 _NC182 _NC183 MUX21X1
X92 N3510 N4100 N3820 N24 _NC184 _NC185 MUX21X1
X93 N329 N328 N4100 N25 _NC186 _NC187 MUX21X1
X94 N2660 N327 N3510 N25 _NC188 _NC189 MUX21X1
X95 N3490 N3520 N361 N24 _NC190 _NC191 MUX21X1
X96 N2640 N2650 N3520 N26 _NC192 _NC193 MUX21X1
X97 N262 N2630 N3490 N26 _NC194 _NC195 MUX21X1
X98 N3250 N3580 N326 N31 _NC196 _NC197 MUX21X1
X99 N3750 N4240 N3580 N11 _NC198 _NC199 MUX21X1
X100 N3340 N3370 N4240 N24 _NC200 _NC201 MUX21X1
X101 N2650 N2660 N3370 N26 _NC202 _NC203 MUX21X1
X102 S_fract_sm_28[14] S_fract_sm_28[13] N3240 N28 _NC204 _NC205 MUX21X1
X103 S_fract_sm_28[16] S_fract_sm_28[15] N3230 N28 _NC206 _NC207 MUX21X1
X104 N2630 N2640 N3340 N26 _NC208 _NC209 MUX21X1
X105 S_fract_sm_28[18] S_fract_sm_28[17] N3220 N28 _NC210 _NC211 MUX21X1
X106 S_fract_sm_28[20] S_fract_sm_28[19] N3210 N28 _NC212 _NC213 MUX21X1
X107 N3350 S_exp_diff[2] N3750 _NC214 _NC215 OR2X1
X108 N330 N262 N3350 N26 _NC216 _NC217 MUX21X1
X109 S_fract_sm_28[22] S_fract_sm_28[21] N3200 N28 _NC218 _NC219 MUX21X1
X110 N4230 N3190 N3250 N11 _NC220 _NC221 MUX21X1
X111 N396 N3180 N3190 N24 _NC222 _NC223 MUX21X1
X112 N379 N26 N3180 _NC224 _NC225 OR2X1
X113 N260 N261 N396 N26 _NC226 _NC227 MUX21X1
X114 S_fract_sm_28[2] S_fract_sm_28[1] N3170 N28 _NC228 _NC229 MUX21X1
X115 S_fract_sm_28[4] S_fract_sm_28[3] N3160 N28 _NC230 _NC231 MUX21X1
X116 N3360 N397 N4230 N24 _NC232 _NC233 MUX21X1
X117 N328 N378 N397 N26 _NC234 _NC235 MUX21X1
X118 N292 N291 N378 N28 _NC236 _NC237 MUX21X1
X119 N294 N293 N328 N28 _NC238 _NC239 MUX21X1
X120 N327 N329 N3360 N25 _NC240 _NC241 MUX21X1
X121 N296 N295 N329 N28 _NC242 _NC243 MUX21X1
X122 N2980 N2970 N327 N28 _NC244 _NC245 MUX21X1
X123 S_exp_diff[7] S_exp_diff[6] S_exp_diff[5] N4330 _NC246 _NC247 OR3X1
X124 S_exp_diff[5] N16 N87 _NC248 _NC249 NAND2X0
X125 S_exp_diff[7] S_exp_diff[6] N88 _NC250 _NC251 NOR2X0
X126 N86 N15 N32 N89 _NC252 _NC253 NAND3X0
X127 N85 N84 N86 N83 N90 _NC254 _NC255 NAND4X0
X128 N15 N32 N83 _NC256 _NC257 OR2X1
X129 N16 S_exp_diff[5] N86 _NC258 _NC259 OR2X1
X130 N91 N82 N84 _NC260 _NC261 NAND2X0
X131 S_rzeros[2] N14 N81 N82 _NC262 _NC263 AO21X1
X132 S_exp_diff[1] N20 N79 S_exp_diff[0] N80 N85 _NC264 _NC265 AO221X1
X133 S_exp_diff[3] N17 N78 S_exp_diff[2] N80 _NC266 _NC267 AO22X1
X134 S_rzeros[2] N81 N78 _NC268 _NC269 NOR2X0
X135 N17 S_exp_diff[3] N81 _NC270 _NC271 NOR2X0
X136 S_rzeros[0] N77 N79 _NC272 _NC273 NOR2X0
X137 S_exp_diff[1] N20 N77 _NC274 _NC275 NOR2X0
X138 N76 N67 N66 N68 _NC276 _NC277 NAND3X0
X139 N65 N64 Opa_i[27] N72 N63 N66 _NC278 _NC279 OA221X1
X140 N74 Opb_i[25] N62 N65 _NC280 _NC281 AOI21X1
X141 Opa_i[24] N70 N61 N49 N64 N67 _NC282 _NC283 AO221X1
X142 Opa_i[26] N71 N60 Opa_i[25] N64 _NC284 _NC285 AO22X1
X143 Opb_i[25] N62 N60 _NC286 _NC287 NOR2X0
X144 N71 Opa_i[26] N62 _NC288 _NC289 NOR2X0
X145 Opb_i[23] N59 N61 _NC290 _NC291 NOR2X0
X146 Opa_i[24] N70 N59 _NC292 _NC293 NOR2X0
X147 N57 N56 N56 N58 N69 _NC294 _NC295 AO22X1
X148 Opb_i[29] N52 N55 N58 _NC296 _NC297 AO21X1
X149 Opa_i[30] N73 N54 N51 N56 _NC298 _NC299 AOI22X1
X150 Opb_i[29] N55 N54 _NC300 _NC301 NOR2X0
X151 N73 Opa_i[30] N55 _NC302 _NC303 NOR2X0
X152 Opb_i[28] N75 N53 N57 _NC304 _NC305 OA21X1
X153 N63 N72 Opa_i[27] N53 _NC306 _NC307 NAND3X0
X154 Opb_i[28] N75 N63 _NC308 _NC309 NAND2X0
X155 Add_105_I28_L07002_C161_carry[3] N614 N624 _NC310 _NC311 XOR2X1
X156 N609 _NC312 _NC313 N619 INVX0
X157 Add_105_I27_L07002_C161_carry[3] N597 N608 _NC314 _NC315 XOR2X1
X158 N592 _NC316 _NC317 N603 INVX0
X159 Add_105_I26_L07002_C161_carry[3] N580 N591 _NC318 _NC319 XOR2X1
X160 N575 _NC320 _NC321 N586 INVX0
X161 Add_105_I25_L07002_C161_carry[3] N563 N574 _NC322 _NC323 XOR2X1
X162 N558 _NC324 _NC325 N569 INVX0
X163 Add_105_I24_L07002_C161_carry[3] N546 N557 _NC326 _NC327 XOR2X1
X164 N541 _NC328 _NC329 N552 INVX0
X165 Add_105_I23_L07002_C161_carry[3] N529 N540 _NC330 _NC331 XOR2X1
X166 N524 _NC332 _NC333 N535 INVX0
X167 Add_105_I22_L07002_C161_carry[3] N512 N523 _NC334 _NC335 XOR2X1
X168 N507 _NC336 _NC337 N518 INVX0
X169 Add_105_I21_L07002_C161_carry[3] N495 N506 _NC338 _NC339 XOR2X1
X170 N490 _NC340 _NC341 N501 INVX0
X171 Add_105_I20_L07002_C161_carry[3] N478 N489 _NC342 _NC343 XOR2X1
X172 N473 _NC344 _NC345 N484 INVX0
X173 Add_105_I19_L07002_C161_carry[3] N461 N472 _NC346 _NC347 XOR2X1
X174 N456 _NC348 _NC349 N467 INVX0
X175 Add_105_I18_L07002_C161_carry[3] N444 N455 _NC350 _NC351 XOR2X1
X176 Add_105_I17_L07002_C161_carry[3] N427 N438 _NC352 _NC353 XOR2X1
X177 N422 _NC354 _NC355 N433 INVX0
X178 Add_105_I16_L07002_C161_carry[3] N410 N421 _NC356 _NC357 XOR2X1
X179 N405 _NC358 _NC359 N416 INVX0
X180 Add_105_I15_L07002_C161_carry[3] N393 N404 _NC360 _NC361 XOR2X1
X181 N388 _NC362 _NC363 N399 INVX0
X182 Add_105_I14_L07002_C161_carry[3] N376 N387 _NC364 _NC365 XOR2X1
X183 N371 _NC366 _NC367 N382 INVX0
X184 Add_105_I13_L07002_C161_carry[3] N359 N370 _NC368 _NC369 XOR2X1
X185 N354 _NC370 _NC371 N365 INVX0
X186 Add_105_I12_L07002_C161_carry[3] N342 N353 _NC372 _NC373 XOR2X1
X187 N337 _NC374 _NC375 N348 INVX0
X188 Add_105_I11_L07002_C161_carry[3] N325 N336 _NC376 _NC377 XOR2X1
X189 N320 _NC378 _NC379 N331 INVX0
X190 Add_105_I10_L07002_C161_carry[3] N308 N319 _NC380 _NC381 XOR2X1
X191 N303 _NC382 _NC383 N314 INVX0
X192 N286 _NC384 _NC385 N297 INVX0
X193 N269 _NC386 _NC387 N280 INVX0
X194 N252 _NC388 _NC389 N263 INVX0
X195 N236 _NC390 _NC391 N246 INVX0
X196 Opa_i[29] _NC392 _NC393 N52 INVX0
X197 N52 _NC394 _NC395 N51 INVX0
X198 Opa_i[23] _NC396 _NC397 N50 INVX0
X199 N50 _NC398 _NC399 N49 INVX0
X200 N36 _NC400 _NC401 N34 INVX0
X201 N36 _NC402 _NC403 N33 INVX0
X202 N69 N68 N109 _NC404 _NC405 NAND2X1
X203 N13 _NC406 _NC407 N25 NBUFFX4
X204 S_exp_diff[4] _NC408 _NC409 N31 NBUFFX2
X205 S_exp_diff[4] _NC410 _NC411 N32 NBUFFX2
X206 S_exp_diff[1] N3880 N3660 _NC412 _NC413 NAND2X1
X207 S_fract_sm_28[0] S_exp_diff[0] N379 _NC414 _NC415 NAND2X1
X208 Opb_i[26] Opb_i[25] N255 _NC416 _NC417 NOR2X0
X209 Opb_i[23] _NC418 _NC419 N312 INVX0
X210 N3590 S_exp_diff[2] N3760 _NC420 _NC421 NOR2X0
X211 N3500 S_exp_diff[2] N360 _NC422 _NC423 NOR2X0
X212 Opb_i[20] N43 Opa_i[20] N22 S_fract_sm_28[20] _NC424 _NC425 AO22X1
X213 Opb_i[21] N43 Opa_i[21] N22 S_fract_sm_28[21] _NC426 _NC427 AO22X1
X214 Opb_i[22] N43 Opa_i[22] N33 S_fract_sm_28[22] _NC428 _NC429 AO22X1
X215 Opb_i[17] N43 Opa_i[17] N22 S_fract_sm_28[17] _NC430 _NC431 AO22X1
X216 Opb_i[18] N43 Opa_i[18] N22 S_fract_sm_28[18] _NC432 _NC433 AO22X1
X217 Opb_i[19] N43 Opa_i[19] N22 S_fract_sm_28[19] _NC434 _NC435 AO22X1
X218 Opa_i[26] Opa_i[25] N2530 _NC436 _NC437 NOR2X0
X219 Opa_i[24] _NC438 _NC439 N311 INVX0
X220 Opb_i[15] N38 Opa_i[15] N22 S_fract_sm_28[15] _NC440 _NC441 AO22X1
X221 Opb_i[16] N38 Opa_i[16] N22 S_fract_sm_28[16] _NC442 _NC443 AO22X1
X222 Opb_i[14] N38 Opa_i[14] N22 S_fract_sm_28[14] _NC444 _NC445 AO22X1
X223 Opb_i[30] _NC446 _NC447 N73 INVX0
X224 Opb_i[27] _NC448 _NC449 N72 INVX0
X225 Opb_i[24] _NC450 _NC451 N70 INVX0
X226 Opb_i[26] _NC452 _NC453 N71 INVX0
X227 Opa_i[25] _NC454 _NC455 N74 INVX0
X228 Opa_i[28] _NC456 _NC457 N75 INVX0
X229 Opb_i[5] N38 Opa_i[5] N22 S_fract_sm_28[5] _NC458 _NC459 AO22X1
X230 Opb_i[0] N37 Opa_i[0] N22 S_fract_sm_28[0] _NC460 _NC461 AO22X1
X231 N4330 _NC462 _NC463 N30 NBUFFX2
X232 N13 _NC464 _NC465 N26 NBUFFX2
X233 N14 _NC466 _NC467 N24 NBUFFX2
X234 N12 _NC468 _NC469 N28 NBUFFX2
X235 N14 _NC470 _NC471 N23 NBUFFX2
X236 N12 _NC472 _NC473 N27 NBUFFX2
X237 N109 _NC474 _NC475 N48 NBUFFX2
X238 N109 _NC476 _NC477 N44 NBUFFX2
X239 N109 _NC478 _NC479 N47 NBUFFX2
X240 N109 _NC480 _NC481 N45 NBUFFX2
X241 N109 _NC482 _NC483 N46 NBUFFX2
X242 N109 _NC484 _NC485 N35 NBUFFX2
X243 N3220 _NC486 _NC487 N2640 INVX0
X244 N3200 _NC488 _NC489 N262 INVX0
X245 N3240 _NC490 _NC491 N2660 INVX0
X246 N3160 _NC492 _NC493 N260 INVX0
X247 N3170 _NC494 _NC495 N261 INVX0
X248 N3230 _NC496 _NC497 N2650 INVX0
X249 N3210 _NC498 _NC499 N2630 INVX0
X250 N362 _NC500 _NC501 N111 INVX0
X251 N3760 _NC502 _NC503 N113 INVX0
X252 N29 N4020 S_fract_shr_28[3] _NC504 _NC505 NOR2X0
X253 N29 N4080 S_fract_shr_28[4] _NC506 _NC507 NOR2X0
X254 N360 _NC508 _NC509 N112 INVX0
X255 N29 N395 S_fract_shr_28[2] _NC510 _NC511 NOR2X0
X256 N29 N415 S_fract_shr_28[5] _NC512 _NC513 NOR2X0
X257 N29 N4220 S_fract_shr_28[6] _NC514 _NC515 NOR2X0
X258 N29 N4270 S_fract_shr_28[7] _NC516 _NC517 NOR2X0
X259 N29 N432 S_fract_shr_28[8] _NC518 _NC519 NOR2X0
X260 N29 N3320 S_fract_shr_28[9] _NC520 _NC521 NOR2X0
X261 S_fract_sm_28[21] _NC522 _NC523 N3070 INVX0
X262 N29 N3700 S_fract_shr_28[0] _NC524 _NC525 NOR2X0
X263 N29 N3850 S_fract_shr_28[1] _NC526 _NC527 NOR2X0
X264 S_fract_sm_28[20] _NC528 _NC529 N3060 INVX0
X265 S_fract_sm_28[22] _NC530 _NC531 N3080 INVX0
X266 N362 N11 N3930 _NC532 _NC533 NAND2X1
X267 N3760 N11 N430 _NC534 _NC535 NAND2X1
X268 N360 N11 N377 _NC536 _NC537 NAND2X1
X269 S_fract_sm_28[18] _NC538 _NC539 N3040 INVX0
X270 S_fract_sm_28[19] _NC540 _NC541 N3050 INVX0
X271 S_fract_sm_28[17] _NC542 _NC543 N3030 INVX0
X272 S_fract_sm_28[16] _NC544 _NC545 N3020 INVX0
X273 S_fract_sm_28[14] _NC546 _NC547 N3000 INVX0
X274 N109 _NC548 _NC549 N43 NBUFFX2
X275 S_fract_sm_28[15] _NC550 _NC551 N3010 INVX0
X276 S_fract_sm_28[13] _NC552 _NC553 N2990 INVX0
X277 S_fract_sm_28[12] _NC554 _NC555 N2980 INVX0
X278 S_fract_sm_28[10] _NC556 _NC557 N296 INVX0
X279 S_fract_sm_28[11] _NC558 _NC559 N2970 INVX0
X280 N232 S_fract_sm_28[21] N233 _NC560 _NC561 NOR2X0
X281 N109 _NC562 _NC563 N38 NBUFFX2
X282 N226 S_fract_sm_28[16] N227 _NC564 _NC565 NOR2X0
X283 N224 S_fract_sm_28[14] N225 _NC566 _NC567 NOR2X0
X284 N216 S_fract_sm_28[7] N217 _NC568 _NC569 NOR2X0
X285 S_fract_sm_28[0] S_fract_sm_28[1] N1840 _NC570 _NC571 NOR2X0
X286 N218 S_fract_sm_28[10] N219 _NC572 _NC573 NOR2X0
X287 S_fract_sm_28[7] _NC574 _NC575 N293 INVX0
X288 N210 S_fract_sm_28[3] N2360 _NC576 _NC577 NOR2X0
X289 N148 S_fract_sm_28[19] N2310 _NC578 _NC579 NOR2X0
X290 N1850 S_fract_sm_28[5] N1860 _NC580 _NC581 NOR2X0
X291 S_fract_sm_28[9] _NC582 _NC583 N295 INVX0
X292 S_fract_sm_28[6] _NC584 _NC585 N292 INVX0
X293 S_fract_sm_28[8] _NC586 _NC587 N294 INVX0
X294 N176 S_fract_sm_28[12] N133 _NC588 _NC589 NOR2X0
X295 S_fract_sm_28[5] _NC590 _NC591 N291 INVX0
X296 S_fract_sm_28[3] _NC592 _NC593 N2890 INVX0
X297 N109 _NC594 _NC595 N37 NBUFFX2
X298 S_fract_sm_28[4] _NC596 _NC597 N2900 INVX0
X299 N80 _NC598 _NC599 N91 INVX0
X300 N58 _NC600 _NC601 N76 INVX0
X301 N1250 N287 N149 N270 N1940 N20 _NC602 _NC603 AOI221X1
X302 S_fract_sm_28[0] _NC604 _NC605 N231 INVX0
X303 S_fract_sm_28[1] _NC606 _NC607 N2870 INVX0
X304 S_fract_sm_28[0] S_fract_sm_28[1] N238 _NC608 _NC609 NAND2X1
X305 N29 N326 N19 _NC610 _NC611 OR2X1
X306 N90 N89 N88 N87 N18 _NC612 _NC613 AND4X1
X307 N18 N1440 N19 N2380 _NC614 _NC615 OA21X1
X308 Add_105_I9_L07002_C161_carry[3] N313 N302 _NC616 _NC617 XNOR2X1
X309 N109 _NC618 _NC619 N36 NBUFFX2
X310 S_fract_sm_28[2] _NC620 _NC621 N2880 INVX0
X311 N3900 _NC622 _NC623 N259 INVX0
X312 N343 _NC624 _NC625 N2670 INVX0
X313 N3420 _NC626 _NC627 N115 INVX0
X314 N3650 _NC628 _NC629 N258 INVX0
X315 N345 _NC630 _NC631 N152 INVX0
X316 N3550 _NC632 _NC633 N114 INVX0
X317 N3860 _NC634 _NC635 N268 INVX0
X318 N210 N2360 N149 _NC636 _NC637 NOR2X0
X319 N2520 _NC638 _NC639 N310 INVX0
X320 N1850 N1860 N150 _NC640 _NC641 NOR2X0
X321 N2520 N35 N243 _NC642 _NC643 NOR2X0
X322 N310 N35 N244 _NC644 _NC645 NOR2X0
X323 N2520 N21 N241 _NC646 _NC647 NOR2X0
X324 N1860 _NC648 _NC649 N2840 INVX0
X325 N1840 _NC650 _NC651 N2820 INVX0
X326 N3540 N23 N3740 _NC652 _NC653 NAND2X1
X327 S_fract_sm_28[23] N27 N330 _NC654 _NC655 NAND2X1
X328 N3390 N25 N3590 _NC656 _NC657 NAND2X1
X329 N216 N217 N122 _NC658 _NC659 NOR2X0
X330 N439 _NC660 _NC661 N2810 INVX0
X331 N358 N1270 N3140 _NC662 _NC663 NAND2X1
X332 N290 N1250 N3150 _NC664 _NC665 NAND2X1
X333 N133 N224 N134 _NC666 _NC667 NAND2X1
X334 N218 N219 N123 _NC668 _NC669 NOR2X0
X335 S_fract_sm_28[23] _NC670 _NC671 N309 INVX0
X336 N458 _NC672 _NC673 N2720 INVX0
X337 N441 _NC674 _NC675 N273 INVX0
X338 N440 _NC676 _NC677 N279 INVX0
X339 N424 _NC678 _NC679 N274 INVX0
X340 N423 _NC680 _NC681 N2800 INVX0
X341 N1240 N406 N197 _NC682 _NC683 NAND2X1
X342 N225 N226 N1310 _NC684 _NC685 NAND2X1
X343 N227 N138 N136 _NC686 _NC687 NAND2X1
X344 N461 _NC688 _NC689 N95 INVX0
X345 N509 _NC690 _NC691 N2690 INVX0
X346 N508 _NC692 _NC693 N275 INVX0
X347 N460 _NC694 _NC695 N102 INVX0
X348 N457 _NC696 _NC697 N278 INVX0
X349 N459 _NC698 _NC699 N108 INVX0
X350 N478 _NC700 _NC701 N94 INVX0
X351 N475 _NC702 _NC703 N2710 INVX0
X352 N477 _NC704 _NC705 N101 INVX0
X353 N474 _NC706 _NC707 N277 INVX0
X354 N476 _NC708 _NC709 N107 INVX0
X355 N492 _NC710 _NC711 N2700 INVX0
X356 N494 _NC712 _NC713 N100 INVX0
X357 N491 _NC714 _NC715 N276 INVX0
X358 N444 _NC716 _NC717 N96 INVX0
X359 N427 _NC718 _NC719 N97 INVX0
X360 N443 _NC720 _NC721 N103 INVX0
X361 N426 _NC722 _NC723 N104 INVX0
X362 N442 _NC724 _NC725 N1090 INVX0
X363 N425 _NC726 _NC727 N110 INVX0
X364 N229 N230 N228 _NC728 _NC729 NOR2X0
X365 N1240 N405 N212 _NC730 _NC731 NAND2X1
X366 N148 N2310 N147 _NC732 _NC733 NOR2X0
X367 N232 N233 N1420 _NC734 _NC735 NOR2X0
X368 N512 _NC736 _NC737 N92 INVX0
X369 N511 _NC738 _NC739 N99 INVX0
X370 N510 _NC740 _NC741 N105 INVX0
X371 N495 _NC742 _NC743 N93 INVX0
X372 N493 _NC744 _NC745 N106 INVX0
X373 N217 N294 N220 _NC746 _NC747 NAND2X1
X374 N2310 N3060 N232 _NC748 _NC749 NAND2X1
X375 N1840 N2880 N210 _NC750 _NC751 NAND2X1
X376 N233 N3080 N234 _NC752 _NC753 NAND2X1
X377 N225 N3010 N226 _NC754 _NC755 NAND2X1
X378 N2860 N295 N218 _NC756 _NC757 NAND2X1
X379 N1860 N292 N216 _NC758 _NC759 NAND2X1
X380 N133 N2990 N224 _NC760 _NC761 NAND2X1
X381 N2360 N2900 N1850 _NC762 _NC763 NAND2X1
X382 N227 N3030 N138 _NC764 _NC765 NAND2X1
X383 N219 N2970 N176 _NC766 _NC767 NAND2X1
X384 N234 S_fract_sm_28[23] N1440 _NC768 _NC769 NOR2X0
X385 N1910 N1920 N1900 _NC770 _NC771 NOR2X0
X386 N1270 N356 N177 _NC772 _NC773 NAND2X1
X387 N1280 N1290 N1260 _NC774 _NC775 NAND2X1
X388 N1560 N1570 N1550 _NC776 _NC777 NAND2X1
X389 N1690 N1700 N1680 _NC778 _NC779 NAND2X1
X390 N1640 N1650 N1660 N1670 N17 _NC780 _NC781 AND4X1
X391 N116 N117 N118 N119 N16 _NC782 _NC783 AND4X1
X392 N1600 N1610 N1590 _NC784 _NC785 NOR2X0
X393 N205 N206 N204 _NC786 _NC787 NOR2X0
X394 N173 N174 N172 _NC788 _NC789 NOR2X0
X395 N1390 N1400 N137 _NC790 _NC791 NOR2X0
X396 N151 N8 N153 N154 N15 _NC792 _NC793 AND4X1
X397 N35 N2380 S_fracta_28_o[0] _NC794 _NC795 NOR2X0
X398 N2380 N21 S_fractb_28_o[0] _NC796 _NC797 NOR2X0
X399 N285 N2900 N313 _NC798 _NC799 NAND2X1
X400 N1850 _NC800 _NC801 N2830 INVX0
X401 N21 N310 N240 _NC802 _NC803 NOR2X0
X402 N176 _NC804 _NC805 N2850 INVX0
X403 N33 _NC806 _NC807 N21 NBUFFX2
X404 N220 _NC808 _NC809 N2860 INVX0
X405 N234 N1440 N1450 _NC810 _NC811 NOR2X0
X406 N313 _NC812 _NC813 N98 INVX0
X407 N34 _NC814 _NC815 N22 NBUFFX4
X408 N3140 N3150 N8 _NC816 _NC817 AND2X1
X409 S_fract_sm_28[0] S_fract_sm_28[1] N7 _NC818 _NC819 AND2X1
X410 N267 N2890 N6 _NC820 _NC821 AND2X1
X411 N249 N2880 N5 _NC822 _NC823 AND2X1
X412 N4330 _NC824 _NC825 N29 NBUFFX2
X413 N308 N150 N116 _NC826 _NC827 NAND2X1
X414 Vdd _NC828 _NC829 Fracta_28_o[27] INVX0
X415 Vdd _NC830 _NC831 Fractb_28_o[27] INVX0
X416 N238 Add_105_I6_L07002_C161_carry[2] N249 _NC832 _NC833 _NC834 HADDX1
X417 N7 N236 Add_105_I6_L07002_C161_carry[2] _NC835 _NC836 _NC837 HADDX1
X418 N5 Add_105_I7_L07002_C161_carry[3] N267 _NC838 _NC839 _NC840 HADDX1
X419 N254 Add_105_I7_L07002_C161_carry[2] Add_105_I7_L07002_C161_carry[3] _NC841 _NC842 _NC843 HADDX1
X420 N253 N252 Add_105_I7_L07002_C161_carry[2] _NC844 _NC845 _NC846 HADDX1
X421 N6 Add_105_I8_L07002_C161_carry[2] N285 _NC847 _NC848 _NC849 HADDX1
X422 N272 Add_105_I8_L07002_C161_carry[1] Add_105_I8_L07002_C161_carry[2] _NC850 _NC851 _NC852 HADDX1
X423 N271 Add_105_I8_L07002_C161_carry[0] Add_105_I8_L07002_C161_carry[1] _NC853 _NC854 _NC855 HADDX1
X424 N270 N269 Add_105_I8_L07002_C161_carry[0] _NC856 _NC857 _NC858 HADDX1
X425 N290 Add_105_I9_L07002_C161_carry[2] Add_105_I9_L07002_C161_carry[3] _NC859 _NC860 _NC861 HADDX1
X426 N289 Add_105_I9_L07002_C161_carry[1] Add_105_I9_L07002_C161_carry[2] _NC862 _NC863 _NC864 HADDX1
X427 N288 Add_105_I9_L07002_C161_carry[0] Add_105_I9_L07002_C161_carry[1] _NC865 _NC866 _NC867 HADDX1
X428 N287 N286 Add_105_I9_L07002_C161_carry[0] _NC868 _NC869 _NC870 HADDX1
X429 N307 Add_105_I10_L07002_C161_carry[2] Add_105_I10_L07002_C161_carry[3] _NC871 _NC872 _NC873 HADDX1
X430 N306 Add_105_I10_L07002_C161_carry[1] Add_105_I10_L07002_C161_carry[2] _NC874 _NC875 _NC876 HADDX1
X431 N305 Add_105_I10_L07002_C161_carry[0] Add_105_I10_L07002_C161_carry[1] _NC877 _NC878 _NC879 HADDX1
X432 N304 N303 Add_105_I10_L07002_C161_carry[0] _NC880 _NC881 _NC882 HADDX1
X433 N324 Add_105_I11_L07002_C161_carry[2] Add_105_I11_L07002_C161_carry[3] _NC883 _NC884 _NC885 HADDX1
X434 N323 Add_105_I11_L07002_C161_carry[1] Add_105_I11_L07002_C161_carry[2] _NC886 _NC887 _NC888 HADDX1
X435 N322 Add_105_I11_L07002_C161_carry[0] Add_105_I11_L07002_C161_carry[1] _NC889 _NC890 _NC891 HADDX1
X436 N321 N320 Add_105_I11_L07002_C161_carry[0] _NC892 _NC893 _NC894 HADDX1
X437 N341 Add_105_I12_L07002_C161_carry[2] Add_105_I12_L07002_C161_carry[3] _NC895 _NC896 _NC897 HADDX1
X438 N340 Add_105_I12_L07002_C161_carry[1] Add_105_I12_L07002_C161_carry[2] _NC898 _NC899 _NC900 HADDX1
X439 N339 Add_105_I12_L07002_C161_carry[0] Add_105_I12_L07002_C161_carry[1] _NC901 _NC902 _NC903 HADDX1
X440 N338 N337 Add_105_I12_L07002_C161_carry[0] _NC904 _NC905 _NC906 HADDX1
X441 N358 Add_105_I13_L07002_C161_carry[2] Add_105_I13_L07002_C161_carry[3] _NC907 _NC908 _NC909 HADDX1
X442 N357 Add_105_I13_L07002_C161_carry[1] Add_105_I13_L07002_C161_carry[2] _NC910 _NC911 _NC912 HADDX1
X443 N356 Add_105_I13_L07002_C161_carry[0] Add_105_I13_L07002_C161_carry[1] _NC913 _NC914 _NC915 HADDX1
X444 N355 N354 Add_105_I13_L07002_C161_carry[0] _NC916 _NC917 _NC918 HADDX1
X445 N375 Add_105_I14_L07002_C161_carry[2] Add_105_I14_L07002_C161_carry[3] _NC919 _NC920 _NC921 HADDX1
X446 N374 Add_105_I14_L07002_C161_carry[1] Add_105_I14_L07002_C161_carry[2] _NC922 _NC923 _NC924 HADDX1
X447 N373 Add_105_I14_L07002_C161_carry[0] Add_105_I14_L07002_C161_carry[1] _NC925 _NC926 _NC927 HADDX1
X448 N372 N371 Add_105_I14_L07002_C161_carry[0] _NC928 _NC929 _NC930 HADDX1
X449 N392 Add_105_I15_L07002_C161_carry[2] Add_105_I15_L07002_C161_carry[3] _NC931 _NC932 _NC933 HADDX1
X450 N391 Add_105_I15_L07002_C161_carry[1] Add_105_I15_L07002_C161_carry[2] _NC934 _NC935 _NC936 HADDX1
X451 N390 Add_105_I15_L07002_C161_carry[0] Add_105_I15_L07002_C161_carry[1] _NC937 _NC938 _NC939 HADDX1
X452 N389 N388 Add_105_I15_L07002_C161_carry[0] _NC940 _NC941 _NC942 HADDX1
X453 N409 Add_105_I16_L07002_C161_carry[2] Add_105_I16_L07002_C161_carry[3] _NC943 _NC944 _NC945 HADDX1
X454 N408 Add_105_I16_L07002_C161_carry[1] Add_105_I16_L07002_C161_carry[2] _NC946 _NC947 _NC948 HADDX1
X455 N407 Add_105_I16_L07002_C161_carry[0] Add_105_I16_L07002_C161_carry[1] _NC949 _NC950 _NC951 HADDX1
X456 N406 N405 Add_105_I16_L07002_C161_carry[0] _NC952 _NC953 _NC954 HADDX1
X457 N426 Add_105_I17_L07002_C161_carry[2] Add_105_I17_L07002_C161_carry[3] _NC955 _NC956 _NC957 HADDX1
X458 N425 Add_105_I17_L07002_C161_carry[1] Add_105_I17_L07002_C161_carry[2] _NC958 _NC959 _NC960 HADDX1
X459 N424 Add_105_I17_L07002_C161_carry[0] Add_105_I17_L07002_C161_carry[1] _NC961 _NC962 _NC963 HADDX1
X460 N423 N422 Add_105_I17_L07002_C161_carry[0] _NC964 _NC965 _NC966 HADDX1
X461 N443 Add_105_I18_L07002_C161_carry[2] Add_105_I18_L07002_C161_carry[3] _NC967 _NC968 _NC969 HADDX1
X462 N442 Add_105_I18_L07002_C161_carry[1] Add_105_I18_L07002_C161_carry[2] _NC970 _NC971 _NC972 HADDX1
X463 N441 Add_105_I18_L07002_C161_carry[0] Add_105_I18_L07002_C161_carry[1] _NC973 _NC974 _NC975 HADDX1
X464 N440 N439 Add_105_I18_L07002_C161_carry[0] _NC976 _NC977 _NC978 HADDX1
X465 N460 Add_105_I19_L07002_C161_carry[2] Add_105_I19_L07002_C161_carry[3] _NC979 _NC980 _NC981 HADDX1
X466 N459 Add_105_I19_L07002_C161_carry[1] Add_105_I19_L07002_C161_carry[2] _NC982 _NC983 _NC984 HADDX1
X467 N458 Add_105_I19_L07002_C161_carry[0] Add_105_I19_L07002_C161_carry[1] _NC985 _NC986 _NC987 HADDX1
X468 N457 N456 Add_105_I19_L07002_C161_carry[0] _NC988 _NC989 _NC990 HADDX1
X469 N477 Add_105_I20_L07002_C161_carry[2] Add_105_I20_L07002_C161_carry[3] _NC991 _NC992 _NC993 HADDX1
X470 N476 Add_105_I20_L07002_C161_carry[1] Add_105_I20_L07002_C161_carry[2] _NC994 _NC995 _NC996 HADDX1
X471 N475 Add_105_I20_L07002_C161_carry[0] Add_105_I20_L07002_C161_carry[1] _NC997 _NC998 _NC999 HADDX1
X472 N474 N473 Add_105_I20_L07002_C161_carry[0] _NC1000 _NC1001 _NC1002 HADDX1
X473 N494 Add_105_I21_L07002_C161_carry[2] Add_105_I21_L07002_C161_carry[3] _NC1003 _NC1004 _NC1005 HADDX1
X474 N493 Add_105_I21_L07002_C161_carry[1] Add_105_I21_L07002_C161_carry[2] _NC1006 _NC1007 _NC1008 HADDX1
X475 N492 Add_105_I21_L07002_C161_carry[0] Add_105_I21_L07002_C161_carry[1] _NC1009 _NC1010 _NC1011 HADDX1
X476 N491 N490 Add_105_I21_L07002_C161_carry[0] _NC1012 _NC1013 _NC1014 HADDX1
X477 N511 Add_105_I22_L07002_C161_carry[2] Add_105_I22_L07002_C161_carry[3] _NC1015 _NC1016 _NC1017 HADDX1
X478 N510 Add_105_I22_L07002_C161_carry[1] Add_105_I22_L07002_C161_carry[2] _NC1018 _NC1019 _NC1020 HADDX1
X479 N509 Add_105_I22_L07002_C161_carry[0] Add_105_I22_L07002_C161_carry[1] _NC1021 _NC1022 _NC1023 HADDX1
X480 N508 N507 Add_105_I22_L07002_C161_carry[0] _NC1024 _NC1025 _NC1026 HADDX1
X481 N528 Add_105_I23_L07002_C161_carry[2] Add_105_I23_L07002_C161_carry[3] _NC1027 _NC1028 _NC1029 HADDX1
X482 N527 Add_105_I23_L07002_C161_carry[1] Add_105_I23_L07002_C161_carry[2] _NC1030 _NC1031 _NC1032 HADDX1
X483 N526 Add_105_I23_L07002_C161_carry[0] Add_105_I23_L07002_C161_carry[1] _NC1033 _NC1034 _NC1035 HADDX1
X484 N525 N524 Add_105_I23_L07002_C161_carry[0] _NC1036 _NC1037 _NC1038 HADDX1
X485 N545 Add_105_I24_L07002_C161_carry[2] Add_105_I24_L07002_C161_carry[3] _NC1039 _NC1040 _NC1041 HADDX1
X486 N544 Add_105_I24_L07002_C161_carry[1] Add_105_I24_L07002_C161_carry[2] _NC1042 _NC1043 _NC1044 HADDX1
X487 N543 Add_105_I24_L07002_C161_carry[0] Add_105_I24_L07002_C161_carry[1] _NC1045 _NC1046 _NC1047 HADDX1
X488 N542 N541 Add_105_I24_L07002_C161_carry[0] _NC1048 _NC1049 _NC1050 HADDX1
X489 N562 Add_105_I25_L07002_C161_carry[2] Add_105_I25_L07002_C161_carry[3] _NC1051 _NC1052 _NC1053 HADDX1
X490 N561 Add_105_I25_L07002_C161_carry[1] Add_105_I25_L07002_C161_carry[2] _NC1054 _NC1055 _NC1056 HADDX1
X491 N560 Add_105_I25_L07002_C161_carry[0] Add_105_I25_L07002_C161_carry[1] _NC1057 _NC1058 _NC1059 HADDX1
X492 N559 N558 Add_105_I25_L07002_C161_carry[0] _NC1060 _NC1061 _NC1062 HADDX1
X493 N579 Add_105_I26_L07002_C161_carry[2] Add_105_I26_L07002_C161_carry[3] _NC1063 _NC1064 _NC1065 HADDX1
X494 N578 Add_105_I26_L07002_C161_carry[1] Add_105_I26_L07002_C161_carry[2] _NC1066 _NC1067 _NC1068 HADDX1
X495 N577 Add_105_I26_L07002_C161_carry[0] Add_105_I26_L07002_C161_carry[1] _NC1069 _NC1070 _NC1071 HADDX1
X496 N576 N575 Add_105_I26_L07002_C161_carry[0] _NC1072 _NC1073 _NC1074 HADDX1
X497 N596 Add_105_I27_L07002_C161_carry[2] Add_105_I27_L07002_C161_carry[3] _NC1075 _NC1076 _NC1077 HADDX1
X498 N595 Add_105_I27_L07002_C161_carry[1] Add_105_I27_L07002_C161_carry[2] _NC1078 _NC1079 _NC1080 HADDX1
X499 N594 Add_105_I27_L07002_C161_carry[0] Add_105_I27_L07002_C161_carry[1] _NC1081 _NC1082 _NC1083 HADDX1
X500 N593 N592 Add_105_I27_L07002_C161_carry[0] _NC1084 _NC1085 _NC1086 HADDX1
X501 N613 Add_105_I28_L07002_C161_carry[2] Add_105_I28_L07002_C161_carry[3] _NC1087 _NC1088 _NC1089 HADDX1
X502 N612 Add_105_I28_L07002_C161_carry[1] Add_105_I28_L07002_C161_carry[2] _NC1090 _NC1091 _NC1092 HADDX1
X503 N611 Add_105_I28_L07002_C161_carry[0] Add_105_I28_L07002_C161_carry[1] _NC1093 _NC1094 _NC1095 HADDX1
X504 N610 N609 Add_105_I28_L07002_C161_carry[0] _NC1096 _NC1097 _NC1098 HADDX1
X505 Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] N49 Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] N51 Opa_i[30] Vss N139 N140 N141 N142 N143 N144 N145 N146 _NC1099 pre_norm_addsub_DW01_sub_3
X506 Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] N49 Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] N51 Opa_i[30] Vdd N155 N156 N157 N158 N159 N160 N161 N162 _NC1100 pre_norm_addsub_DW01_sub_2
X507 N49 Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] N51 Opa_i[30] Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Vss N163 N164 N165 N166 N167 N168 N169 N170 _NC1101 pre_norm_addsub_DW01_sub_1
X508 N49 Opa_i[24] Opa_i[25] Opa_i[26] Opa_i[27] Opa_i[28] N51 Opa_i[30] Opb_i[23] Opb_i[24] Opb_i[25] Opb_i[26] Opb_i[27] Opb_i[28] Opb_i[29] Opb_i[30] Vdd N179 N180 N181 N182 N183 N184 N185 N186 _NC1102 pre_norm_addsub_DW01_sub_0
X509 N49 N44 Opb_i[23] N33 N124 _NC1103 _NC1104 AO22X1
X510 Opa_i[24] N36 Opb_i[24] N22 N125 _NC1105 _NC1106 AO22X1
X511 Opa_i[25] N36 Opb_i[25] N22 N126 _NC1107 _NC1108 AO22X1
X512 Opa_i[26] N36 Opb_i[26] N22 N127 _NC1109 _NC1110 AO22X1
X513 Opa_i[27] N37 Opb_i[27] N22 N128 _NC1111 _NC1112 AO22X1
X514 Opa_i[28] N37 Opb_i[28] N22 N129 _NC1113 _NC1114 AO22X1
X515 N51 N37 Opb_i[29] N22 N130 _NC1115 _NC1116 AO22X1
X516 Opa_i[30] N37 Opb_i[30] N22 N131 _NC1117 _NC1118 AO22X1
X517 Opb_i[30] Opb_i[29] Opb_i[28] Opb_i[27] N256 _NC1119 _NC1120 NOR4X0
X518 N312 N70 N255 N256 N237 _NC1121 _NC1122 NAND4X0
X519 Opa_i[30] N51 Opa_i[28] Opa_i[27] N2540 _NC1123 _NC1124 NOR4X0
X520 N50 N311 N2530 N2540 N239 _NC1125 _NC1126 NAND4X0
X521 N237 N239 N2520 _NC1127 _NC1128 XOR2X1
X522 N139 N243 N155 N244 N251 _NC1129 _NC1130 AO22X1
X523 N179 N240 N163 N241 N251 N187 _NC1131 _NC1132 AO221X1
X524 N140 N243 N156 N244 N250 _NC1133 _NC1134 AO22X1
X525 N180 N240 N164 N241 N250 N188 _NC1135 _NC1136 AO221X1
X526 N141 N243 N157 N244 N2490 _NC1137 _NC1138 AO22X1
X527 N181 N240 N165 N241 N2490 N189 _NC1139 _NC1140 AO221X1
X528 N142 N243 N158 N244 N2480 _NC1141 _NC1142 AO22X1
X529 N182 N240 N166 N241 N2480 N190 _NC1143 _NC1144 AO221X1
X530 N143 N243 N159 N244 N2470 _NC1145 _NC1146 AO22X1
X531 N183 N240 N167 N241 N2470 N191 _NC1147 _NC1148 AO221X1
X532 N144 N243 N160 N244 N2460 _NC1149 _NC1150 AO22X1
X533 N184 N240 N168 N241 N2460 N192 _NC1151 _NC1152 AO221X1
X534 N145 N243 N161 N244 N245 _NC1153 _NC1154 AO22X1
X535 N185 N240 N169 N241 N245 N193 _NC1155 _NC1156 AO221X1
X536 N146 N243 N162 N244 N242 _NC1157 _NC1158 AO22X1
X537 N186 N240 N170 N241 N242 N194 _NC1159 _NC1160 AO221X1
X538 Opb_i[1] N37 Opa_i[1] N22 S_fract_sm_28[1] _NC1161 _NC1162 AO22X1
X539 N231 N2870 S_fract_sm_28[1] S_fract_sm_28[0] N236 _NC1163 _NC1164 AO22X1
X540 Opb_i[2] N37 Opa_i[2] N22 S_fract_sm_28[2] _NC1165 _NC1166 AO22X1
X541 N246 N2880 N236 S_fract_sm_28[2] N252 _NC1167 _NC1168 AO22X1
X542 N247 N2880 N7 S_fract_sm_28[2] N253 _NC1169 _NC1170 AO22X1
X543 N248 N2880 N238 S_fract_sm_28[2] N254 _NC1171 _NC1172 AO22X1
X544 Opb_i[3] N37 Opa_i[3] N22 S_fract_sm_28[3] _NC1173 _NC1174 AO22X1
X545 N263 N2890 N252 S_fract_sm_28[3] N269 _NC1175 _NC1176 AO22X1
X546 N264 N2890 N253 S_fract_sm_28[3] N270 _NC1177 _NC1178 AO22X1
X547 N265 N2890 N254 S_fract_sm_28[3] N271 _NC1179 _NC1180 AO22X1
X548 N266 N2890 N5 S_fract_sm_28[3] N272 _NC1181 _NC1182 AO22X1
X549 Opb_i[4] N37 Opa_i[4] N22 S_fract_sm_28[4] _NC1183 _NC1184 AO22X1
X550 N280 N2900 N269 S_fract_sm_28[4] N286 _NC1185 _NC1186 AO22X1
X551 N281 N2900 N270 S_fract_sm_28[4] N287 _NC1187 _NC1188 AO22X1
X552 N282 N2900 N271 S_fract_sm_28[4] N288 _NC1189 _NC1190 AO22X1
X553 N283 N2900 N272 S_fract_sm_28[4] N289 _NC1191 _NC1192 AO22X1
X554 N284 N2900 N6 S_fract_sm_28[4] N290 _NC1193 _NC1194 AO22X1
X555 N297 N291 N286 S_fract_sm_28[5] N303 _NC1195 _NC1196 AO22X1
X556 N298 N291 N287 S_fract_sm_28[5] N304 _NC1197 _NC1198 AO22X1
X557 N299 N291 N288 S_fract_sm_28[5] N305 _NC1199 _NC1200 AO22X1
X558 N300 N291 N289 S_fract_sm_28[5] N306 _NC1201 _NC1202 AO22X1
X559 N301 N291 N290 S_fract_sm_28[5] N307 _NC1203 _NC1204 AO22X1
X560 N302 N291 N98 S_fract_sm_28[5] N308 _NC1205 _NC1206 AO22X1
X561 Opb_i[6] N37 Opa_i[6] N22 S_fract_sm_28[6] _NC1207 _NC1208 AO22X1
X562 N314 N292 N303 S_fract_sm_28[6] N320 _NC1209 _NC1210 AO22X1
X563 N315 N292 N304 S_fract_sm_28[6] N321 _NC1211 _NC1212 AO22X1
X564 N316 N292 N305 S_fract_sm_28[6] N322 _NC1213 _NC1214 AO22X1
X565 N317 N292 N306 S_fract_sm_28[6] N323 _NC1215 _NC1216 AO22X1
X566 N318 N292 N307 S_fract_sm_28[6] N324 _NC1217 _NC1218 AO22X1
X567 N319 N292 S_fract_sm_28[6] N308 N325 _NC1219 _NC1220 AO22X1
X568 Opb_i[7] N38 Opa_i[7] N22 S_fract_sm_28[7] _NC1221 _NC1222 AO22X1
X569 N331 N293 N320 S_fract_sm_28[7] N337 _NC1223 _NC1224 AO22X1
X570 N332 N293 N321 S_fract_sm_28[7] N338 _NC1225 _NC1226 AO22X1
X571 N333 N293 N322 S_fract_sm_28[7] N339 _NC1227 _NC1228 AO22X1
X572 N334 N293 N323 S_fract_sm_28[7] N340 _NC1229 _NC1230 AO22X1
X573 N335 N293 N324 S_fract_sm_28[7] N341 _NC1231 _NC1232 AO22X1
X574 N336 N293 N325 S_fract_sm_28[7] N342 _NC1233 _NC1234 AO22X1
X575 Opb_i[8] N38 Opa_i[8] N22 S_fract_sm_28[8] _NC1235 _NC1236 AO22X1
X576 N348 N294 N337 S_fract_sm_28[8] N354 _NC1237 _NC1238 AO22X1
X577 N349 N294 N338 S_fract_sm_28[8] N355 _NC1239 _NC1240 AO22X1
X578 N350 N294 N339 S_fract_sm_28[8] N356 _NC1241 _NC1242 AO22X1
X579 N351 N294 N340 S_fract_sm_28[8] N357 _NC1243 _NC1244 AO22X1
X580 N352 N294 N341 S_fract_sm_28[8] N358 _NC1245 _NC1246 AO22X1
X581 N353 N294 N342 S_fract_sm_28[8] N359 _NC1247 _NC1248 AO22X1
X582 Opb_i[9] N38 Opa_i[9] N22 S_fract_sm_28[9] _NC1249 _NC1250 AO22X1
X583 N365 N295 N354 S_fract_sm_28[9] N371 _NC1251 _NC1252 AO22X1
X584 N366 N295 N355 S_fract_sm_28[9] N372 _NC1253 _NC1254 AO22X1
X585 N367 N295 N356 S_fract_sm_28[9] N373 _NC1255 _NC1256 AO22X1
X586 N368 N295 N357 S_fract_sm_28[9] N374 _NC1257 _NC1258 AO22X1
X587 N369 N295 N358 S_fract_sm_28[9] N375 _NC1259 _NC1260 AO22X1
X588 N370 N295 N359 S_fract_sm_28[9] N376 _NC1261 _NC1262 AO22X1
X589 Opb_i[10] N38 Opa_i[10] N22 S_fract_sm_28[10] _NC1263 _NC1264 AO22X1
X590 N382 N296 N371 S_fract_sm_28[10] N388 _NC1265 _NC1266 AO22X1
X591 N383 N296 N372 S_fract_sm_28[10] N389 _NC1267 _NC1268 AO22X1
X592 N384 N296 N373 S_fract_sm_28[10] N390 _NC1269 _NC1270 AO22X1
X593 N385 N296 N374 S_fract_sm_28[10] N391 _NC1271 _NC1272 AO22X1
X594 N386 N296 N375 S_fract_sm_28[10] N392 _NC1273 _NC1274 AO22X1
X595 N387 N296 N376 S_fract_sm_28[10] N393 _NC1275 _NC1276 AO22X1
X596 Opb_i[11] N38 Opa_i[11] N22 S_fract_sm_28[11] _NC1277 _NC1278 AO22X1
X597 N399 N2970 N388 S_fract_sm_28[11] N405 _NC1279 _NC1280 AO22X1
X598 N400 N2970 N389 S_fract_sm_28[11] N406 _NC1281 _NC1282 AO22X1
X599 N401 N2970 N390 S_fract_sm_28[11] N407 _NC1283 _NC1284 AO22X1
X600 N402 N2970 N391 S_fract_sm_28[11] N408 _NC1285 _NC1286 AO22X1
X601 N403 N2970 N392 S_fract_sm_28[11] N409 _NC1287 _NC1288 AO22X1
X602 N404 N2970 N393 S_fract_sm_28[11] N410 _NC1289 _NC1290 AO22X1
X603 Opb_i[12] N38 Opa_i[12] N21 S_fract_sm_28[12] _NC1291 _NC1292 AO22X1
X604 N416 N2980 N405 S_fract_sm_28[12] N422 _NC1293 _NC1294 AO22X1
X605 N417 N2980 N406 S_fract_sm_28[12] N423 _NC1295 _NC1296 AO22X1
X606 N418 N2980 N407 S_fract_sm_28[12] N424 _NC1297 _NC1298 AO22X1
X607 N419 N2980 N408 S_fract_sm_28[12] N425 _NC1299 _NC1300 AO22X1
X608 N420 N2980 N409 S_fract_sm_28[12] N426 _NC1301 _NC1302 AO22X1
X609 N421 N2980 S_fract_sm_28[12] N410 N427 _NC1303 _NC1304 AO22X1
X610 Opb_i[13] N43 Opa_i[13] N21 S_fract_sm_28[13] _NC1305 _NC1306 AO22X1
X611 N433 N2990 N422 S_fract_sm_28[13] N439 _NC1307 _NC1308 AO22X1
X612 N434 N2990 N423 S_fract_sm_28[13] N440 _NC1309 _NC1310 AO22X1
X613 N435 N2990 N424 S_fract_sm_28[13] N441 _NC1311 _NC1312 AO22X1
X614 N436 N2990 N425 S_fract_sm_28[13] N442 _NC1313 _NC1314 AO22X1
X615 N437 N2990 N426 S_fract_sm_28[13] N443 _NC1315 _NC1316 AO22X1
X616 N438 N2990 N427 S_fract_sm_28[13] N444 _NC1317 _NC1318 AO22X1
X617 N2810 N3000 N439 S_fract_sm_28[14] N456 _NC1319 _NC1320 AO22X1
X618 N451 N3000 N440 S_fract_sm_28[14] N457 _NC1321 _NC1322 AO22X1
X619 N452 N3000 N441 S_fract_sm_28[14] N458 _NC1323 _NC1324 AO22X1
X620 N453 N3000 N442 S_fract_sm_28[14] N459 _NC1325 _NC1326 AO22X1
X621 N454 N3000 N443 S_fract_sm_28[14] N460 _NC1327 _NC1328 AO22X1
X622 N455 N3000 N444 S_fract_sm_28[14] N461 _NC1329 _NC1330 AO22X1
X623 N467 N3010 N456 S_fract_sm_28[15] N473 _NC1331 _NC1332 AO22X1
X624 N468 N3010 N457 S_fract_sm_28[15] N474 _NC1333 _NC1334 AO22X1
X625 N469 N3010 N458 S_fract_sm_28[15] N475 _NC1335 _NC1336 AO22X1
X626 N470 N3010 N459 S_fract_sm_28[15] N476 _NC1337 _NC1338 AO22X1
X627 N471 N3010 N460 S_fract_sm_28[15] N477 _NC1339 _NC1340 AO22X1
X628 N472 N3010 N461 S_fract_sm_28[15] N478 _NC1341 _NC1342 AO22X1
X629 N484 N3020 N473 S_fract_sm_28[16] N490 _NC1343 _NC1344 AO22X1
X630 N485 N3020 N474 S_fract_sm_28[16] N491 _NC1345 _NC1346 AO22X1
X631 N486 N3020 N475 S_fract_sm_28[16] N492 _NC1347 _NC1348 AO22X1
X632 N487 N3020 N476 S_fract_sm_28[16] N493 _NC1349 _NC1350 AO22X1
X633 N488 N3020 N477 S_fract_sm_28[16] N494 _NC1351 _NC1352 AO22X1
X634 N489 N3020 N478 S_fract_sm_28[16] N495 _NC1353 _NC1354 AO22X1
X635 N501 N3030 N490 S_fract_sm_28[17] N507 _NC1355 _NC1356 AO22X1
X636 N502 N3030 N491 S_fract_sm_28[17] N508 _NC1357 _NC1358 AO22X1
X637 N503 N3030 N492 S_fract_sm_28[17] N509 _NC1359 _NC1360 AO22X1
X638 N504 N3030 N493 S_fract_sm_28[17] N510 _NC1361 _NC1362 AO22X1
X639 N505 N3030 N494 S_fract_sm_28[17] N511 _NC1363 _NC1364 AO22X1
X640 N506 N3030 N495 S_fract_sm_28[17] N512 _NC1365 _NC1366 AO22X1
X641 N518 N3040 N507 S_fract_sm_28[18] N524 _NC1367 _NC1368 AO22X1
X642 N519 N3040 N508 S_fract_sm_28[18] N525 _NC1369 _NC1370 AO22X1
X643 N520 N3040 N509 S_fract_sm_28[18] N526 _NC1371 _NC1372 AO22X1
X644 N521 N3040 N510 S_fract_sm_28[18] N527 _NC1373 _NC1374 AO22X1
X645 N522 N3040 N511 S_fract_sm_28[18] N528 _NC1375 _NC1376 AO22X1
X646 N523 N3040 S_fract_sm_28[18] N512 N529 _NC1377 _NC1378 AO22X1
X647 N535 N3050 N524 S_fract_sm_28[19] N541 _NC1379 _NC1380 AO22X1
X648 N536 N3050 N525 S_fract_sm_28[19] N542 _NC1381 _NC1382 AO22X1
X649 N537 N3050 N526 S_fract_sm_28[19] N543 _NC1383 _NC1384 AO22X1
X650 N538 N3050 N527 S_fract_sm_28[19] N544 _NC1385 _NC1386 AO22X1
X651 N539 N3050 N528 S_fract_sm_28[19] N545 _NC1387 _NC1388 AO22X1
X652 N540 N3050 N529 S_fract_sm_28[19] N546 _NC1389 _NC1390 AO22X1
X653 N552 N3060 N541 S_fract_sm_28[20] N558 _NC1391 _NC1392 AO22X1
X654 N553 N3060 N542 S_fract_sm_28[20] N559 _NC1393 _NC1394 AO22X1
X655 N554 N3060 N543 S_fract_sm_28[20] N560 _NC1395 _NC1396 AO22X1
X656 N555 N3060 N544 S_fract_sm_28[20] N561 _NC1397 _NC1398 AO22X1
X657 N556 N3060 N545 S_fract_sm_28[20] N562 _NC1399 _NC1400 AO22X1
X658 N557 N3060 N546 S_fract_sm_28[20] N563 _NC1401 _NC1402 AO22X1
X659 N569 N3070 N558 S_fract_sm_28[21] N575 _NC1403 _NC1404 AO22X1
X660 N570 N3070 N559 S_fract_sm_28[21] N576 _NC1405 _NC1406 AO22X1
X661 N571 N3070 N560 S_fract_sm_28[21] N577 _NC1407 _NC1408 AO22X1
X662 N572 N3070 N561 S_fract_sm_28[21] N578 _NC1409 _NC1410 AO22X1
X663 N573 N3070 N562 S_fract_sm_28[21] N579 _NC1411 _NC1412 AO22X1
X664 N574 N3070 N563 S_fract_sm_28[21] N580 _NC1413 _NC1414 AO22X1
X665 N586 N3080 N575 S_fract_sm_28[22] N592 _NC1415 _NC1416 AO22X1
X666 N587 N3080 N576 S_fract_sm_28[22] N593 _NC1417 _NC1418 AO22X1
X667 N588 N3080 N577 S_fract_sm_28[22] N594 _NC1419 _NC1420 AO22X1
X668 N589 N3080 N578 S_fract_sm_28[22] N595 _NC1421 _NC1422 AO22X1
X669 N590 N3080 N579 S_fract_sm_28[22] N596 _NC1423 _NC1424 AO22X1
X670 N591 N3080 N580 S_fract_sm_28[22] N597 _NC1425 _NC1426 AO22X1
X671 N239 N34 N36 N237 S_fract_sm_28[23] _NC1427 _NC1428 AO22X1
X672 N603 N309 N592 S_fract_sm_28[23] N609 _NC1429 _NC1430 AO22X1
X673 N604 N309 N593 S_fract_sm_28[23] N610 _NC1431 _NC1432 AO22X1
X674 N605 N309 N594 S_fract_sm_28[23] N611 _NC1433 _NC1434 AO22X1
X675 N606 N309 N595 S_fract_sm_28[23] N612 _NC1435 _NC1436 AO22X1
X676 N607 N309 N596 S_fract_sm_28[23] N613 _NC1437 _NC1438 AO22X1
X677 N608 N309 N597 S_fract_sm_28[23] N614 _NC1439 _NC1440 AO22X1
X678 N138 S_fract_sm_28[18] N148 _NC1441 _NC1442 OR2X1
X679 Opa_i[7] N43 S_fract_shr_28[9] N33 S_fracta_28_o[10] _NC1443 _NC1444 AO22X1
X680 Opa_i[8] N43 S_fract_shr_28[10] N33 S_fracta_28_o[11] _NC1445 _NC1446 AO22X1
X681 Opa_i[9] N43 S_fract_shr_28[11] N33 S_fracta_28_o[12] _NC1447 _NC1448 AO22X1
X682 Opa_i[10] N44 S_fract_shr_28[12] N33 S_fracta_28_o[13] _NC1449 _NC1450 AO22X1
X683 Opa_i[11] N44 S_fract_shr_28[13] N33 S_fracta_28_o[14] _NC1451 _NC1452 AO22X1
X684 Opa_i[12] N44 S_fract_shr_28[14] N33 S_fracta_28_o[15] _NC1453 _NC1454 AO22X1
X685 Opa_i[13] N44 S_fract_shr_28[15] N33 S_fracta_28_o[16] _NC1455 _NC1456 AO22X1
X686 Opa_i[14] N44 S_fract_shr_28[16] N33 S_fracta_28_o[17] _NC1457 _NC1458 AO22X1
X687 Opa_i[15] N44 S_fract_shr_28[17] N33 S_fracta_28_o[18] _NC1459 _NC1460 AO22X1
X688 Opa_i[16] N44 S_fract_shr_28[18] N33 S_fracta_28_o[19] _NC1461 _NC1462 AO22X1
X689 Opa_i[17] N44 S_fract_shr_28[19] N33 S_fracta_28_o[20] _NC1463 _NC1464 AO22X1
X690 Opa_i[18] N44 S_fract_shr_28[20] N33 S_fracta_28_o[21] _NC1465 _NC1466 AO22X1
X691 Opa_i[19] N45 S_fract_shr_28[21] N33 S_fracta_28_o[22] _NC1467 _NC1468 AO22X1
X692 Opa_i[20] N45 S_fract_shr_28[22] N33 S_fracta_28_o[23] _NC1469 _NC1470 AO22X1
X693 Opa_i[21] N45 S_fract_shr_28[23] N33 S_fracta_28_o[24] _NC1471 _NC1472 AO22X1
X694 Opa_i[22] N45 S_fract_shr_28[24] N33 S_fracta_28_o[25] _NC1473 _NC1474 AO22X1
X695 S_fract_shr_28[25] N34 N36 N239 S_fracta_28_o[26] _NC1475 _NC1476 AO22X1
X696 N36 Opa_i[0] S_fract_shr_28[2] N33 S_fracta_28_o[3] _NC1477 _NC1478 AO22X1
X697 Opa_i[1] N45 S_fract_shr_28[3] N33 S_fracta_28_o[4] _NC1479 _NC1480 AO22X1
X698 Opa_i[2] N45 S_fract_shr_28[4] N33 S_fracta_28_o[5] _NC1481 _NC1482 AO22X1
X699 Opa_i[3] N45 S_fract_shr_28[5] N33 S_fracta_28_o[6] _NC1483 _NC1484 AO22X1
X700 Opa_i[4] N45 S_fract_shr_28[6] N33 S_fracta_28_o[7] _NC1485 _NC1486 AO22X1
X701 Opa_i[5] N45 S_fract_shr_28[7] N33 S_fracta_28_o[8] _NC1487 _NC1488 AO22X1
X702 Opa_i[6] N45 S_fract_shr_28[8] N33 S_fracta_28_o[9] _NC1489 _NC1490 AO22X1
X703 S_fract_shr_28[9] N46 Opb_i[7] N33 S_fractb_28_o[10] _NC1491 _NC1492 AO22X1
X704 S_fract_shr_28[10] N46 Opb_i[8] N33 S_fractb_28_o[11] _NC1493 _NC1494 AO22X1
X705 S_fract_shr_28[11] N46 Opb_i[9] N33 S_fractb_28_o[12] _NC1495 _NC1496 AO22X1
X706 S_fract_shr_28[12] N46 Opb_i[10] N33 S_fractb_28_o[13] _NC1497 _NC1498 AO22X1
X707 S_fract_shr_28[13] N46 Opb_i[11] N33 S_fractb_28_o[14] _NC1499 _NC1500 AO22X1
X708 S_fract_shr_28[14] N46 Opb_i[12] N33 S_fractb_28_o[15] _NC1501 _NC1502 AO22X1
X709 S_fract_shr_28[15] N46 Opb_i[13] N33 S_fractb_28_o[16] _NC1503 _NC1504 AO22X1
X710 S_fract_shr_28[16] N46 Opb_i[14] N33 S_fractb_28_o[17] _NC1505 _NC1506 AO22X1
X711 S_fract_shr_28[17] N46 Opb_i[15] N33 S_fractb_28_o[18] _NC1507 _NC1508 AO22X1
X712 S_fract_shr_28[18] N46 Opb_i[16] N33 S_fractb_28_o[19] _NC1509 _NC1510 AO22X1
X713 S_fract_shr_28[19] N47 Opb_i[17] N33 S_fractb_28_o[20] _NC1511 _NC1512 AO22X1
X714 S_fract_shr_28[20] N47 Opb_i[18] N33 S_fractb_28_o[21] _NC1513 _NC1514 AO22X1
X715 S_fract_shr_28[21] N47 Opb_i[19] N33 S_fractb_28_o[22] _NC1515 _NC1516 AO22X1
X716 S_fract_shr_28[22] N47 Opb_i[20] N34 S_fractb_28_o[23] _NC1517 _NC1518 AO22X1
X717 S_fract_shr_28[23] N47 Opb_i[21] N34 S_fractb_28_o[24] _NC1519 _NC1520 AO22X1
X718 S_fract_shr_28[24] N47 Opb_i[22] N34 S_fractb_28_o[25] _NC1521 _NC1522 AO22X1
X719 S_fract_shr_28[25] N47 N237 N34 S_fractb_28_o[26] _NC1523 _NC1524 AO22X1
X720 S_fract_shr_28[2] N47 Opb_i[0] N34 S_fractb_28_o[3] _NC1525 _NC1526 AO22X1
X721 S_fract_shr_28[3] N47 Opb_i[1] N34 S_fractb_28_o[4] _NC1527 _NC1528 AO22X1
X722 S_fract_shr_28[4] N47 Opb_i[2] N34 S_fractb_28_o[5] _NC1529 _NC1530 AO22X1
X723 S_fract_shr_28[5] N48 Opb_i[3] N34 S_fractb_28_o[6] _NC1531 _NC1532 AO22X1
X724 S_fract_shr_28[6] N48 Opb_i[4] N34 S_fractb_28_o[7] _NC1533 _NC1534 AO22X1
X725 S_fract_shr_28[7] N48 Opb_i[5] N34 S_fractb_28_o[8] _NC1535 _NC1536 AO22X1
X726 S_fract_shr_28[8] N48 Opb_i[6] N34 S_fractb_28_o[9] _NC1537 _NC1538 AO22X1
X727 N2360 N1850 N1250 _NC1539 _NC1540 AND2X1
X728 N224 N225 N135 _NC1541 _NC1542 OR2X1
X729 N147 N541 N524 N148 N235 _NC1543 _NC1544 AO22X1
X730 N619 N1440 N1450 N609 N235 N229 _NC1545 _NC1546 AO221X1
X731 N233 N234 N1410 _NC1547 _NC1548 AND2X1
X732 N2310 N232 N1430 _NC1549 _NC1550 AND2X1
X733 N1410 N592 N1420 N575 N1430 N558 N230 _NC1551 _NC1552 AO222X1
X734 N467 N135 N518 N136 N228 N138 N221 _NC1553 _NC1554 OA222X1
X735 N226 N227 N1300 _NC1555 _NC1556 OR2X1
X736 N133 N433 N2810 N134 N223 _NC1557 _NC1558 OA22X1
X737 N501 N1300 N484 N1310 N223 N222 _NC1559 _NC1560 OA221X1
X738 N221 N222 N176 N211 _NC1561 _NC1562 AO21X1
X739 N219 N176 N1240 _NC1563 _NC1564 AND2X1
X740 N217 N220 N1270 _NC1565 _NC1566 AND2X1
X741 N354 N1270 N2840 N303 N213 _NC1567 _NC1568 AOI22X1
X742 N2860 N218 N120 _NC1569 _NC1570 AND2X1
X743 N1860 N216 N121 _NC1571 _NC1572 AND2X1
X744 N320 N121 N337 N122 N215 _NC1573 _NC1574 AO22X1
X745 N388 N123 N371 N120 N215 N214 _NC1575 _NC1576 AOI221X1
X746 N211 N212 N213 N214 N209 _NC1577 _NC1578 NAND4X0
X747 N1840 N210 N1630 _NC1579 _NC1580 AND2X1
X748 N2830 N209 N1630 N252 S_fract_sm_28[0] N208 _NC1581 _NC1582 AO221X1
X749 N1250 N286 N149 N269 N208 S_rzeros[0] _NC1583 _NC1584 AO221X1
X750 N147 N542 N525 N148 N207 _NC1585 _NC1586 AO22X1
X751 N620 N1440 N1450 N610 N207 N205 _NC1587 _NC1588 AO221X1
X752 N1410 N593 N1420 N576 N1430 N559 N206 _NC1589 _NC1590 AO222X1
X753 N278 N135 N275 N136 N204 N138 N201 _NC1591 _NC1592 OA222X1
X754 N133 N2800 N279 N134 N203 _NC1593 _NC1594 OA22X1
X755 N276 N1300 N277 N1310 N203 N202 _NC1595 _NC1596 OA221X1
X756 N201 N202 N176 N196 _NC1597 _NC1598 AO21X1
X757 N355 N1270 N2840 N304 N198 _NC1599 _NC1600 AOI22X1
X758 N321 N121 N338 N122 N200 _NC1601 _NC1602 AO22X1
X759 N389 N123 N372 N120 N200 N199 _NC1603 _NC1604 AOI221X1
X760 N196 N197 N198 N199 N195 _NC1605 _NC1606 NAND4X0
X761 N2830 N195 N1630 N253 S_fract_sm_28[0] N1940 _NC1607 _NC1608 AO221X1
X762 N147 N543 N526 N148 N1930 _NC1609 _NC1610 AO22X1
X763 N621 N1440 N1450 N611 N1930 N1910 _NC1611 _NC1612 AO221X1
X764 N1410 N594 N1420 N577 N1430 N560 N1920 _NC1613 _NC1614 AO222X1
X765 N2720 N135 N2690 N136 N1900 N138 N1870 _NC1615 _NC1616 OA222X1
X766 N133 N274 N273 N134 N1890 _NC1617 _NC1618 OA22X1
X767 N2700 N1300 N2710 N1310 N1890 N1880 _NC1619 _NC1620 OA221X1
X768 N1870 N1880 N176 N178 _NC1621 _NC1622 AO21X1
X769 N271 N149 N2820 N1830 _NC1623 _NC1624 AO21X1
X770 N288 N1250 N254 N1630 N1830 N1820 _NC1625 _NC1626 AO221X1
X771 N305 N150 N231 N1820 N1790 _NC1627 _NC1628 AOI22X1
X772 N373 N120 N322 N121 N339 N122 N1810 _NC1629 _NC1630 AO222X1
X773 N407 N1240 N390 N123 N1810 N1800 _NC1631 _NC1632 AOI221X1
X774 N177 N178 N1790 N1800 S_rzeros[2] _NC1633 _NC1634 NAND4X0
X775 N272 N149 N306 N150 N1640 _NC1635 _NC1636 AOI22X1
X776 N289 N1250 N357 N1270 N5 N1630 N1650 _NC1637 _NC1638 AOI222X1
X777 N147 N544 N527 N148 N175 _NC1639 _NC1640 AO22X1
X778 N622 N1440 N1450 N612 N175 N173 _NC1641 _NC1642 AO221X1
X779 N1410 N595 N1420 N578 N1430 N561 N174 _NC1643 _NC1644 AO222X1
X780 N108 N135 N105 N136 N172 N138 N1690 _NC1645 _NC1646 OA222X1
X781 N133 N110 N1090 N134 N171 _NC1647 _NC1648 OA22X1
X782 N106 N1300 N107 N1310 N171 N1700 _NC1649 _NC1650 OA221X1
X783 N2850 N1680 N123 N391 N1240 N408 N1660 _NC1651 _NC1652 AOI222X1
X784 N374 N120 N323 N121 N340 N122 N1670 _NC1653 _NC1654 AOI222X1
X785 N6 N149 N307 N150 N151 _NC1655 _NC1656 AOI22X1
X786 N147 N545 N528 N148 N1620 _NC1657 _NC1658 AO22X1
X787 N623 N1440 N1450 N613 N1620 N1600 _NC1659 _NC1660 AO221X1
X788 N1410 N596 N1420 N579 N1430 N562 N1610 _NC1661 _NC1662 AO222X1
X789 N102 N135 N99 N136 N1590 N138 N1560 _NC1663 _NC1664 OA222X1
X790 N133 N104 N103 N134 N1580 _NC1665 _NC1666 OA22X1
X791 N100 N1300 N101 N1310 N1580 N1570 _NC1667 _NC1668 OA221X1
X792 N2850 N1550 N123 N392 N1240 N409 N153 _NC1669 _NC1670 AOI222X1
X793 N375 N120 N324 N121 N341 N122 N154 _NC1671 _NC1672 AOI222X1
X794 N147 N546 N529 N148 N1460 _NC1673 _NC1674 AO22X1
X795 N624 N1440 N1450 N614 N1460 N1390 _NC1675 _NC1676 AO221X1
X796 N1410 N597 N1420 N580 N1430 N563 N1400 _NC1677 _NC1678 AO222X1
X797 N95 N135 N92 N136 N137 N138 N1280 _NC1679 _NC1680 OA222X1
X798 N133 N97 N96 N134 N132 _NC1681 _NC1682 OA22X1
X799 N93 N1300 N94 N1310 N132 N1290 _NC1683 _NC1684 OA221X1
X800 N1250 N98 N2850 N1260 N1270 N359 N117 _NC1685 _NC1686 AOI222X1
X801 N393 N123 N410 N1240 N118 _NC1687 _NC1688 AOI22X1
X802 N376 N120 N325 N121 N342 N122 N119 _NC1689 _NC1690 AOI222X1
X803 Clk_i S_fracta_28_o[0] Fracta_28_o[0] _NC1691 _NC1692 _NC1693 DFFX1
X804 Clk_i S_fractb_28_o[0] Fractb_28_o[0] _NC1694 _NC1695 _NC1696 DFFX1
X805 Clk_i S_fractb_28_o[26] Fractb_28_o[26] _NC1697 _NC1698 _NC1699 DFFX1
X806 Clk_i S_fracta_28_o[26] Fracta_28_o[26] _NC1700 _NC1701 _NC1702 DFFX1
X807 Clk_i S_fractb_28_o[25] Fractb_28_o[25] _NC1703 _NC1704 _NC1705 DFFX1
X808 Clk_i S_fracta_28_o[25] Fracta_28_o[25] _NC1706 _NC1707 _NC1708 DFFX1
X809 Clk_i S_fractb_28_o[24] Fractb_28_o[24] _NC1709 _NC1710 _NC1711 DFFX1
X810 Clk_i S_fracta_28_o[24] Fracta_28_o[24] _NC1712 _NC1713 _NC1714 DFFX1
X811 Clk_i S_fractb_28_o[23] Fractb_28_o[23] _NC1715 _NC1716 _NC1717 DFFX1
X812 Clk_i S_fracta_28_o[23] Fracta_28_o[23] _NC1718 _NC1719 _NC1720 DFFX1
X813 Clk_i S_fractb_28_o[22] Fractb_28_o[22] _NC1721 _NC1722 _NC1723 DFFX1
X814 Clk_i S_fracta_28_o[22] Fracta_28_o[22] _NC1724 _NC1725 _NC1726 DFFX1
X815 Clk_i S_fractb_28_o[21] Fractb_28_o[21] _NC1727 _NC1728 _NC1729 DFFX1
X816 Clk_i S_fracta_28_o[21] Fracta_28_o[21] _NC1730 _NC1731 _NC1732 DFFX1
X817 Clk_i S_fractb_28_o[20] Fractb_28_o[20] _NC1733 _NC1734 _NC1735 DFFX1
X818 Clk_i S_fracta_28_o[20] Fracta_28_o[20] _NC1736 _NC1737 _NC1738 DFFX1
X819 Clk_i S_fractb_28_o[19] Fractb_28_o[19] _NC1739 _NC1740 _NC1741 DFFX1
X820 Clk_i S_fracta_28_o[19] Fracta_28_o[19] _NC1742 _NC1743 _NC1744 DFFX1
X821 Clk_i S_fractb_28_o[18] Fractb_28_o[18] _NC1745 _NC1746 _NC1747 DFFX1
X822 Clk_i S_fracta_28_o[18] Fracta_28_o[18] _NC1748 _NC1749 _NC1750 DFFX1
X823 Clk_i S_fractb_28_o[17] Fractb_28_o[17] _NC1751 _NC1752 _NC1753 DFFX1
X824 Clk_i S_fracta_28_o[17] Fracta_28_o[17] _NC1754 _NC1755 _NC1756 DFFX1
X825 Clk_i S_fractb_28_o[16] Fractb_28_o[16] _NC1757 _NC1758 _NC1759 DFFX1
X826 Clk_i S_fracta_28_o[16] Fracta_28_o[16] _NC1760 _NC1761 _NC1762 DFFX1
X827 Clk_i S_fractb_28_o[15] Fractb_28_o[15] _NC1763 _NC1764 _NC1765 DFFX1
X828 Clk_i S_fracta_28_o[15] Fracta_28_o[15] _NC1766 _NC1767 _NC1768 DFFX1
X829 Clk_i S_fractb_28_o[14] Fractb_28_o[14] _NC1769 _NC1770 _NC1771 DFFX1
X830 Clk_i S_fracta_28_o[14] Fracta_28_o[14] _NC1772 _NC1773 _NC1774 DFFX1
X831 Clk_i S_fractb_28_o[13] Fractb_28_o[13] _NC1775 _NC1776 _NC1777 DFFX1
X832 Clk_i S_fracta_28_o[13] Fracta_28_o[13] _NC1778 _NC1779 _NC1780 DFFX1
X833 Clk_i S_fractb_28_o[12] Fractb_28_o[12] _NC1781 _NC1782 _NC1783 DFFX1
X834 Clk_i S_fracta_28_o[12] Fracta_28_o[12] _NC1784 _NC1785 _NC1786 DFFX1
X835 Clk_i S_fractb_28_o[11] Fractb_28_o[11] _NC1787 _NC1788 _NC1789 DFFX1
X836 Clk_i S_fracta_28_o[11] Fracta_28_o[11] _NC1790 _NC1791 _NC1792 DFFX1
X837 Clk_i S_fractb_28_o[10] Fractb_28_o[10] _NC1793 _NC1794 _NC1795 DFFX1
X838 Clk_i S_fracta_28_o[10] Fracta_28_o[10] _NC1796 _NC1797 _NC1798 DFFX1
X839 Clk_i S_fractb_28_o[9] Fractb_28_o[9] _NC1799 _NC1800 _NC1801 DFFX1
X840 Clk_i S_fracta_28_o[9] Fracta_28_o[9] _NC1802 _NC1803 _NC1804 DFFX1
X841 Clk_i S_fractb_28_o[8] Fractb_28_o[8] _NC1805 _NC1806 _NC1807 DFFX1
X842 Clk_i S_fracta_28_o[8] Fracta_28_o[8] _NC1808 _NC1809 _NC1810 DFFX1
X843 Clk_i S_fractb_28_o[7] Fractb_28_o[7] _NC1811 _NC1812 _NC1813 DFFX1
X844 Clk_i S_fracta_28_o[7] Fracta_28_o[7] _NC1814 _NC1815 _NC1816 DFFX1
X845 Clk_i S_fractb_28_o[6] Fractb_28_o[6] _NC1817 _NC1818 _NC1819 DFFX1
X846 Clk_i S_fracta_28_o[6] Fracta_28_o[6] _NC1820 _NC1821 _NC1822 DFFX1
X847 Clk_i S_fractb_28_o[5] Fractb_28_o[5] _NC1823 _NC1824 _NC1825 DFFX1
X848 Clk_i S_fracta_28_o[5] Fracta_28_o[5] _NC1826 _NC1827 _NC1828 DFFX1
X849 Clk_i S_fractb_28_o[4] Fractb_28_o[4] _NC1829 _NC1830 _NC1831 DFFX1
X850 Clk_i S_fracta_28_o[4] Fracta_28_o[4] _NC1832 _NC1833 _NC1834 DFFX1
X851 Clk_i S_fractb_28_o[3] Fractb_28_o[3] _NC1835 _NC1836 _NC1837 DFFX1
X852 Clk_i S_fracta_28_o[3] Fracta_28_o[3] _NC1838 _NC1839 _NC1840 DFFX1
X853 Clk_i N34 Fracta_28_o[2] _NC1841 S_fract_shr_28[1] Vdd _NC1842 _NC1843 DFFSSRX1
X854 Clk_i N48 Fractb_28_o[2] _NC1844 S_fract_shr_28[1] Vdd _NC1845 _NC1846 DFFSSRX1
X855 Clk_i N34 Fracta_28_o[1] _NC1847 S_fract_shr_28[0] Vdd _NC1848 _NC1849 DFFSSRX1
X856 Clk_i N48 Fractb_28_o[1] _NC1850 S_fract_shr_28[0] Vdd _NC1851 _NC1852 DFFSSRX1
X857 Clk_i N187 S_exp_diff[0] N12 _NC1853 _NC1854 DFFX1
X858 Clk_i N188 S_exp_diff[1] N13 _NC1855 _NC1856 DFFX1
X859 Clk_i N189 S_exp_diff[2] N14 _NC1857 _NC1858 DFFX1
X860 Clk_i N190 S_exp_diff[3] N11 _NC1859 _NC1860 DFFX1
X861 Clk_i N191 S_exp_diff[4] _NC1861 _NC1862 _NC1863 DFFX1
X862 Clk_i N192 S_exp_diff[5] _NC1864 _NC1865 _NC1866 DFFX1
X863 Clk_i N193 S_exp_diff[6] _NC1867 _NC1868 _NC1869 DFFX1
X864 Clk_i N194 S_exp_diff[7] _NC1870 _NC1871 _NC1872 DFFX1
X865 Clk_i S_exp_o[0] Exp_o[0] _NC1873 _NC1874 _NC1875 DFFX1
X866 Clk_i N124 S_exp_o[0] _NC1876 _NC1877 _NC1878 DFFX1
X867 Clk_i S_exp_o[1] Exp_o[1] _NC1879 _NC1880 _NC1881 DFFX1
X868 Clk_i N125 S_exp_o[1] _NC1882 _NC1883 _NC1884 DFFX1
X869 Clk_i S_exp_o[2] Exp_o[2] _NC1885 _NC1886 _NC1887 DFFX1
X870 Clk_i N126 S_exp_o[2] _NC1888 _NC1889 _NC1890 DFFX1
X871 Clk_i S_exp_o[3] Exp_o[3] _NC1891 _NC1892 _NC1893 DFFX1
X872 Clk_i N127 S_exp_o[3] _NC1894 _NC1895 _NC1896 DFFX1
X873 Clk_i S_exp_o[4] Exp_o[4] _NC1897 _NC1898 _NC1899 DFFX1
X874 Clk_i N128 S_exp_o[4] _NC1900 _NC1901 _NC1902 DFFX1
X875 Clk_i S_exp_o[5] Exp_o[5] _NC1903 _NC1904 _NC1905 DFFX1
X876 Clk_i N129 S_exp_o[5] _NC1906 _NC1907 _NC1908 DFFX1
X877 Clk_i S_exp_o[6] Exp_o[6] _NC1909 _NC1910 _NC1911 DFFX1
X878 Clk_i N130 S_exp_o[6] _NC1912 _NC1913 _NC1914 DFFX1
X879 Clk_i S_exp_o[7] Exp_o[7] _NC1915 _NC1916 _NC1917 DFFX1
X880 Clk_i N131 S_exp_o[7] _NC1918 _NC1919 _NC1920 DFFX1
.ENDS pre_norm_addsub

.SUBCKT pre_norm_addsub_DW01_sub_3 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] CO
X0 B[7] _NC0 _NC1 N3 INVX0
X1 B[6] _NC2 _NC3 N2 INVX0
X2 B[0] A[0] DIFF[0] _NC4 _NC5 XOR2X1
X3 B[4] _NC6 _NC7 N5 INVX0
X4 B[5] _NC8 _NC9 N4 INVX0
X5 A[0] _NC10 _NC11 N1 INVX0
X6 B[1] _NC12 _NC13 N8 INVX0
X7 N1 B[0] Carry[0] _NC14 _NC15 NAND2X1
X8 B[3] _NC16 _NC17 N6 INVX0
X9 B[2] _NC18 _NC19 N7 INVX0
X10 A[7] N3 Carry[6] DIFF[7] _NC20 _NC21 XOR3X1
X11 A[1] N8 Carry[0] Carry[1] DIFF[1] _NC22 _NC23 FADDX1
X12 A[2] N7 Carry[1] Carry[2] DIFF[2] _NC24 _NC25 FADDX1
X13 A[3] N6 Carry[2] Carry[3] DIFF[3] _NC26 _NC27 FADDX1
X14 A[4] N5 Carry[3] Carry[4] DIFF[4] _NC28 _NC29 FADDX1
X15 A[5] N4 Carry[4] Carry[5] DIFF[5] _NC30 _NC31 FADDX1
X16 A[6] N2 Carry[5] Carry[6] DIFF[6] _NC32 _NC33 FADDX1
.ENDS pre_norm_addsub_DW01_sub_3

.SUBCKT pre_norm_addsub_DW01_sub_2 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] CO
X0 B[7] _NC0 _NC1 N4 INVX0
X1 B[6] _NC2 _NC3 N3 INVX0
X2 B[0] _NC4 _NC5 N2 INVX0
X3 A[0] N2 DIFF[0] _NC6 _NC7 XOR2X1
X4 B[4] _NC8 _NC9 N6 INVX0
X5 B[5] _NC10 _NC11 N5 INVX0
X6 A[0] N2 N1 _NC12 _NC13 AND2X1
X7 B[3] _NC14 _NC15 N7 INVX0
X8 B[2] _NC16 _NC17 N8 INVX0
X9 B[1] _NC18 _NC19 N9 INVX0
X10 A[7] N4 Carry[5] DIFF[7] _NC20 _NC21 XOR3X1
X11 A[1] N9 N1 Carry[0] DIFF[1] _NC22 _NC23 FADDX1
X12 A[2] N8 Carry[0] Carry[1] DIFF[2] _NC24 _NC25 FADDX1
X13 A[3] N7 Carry[1] Carry[2] DIFF[3] _NC26 _NC27 FADDX1
X14 A[4] N6 Carry[2] Carry[3] DIFF[4] _NC28 _NC29 FADDX1
X15 A[5] N5 Carry[3] Carry[4] DIFF[5] _NC30 _NC31 FADDX1
X16 A[6] N3 Carry[4] Carry[5] DIFF[6] _NC32 _NC33 FADDX1
.ENDS pre_norm_addsub_DW01_sub_2

.SUBCKT pre_norm_addsub_DW01_sub_1 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] CO
X0 B[0] A[0] DIFF[0] _NC0 _NC1 XOR2X1
X1 B[7] _NC2 _NC3 N2 INVX0
X2 B[6] _NC4 _NC5 N3 INVX0
X3 B[5] _NC6 _NC7 N4 INVX0
X4 B[4] _NC8 _NC9 N5 INVX0
X5 A[0] _NC10 _NC11 N1 INVX0
X6 N1 B[0] Carry[0] _NC12 _NC13 NAND2X1
X7 B[1] _NC14 _NC15 N8 INVX0
X8 B[3] _NC16 _NC17 N6 INVX0
X9 B[2] _NC18 _NC19 N7 INVX0
X10 A[7] N2 Carry[6] DIFF[7] _NC20 _NC21 XOR3X1
X11 A[1] N8 Carry[0] Carry[1] DIFF[1] _NC22 _NC23 FADDX1
X12 A[2] N7 Carry[1] Carry[2] DIFF[2] _NC24 _NC25 FADDX1
X13 A[3] N6 Carry[2] Carry[3] DIFF[3] _NC26 _NC27 FADDX1
X14 A[4] N5 Carry[3] Carry[4] DIFF[4] _NC28 _NC29 FADDX1
X15 A[5] N4 Carry[4] Carry[5] DIFF[5] _NC30 _NC31 FADDX1
X16 A[6] N3 Carry[5] Carry[6] DIFF[6] _NC32 _NC33 FADDX1
.ENDS pre_norm_addsub_DW01_sub_1

.SUBCKT pre_norm_addsub_DW01_sub_0 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] CI DIFF[0] DIFF[1] DIFF[2] DIFF[3] DIFF[4] DIFF[5] DIFF[6] DIFF[7] CO
X0 A[0] N9 DIFF[0] _NC0 _NC1 XOR2X1
X1 B[7] _NC2 _NC3 N2 INVX0
X2 B[0] _NC4 _NC5 N9 INVX0
X3 B[6] _NC6 _NC7 N3 INVX0
X4 B[5] _NC8 _NC9 N4 INVX0
X5 B[4] _NC10 _NC11 N5 INVX0
X6 A[0] N9 N1 _NC12 _NC13 AND2X1
X7 B[3] _NC14 _NC15 N6 INVX0
X8 B[2] _NC16 _NC17 N7 INVX0
X9 B[1] _NC18 _NC19 N8 INVX0
X10 A[7] N2 Carry[5] DIFF[7] _NC20 _NC21 XOR3X1
X11 A[1] N8 N1 Carry[0] DIFF[1] _NC22 _NC23 FADDX1
X12 A[2] N7 Carry[0] Carry[1] DIFF[2] _NC24 _NC25 FADDX1
X13 A[3] N6 Carry[1] Carry[2] DIFF[3] _NC26 _NC27 FADDX1
X14 A[4] N5 Carry[2] Carry[3] DIFF[4] _NC28 _NC29 FADDX1
X15 A[5] N4 Carry[3] Carry[4] DIFF[5] _NC30 _NC31 FADDX1
X16 A[6] N3 Carry[4] Carry[5] DIFF[6] _NC32 _NC33 FADDX1
.ENDS pre_norm_addsub_DW01_sub_0

************************
* end of SPICE netlist *
************************
